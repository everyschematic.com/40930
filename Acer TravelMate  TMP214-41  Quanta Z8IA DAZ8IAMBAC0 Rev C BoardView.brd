# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A2: length 66.2
  IN4 w0.102: v2(46.53,139.09) 45.89,138.45 45.89,136.17 46.53,135.53 50.85,135.53 51.27,135.95 52.92,135.95 53.19,136.22 56.87,136.22 58.12,137.47 61.03,137.47 61.43,137.08 64.43,137.08 64.82,136.7 65.71,136.7 66.42,137.41 68.5,137.41 68.97,136.93 80.64,136.93 81.2,136.37 81.91,136.37 82.47,136.93 85.26,136.93 85.41,136.78 96.27,136.78 99.35,139.86 101.02,139.86 101.49,140.33 v1(102.99,140.33)
  BOTTOM w0.102: v1(102.99,140.33) 103.21,140.12 U6539.BV47
  BOTTOM w0.152: JDIM1.132 46.26,138.82 v2(46.53,139.09)
M_A_A3: length 64.2
  IN4 w0.102: v2(50.57,138.79) 53.94,138.79 54.49,139.34 56.18,139.34 57.96,141.12 73.2,141.12 74.72,139.6 75.43,139.6 75.53,139.7 75.53,140.2 75.64,140.31 75.84,140.31 75.94,140.2 75.94,139.7 76.04,139.6 76.25,139.6 76.35,139.7 76.35,140.2 76.45,140.31 76.65,140.31 76.75,140.2 76.75,139.7 76.85,139.6 77.06,139.6 77.16,139.7 77.16,140.2 77.26,140.31 77.46,140.31 77.57,140.2 77.57,139.7 77.67,139.6 77.87,139.6 77.97,139.7 77.97,140.2 78.07,140.31 78.28,140.31 78.38,140.2 78.38,139.7 78.48,139.6 78.68,139.6 78.79,139.7 78.79,140.2 78.89,140.31 79.09,140.31 79.19,140.2 79.19,139.7 79.29,139.6 79.5,139.6 79.6,139.7 79.6,140.2 79.7,140.31 79.9,140.31 80,140.2 80,139.7 80.11,139.6 80.31,139.6 80.41,139.7 80.41,140.2 80.51,140.31 80.72,140.31 80.82,140.2 80.82,139.7 80.92,139.6 85.48,139.6 86.69,138.38 89.08,138.38 v1(89.5,138.8)
  BOTTOM w0.102: 95.76,136.99 100.41,136.99 U6539.CD53
  BOTTOM w0.127: 93.64,137.18 93.84,136.99 95.76,136.99
  BOTTOM w0.152: 93.64,137.18 93.26,137.56 90.73,137.56 v1(89.5,138.8) ; v2(50.57,138.79) 50.85,139.07 JDIM1.131
M_A_A4: length 64.8
  IN4 w0.102: v1(88.85,138.79) 88.84,138.79 88.42,139.21 86.67,139.21 85.52,140.37 82.07,140.37 81.33,141.12 77.57,141.12 77.44,141.25 77.44,141.94 77.31,142.06 77.13,142.06 77.01,141.94 77.01,141.25 76.88,141.12 74.35,141.12 73.73,141.74 73.73,142.11 73.38,142.47 69.02,142.47 68.49,141.94 57.51,141.94 55.72,140.15 54.15,140.15 53.62,139.62 48.28,139.62 48.05,139.85 46.78,139.85 46.65,139.72 46.65,139.54 46.78,139.42 47.47,139.42 v2(47.8,139.09)
  BOTTOM w0.102: 95.76,136.67 99.89,136.67 100,136.78 100.85,136.78 101.14,137.07 U6539.CD51
  BOTTOM w0.127: 94.53,136.67 95.76,136.67
  BOTTOM w0.152: v1(88.85,138.79) 88.85,138.78 91.08,136.55 94.41,136.55 94.53,136.67 ; v2(47.8,139.09) 47.16,139.72 46.56,139.72 46.46,139.82 JDIM1.128
M_A_A5: length 67.5
  IN4 w0.102: v1(92.01,138.81) 92.73,138.81 93.39,139.47 93.39,139.85 93.02,140.23 87.22,140.23 85.65,141.79 83.19,141.79 82.24,142.74 78.93,142.74 77.59,144.09 75.02,144.09 74.21,144.9 66.62,144.9 65.91,144.19 65.71,144.19 65.61,144.29 65.61,144.8 65.51,144.9 65.3,144.9 65.2,144.8 65.2,143.66 65.1,143.56 64.9,143.56 64.8,143.66 64.8,144.8 64.69,144.9 62.5,144.9 62.32,145.08 58.04,145.08 56.21,143.25 54.91,143.25 52.93,141.27 48.71,141.27 48.31,140.87 46.94,140.87 v2(46.49,140.42)
  BOTTOM w0.102: 92.03,138.79 92.19,138.63 101.11,138.63 U6539.BY50
  BOTTOM w0.152: JDIM1.126 46.4,140.32 v2(46.49,140.42) ; v1(92.01,138.81) 92.03,138.79
M_A_A6: length 67.3
  IN4 w0.102: v1(92.76,139.72) 92.37,139.34 90.98,139.34 90.54,139.78 86.9,139.78 85.6,141.08 82.63,141.08 81.78,141.93 78.59,141.93 77.25,143.28 74.09,143.28 73.99,143.38 73.99,143.94 73.88,144.04 73.68,144.04 73.58,143.94 73.58,143.38 73.48,143.28 73.2,143.28 73.1,143.38 73.1,143.94 72.99,144.04 72.79,144.04 72.69,143.94 72.69,143.38 72.59,143.28 72.39,143.28 72.28,143.38 72.28,143.94 72.18,144.04 71.98,144.04 71.88,143.94 71.88,143.38 71.78,143.28 71.57,143.28 71.47,143.38 71.47,143.94 71.37,144.04 71.17,144.04 71.06,143.94 71.06,143.38 70.96,143.28 70.76,143.28 70.66,143.38 70.66,143.94 70.56,144.04 70.35,144.04 70.25,143.94 70.25,143.38 70.15,143.28 69.95,143.28 69.85,143.38 69.85,143.94 69.74,144.04 69.54,144.04 69.44,143.94 69.44,143.38 69.34,143.28 69.13,143.28 69.03,143.38 69.03,143.94 68.93,144.04 68.73,144.04 68.63,143.94 68.63,143.38 68.52,143.28 66.47,143.28 65.94,142.75 62.1,142.75 62,142.85 62,143.3 61.9,143.41 61.69,143.41 61.59,143.3 61.59,142.85 61.49,142.75 61.29,142.75 61.19,142.85 61.19,143.3 61.08,143.41 60.88,143.41 60.78,143.3 60.78,142.85 60.68,142.75 60.5,142.75 60.37,142.88 60.37,143.3 60.27,143.41 58.92,143.41 58.82,143.51 58.82,143.89 58.72,143.99 58.51,143.99 58.41,143.89 58.41,143.51 58.31,143.41 57.6,143.41 56.08,141.88 54.73,141.88 53.31,140.46 v2(51.63,140.46)
  BOTTOM w0.102: U6539.BY52 100.65,139 100.39,139.27 99.59,139.27 99.46,139.14 93.47,139.14 92.88,139.72 v1(92.76,139.72)
  BOTTOM w0.152: v2(51.63,140.46) 51.71,140.46 52.1,140.07 JDIM1.127
M_A_A7: length 67.3
  IN4 w0.102: v1(90.77,138.77) 90.77,138.9 90.12,139.55 86.72,139.55 85.55,140.73 82.35,140.73 81.55,141.53 78.43,141.53 77.44,142.52 76.75,142.52 76.5,142.26 76.5,141.63 76.4,141.53 76.2,141.53 76.09,141.63 76.09,142.77 75.99,142.87 75.79,142.87 75.69,142.77 75.69,141.63 75.59,141.53 75.38,141.53 75.28,141.63 75.28,142.77 75.18,142.87 74.98,142.87 74.87,142.77 74.87,141.63 74.77,141.53 74.57,141.53 74.14,141.96 74.14,142.28 73.54,142.87 68.85,142.87 68.33,142.34 57.15,142.34 56.18,141.37 54.8,141.37 53.45,140.03 49.27,140.03 v2(48.81,140.48)
  BOTTOM w0.102: U6539.CA50 101.54,138.1 100.02,138.1 99.73,138.39 95.7,138.39
  BOTTOM w0.127: 92.03,138.2 93.14,138.2 93.33,138.39 95.7,138.39
  BOTTOM w0.152: v2(48.81,140.48) 48.81,140.61 47.92,141.5 47.04,141.5 46.86,141.32 JDIM1.122 ; 92.03,138.2 91.29,138.2 90.79,138.7 90.79,138.75 v1(90.77,138.77)
M_A_A8: length 63.9
  IN4 w0.102: v2(50.29,140.56) 50.59,140.87 53.1,140.87 54.52,142.29 55.85,142.29 58.24,144.68 62.15,144.68 62.66,144.17 62.66,143.28 62.78,143.16 62.96,143.16 63.07,143.26 63.07,144.39 63.17,144.49 63.37,144.49 63.47,144.39 63.47,143.26 63.57,143.16 63.78,143.16 63.88,143.26 63.88,144.39 63.98,144.49 64.18,144.49 64.28,144.39 64.28,143.26 64.39,143.16 65.46,143.16 66.75,144.45 74.06,144.45 74.82,143.68 77.42,143.68 78.76,142.34 82.01,142.34 82.91,141.44 85.62,141.44 87.06,140 91.18,140 v1(91.44,139.74)
  BOTTOM w0.102: U6539.BY53 99.81,139 99.68,138.88 92.56,138.88 92.1,139.34 92.03,139.34
  BOTTOM w0.152: v2(50.29,140.56) 50.72,140.99 51.99,140.99 52.41,140.57 JDIM1.125 ; 92.03,139.34 91.84,139.34 v1(91.44,139.74)
M_A_A9: length 66.7
  IN4 w0.102: v2(50.39,142.9) 49.95,143.34 49.95,143.63 50.08,143.76 51.85,143.76 54.34,146.25 55.11,146.25 55.6,146.73 56.62,146.73 57.98,148.09 62.9,148.09 63.09,148.29 66.16,148.29 66.32,148.12 73.65,148.12 73.75,148.02 73.75,147.19 73.85,147.09 74.05,147.09 74.15,147.19 74.15,148.02 74.26,148.12 74.46,148.12 74.56,148.02 74.56,147.19 74.66,147.09 77.63,147.09 79.53,145.18 82.34,145.18 84.25,143.28 86.54,143.28 87.84,141.97 91.04,141.97 91.85,141.16 96.7,141.16 96.98,140.87 96.98,139.79 v1(96.74,139.55)
  BOTTOM w0.102: v1(96.74,139.55) 96.8,139.49 97.11,139.49 97.21,139.59 100.22,139.59 100.63,140 101.04,140 101.31,140.28 U6539.BU50
  BOTTOM w0.152: JDIM1.121 52.09,141.57 51.84,141.33 50.28,141.33 50.13,141.48 50.13,141.67 50.39,141.93 v2(50.39,142.9)
M_A_A10: length 66
  IN4 w0.102: v1(104.95,140.33) 104.02,139.41 102.66,139.41 102.46,139.22 99.47,139.22 99.23,138.98 96.55,136.3 82.85,136.3 82.11,135.56 77.89,135.56 77.79,135.66 77.79,136.02 77.69,136.12 77.49,136.12 77.39,136.02 77.39,135.66 77.29,135.56 77.08,135.56 76.98,135.66 76.98,136.02 76.88,136.12 76.68,136.12 76.57,136.02 76.57,135.66 76.47,135.56 76.27,135.56 76.17,135.66 76.17,136.02 76.07,136.12 68.84,136.12 68.47,135.76 59.46,135.76 59.23,135.53 57.45,135.53 57.26,135.34 53.77,135.34 53.56,135.14 51.72,135.14 51.26,134.68 49.5,134.68 48.55,133.73 v2(48.53,133.73)
  BOTTOM w0.102: U6539.BV42 105.16,140.05 105.08,140.13 v1(104.95,140.33)
  BOTTOM w0.152: JDIM1.146 46.12,133.32 46.93,134.13 48.12,134.13 v2(48.53,133.73)
M_A_A11: length 66.4
  IN4 w0.102: v1(90.74,140.64) 90.37,141.02 86.8,141.02 85.69,142.14 83.48,142.14 82.47,143.15 79.1,143.15 77.75,144.5 77.13,144.5 77.01,144.62 77.01,145.24 76.88,145.37 76.56,145.37 76.46,145.27 76.46,144.6 76.36,144.5 76.16,144.5 76.05,144.6 76.05,145.27 75.95,145.37 75.75,145.37 75.65,145.27 75.65,144.6 75.55,144.5 75.34,144.5 75.24,144.6 75.24,145.27 75.14,145.37 64.63,145.37 64.19,145.81 63.63,145.81 63.53,145.71 63.53,145.43 63.4,145.31 62.79,145.31 62.53,145.56 57.86,145.56 56.36,144.06 54.45,144.06 53.89,143.5 53.89,142.9 52.67,141.68 48.04,141.68 47.63,141.27 45.87,141.27 45.77,141.37 45.77,141.75 45.95,141.94 v2(46.41,141.94)
  BOTTOM w0.102: U6539.BT51 100.85,141.23 99.86,141.23 99.61,140.98 95.39,140.98 95.14,140.73 92.12,140.73 92.03,140.64
  BOTTOM w0.152: v2(46.41,141.94) 46.29,141.82 JDIM1.120 ; v1(90.74,140.64) 92.03,140.64
M_A_A12: length 66.2
  IN4 w0.102: v2(51.71,142.9) 51.71,143.05 54.38,145.72 56.18,145.72 57.32,146.86 57.73,146.86 57.95,147.08 57.95,147.48 58.15,147.68 63.06,147.68 63.26,147.88 64.45,147.88 64.58,147.75 64.58,147.16 64.71,147.03 64.93,147.03 65.03,147.13 65.03,147.73 65.13,147.84 65.66,147.84 65.76,147.73 65.76,147.32 65.86,147.22 68.39,147.22 68.5,147.32 68.5,147.61 68.6,147.72 68.8,147.72 68.9,147.61 68.9,147.32 69,147.22 69.21,147.22 69.31,147.32 69.31,147.61 69.41,147.72 69.61,147.72 69.72,147.61 69.72,147.34 69.84,147.22 70.06,147.22 70.15,147.31 70.15,147.61 70.25,147.72 70.5,147.72 70.62,147.59 70.62,146.76 70.71,146.67 71.03,146.67 71.13,146.77 71.13,147.61 71.23,147.72 71.44,147.72 71.54,147.61 71.54,146.77 71.64,146.67 71.84,146.67 71.94,146.77 71.94,147.61 72.05,147.72 72.25,147.72 72.35,147.61 72.35,146.77 72.45,146.67 72.73,146.67 72.83,146.77 72.83,147.61 72.93,147.72 73.14,147.72 73.24,147.61 73.24,146.77 73.34,146.67 77.47,146.67 79.4,144.74 82.33,144.74 84.04,143.02 86.27,143.02 87.56,141.73 90.98,141.73 91.76,140.95 95.86,140.95 96.48,140.33 v1(96.49,140.33)
  BOTTOM w0.102: v1(96.49,140.33) 96.55,140.33 96.6,140.38 100.09,140.38 U6539.BU53
  BOTTOM w0.152: v2(51.71,142.9) 51.71,142.2 51.84,142.07 JDIM1.119
M_A_A13: length 66.1
  IN4 w0.102: v2(47.29,130.2) 47.38,130.2 48.12,129.46 53.73,129.46 53.91,129.28 57.35,129.28 57.87,128.76 64.47,128.76 65.78,130.07 68.63,130.07 69.9,131.34 74.67,131.34 74.78,131.24 74.78,130.99 74.88,130.88 75.08,130.88 75.18,130.99 75.18,131.24 75.28,131.34 75.57,131.34 76.03,130.88 82.29,130.88 85.33,133.93 98.01,133.93 100.1,136.02 102.09,136.02 102.22,135.88 103.74,135.88 104.11,136.25 105.19,136.25 v1(105.62,136.67)
  BOTTOM w0.102: U6539.CF41 105.81,136.48 v1(105.62,136.67)
  BOTTOM w0.152: JDIM1.158 47.16,130.32 v2(47.29,130.2)
M_A_ACT#: length 66
  IN4 w0.102: v1(94.02,139.76) 94.43,139.34 95.42,139.34 95.68,139.6 95.68,139.98 94.91,140.74 91.69,140.74 90.94,141.48 87.3,141.48 86.01,142.77 83.87,142.77 82.43,144.21 79.25,144.21 77.2,146.26 70.09,146.26 69.98,146.36 69.98,146.61 69.87,146.72 69.69,146.72 69.58,146.61 69.58,146.36 69.48,146.26 69.26,146.26 69.13,146.39 69.13,146.63 69.01,146.76 65.25,146.76 65.12,146.63 63.21,146.63 63.04,146.45 57.49,146.45 56.32,145.28 55.37,145.28 54.99,144.9 54.14,144.9 52.5,143.26 52.5,142.87 52.12,142.49 49.45,142.49 v2(49.04,142.9)
  BOTTOM w0.102: v1(94.02,139.76) 94.53,140.27 95.2,140.27 95.64,140.71 99.89,140.71 100.09,140.91 U6539.BT53
  BOTTOM w0.152: JDIM1.114 46.83,143.32 47.04,143.53 48.41,143.53 v2(49.04,142.9)
M_A_ALERT#: length 70.7
  IN4 w0.102: v1(96.07,149.2) 96.07,147.83 96.69,147.22 96.69,145.95 97.58,145.06 97.58,143.66 95.28,141.36 92.01,141.36 91.18,142.19 87.92,142.19 86.57,143.53 84.45,143.53 82.29,145.69 79.6,145.69 77.8,147.5 75.79,147.5 74.59,148.69 62.92,148.69 62.73,148.5 57.81,148.5 56.45,147.14 55.42,147.14 54.99,146.71 54.21,146.71 51.67,144.17 48.56,144.17 v2(47.42,143.02)
  BOTTOM w0.089: U6539.AU50 101.21,149.21 100.92,149.5 100.5,149.5 100.5,149.5 99.13,149.5
  BOTTOM w0.102: 99.13,149.5 96.39,149.5 96.09,149.2 v1(96.07,149.2)
  BOTTOM w0.152: JDIM1.116 47.22,142.82 v2(47.42,143.02)
M_A_BG#0: length 68.2
  IN4 w0.102: v1(93.44,141.79) 92.59,142.64 88.18,142.64 86.28,144.55 84.7,144.55 82.55,146.71 79.8,146.71 78.12,148.39 76.05,148.39 75.48,148.96 75.48,149.88 75.37,149.98 75.17,149.98 75.07,149.88 75.07,149.61 74.97,149.5 74.77,149.5 74.66,149.61 74.66,149.88 74.56,149.98 74.36,149.98 74.26,149.88 74.26,149.61 74.16,149.5 73.95,149.5 73.85,149.61 73.85,149.88 73.75,149.98 60.33,149.98 59.92,149.57 59.69,149.57 59.29,149.97 58.14,149.97 57.84,149.67 57.65,149.67 57.44,149.88 57.15,149.88 57.02,149.76 57.02,149.58 57.28,149.31 57.28,149.12 57.16,148.99 57.01,148.99 56.44,149.56 56.33,149.56 56.13,149.36 56.13,149.22 56.68,148.67 56.68,148.51 56.47,148.31 56.31,148.31 55.81,148.81 54.35,148.81 52.62,147.09 52.62,146.45 52.12,145.95 51.68,145.95 51.3,145.56 50.21,145.56 v2(49.45,144.8)
  BOTTOM w0.102: U6539.BL52 100.58,142.57 100.15,142.57 99.15,141.57 95.06,141.57 94.78,141.29 94.52,141.29
  BOTTOM w0.127: 94.52,141.29 93.9,141.29 93.44,141.75 v1(93.44,141.79)
  BOTTOM w0.152: v2(49.45,144.8) 50.08,144.17 51.23,144.17 52.32,143.07 JDIM1.115
M_A_BG#1: length 69.3
  IN4 w0.102: v2(51.08,144.73) 51.65,144.73 53.13,146.21 53.13,146.71 54.4,147.97 56.07,147.97 56.28,147.77 56.51,147.77 58.3,149.56 59.13,149.56 59.69,149 59.79,148.9 60.33,148.9 60.43,149.01 60.43,149.4 60.54,149.5 60.74,149.5 60.84,149.4 60.84,149 60.93,148.9 61.18,148.9 61.25,148.97 61.25,149.4 61.35,149.5 61.55,149.5 61.65,149.4 61.65,148.98 61.73,148.9 61.99,148.9 62.06,148.97 62.06,149.4 62.16,149.5 62.36,149.5 62.47,149.4 62.47,149.2 62.57,149.1 62.77,149.1 62.87,149.2 62.87,149.4 62.97,149.5 63.18,149.5 63.28,149.4 63.28,149.2 63.38,149.1 63.58,149.1 63.68,149.2 63.68,149.4 63.79,149.5 63.99,149.5 64.09,149.4 64.09,149.2 64.19,149.1 64.4,149.1 64.5,149.2 64.5,149.41 64.59,149.5 64.79,149.5 64.9,149.39 64.9,149.2 65.01,149.1 65.41,149.1 65.87,149.55 67.94,149.55 68.39,149.1 68.8,149.1 68.9,149.2 68.9,149.48 69,149.58 69.21,149.58 69.31,149.48 69.31,149.2 69.41,149.1 69.61,149.1 69.71,149.2 69.71,149.48 69.82,149.58 70.02,149.58 70.12,149.48 70.12,149.2 70.22,149.1 70.43,149.1 70.53,149.2 70.53,149.48 70.63,149.58 70.83,149.58 70.93,149.48 70.93,149.2 71.04,149.1 71.24,149.1 71.34,149.2 71.34,149.48 71.44,149.58 71.65,149.58 71.75,149.48 71.75,149.2 71.85,149.1 72.05,149.1 72.15,149.2 72.15,149.48 72.25,149.58 72.46,149.58 72.56,149.48 72.56,149.2 72.66,149.1 72.86,149.1 72.97,149.2 72.97,149.48 73.07,149.58 73.27,149.58 73.37,149.48 73.37,149.2 73.47,149.1 74.76,149.1 75.88,147.98 77.9,147.98 79.68,146.2 82.57,146.2 84.73,144.04 86.41,144.04 88.06,142.39 91.54,142.39 v1(92.18,141.74)
  BOTTOM w0.102: U6539.BN50 101.5,141.88 99.89,141.88 99.31,141.3 95.19,141.3 94.9,141.01 94.8,141.01
  BOTTOM w0.127: v1(92.18,141.74) 92.18,141.58 92.76,141.01 94.8,141.01
  BOTTOM w0.152: v2(51.08,144.73) 52.23,143.57 JDIM1.113
M_A_BS#0: length 66.8
  IN4 w0.102: v2(47.16,133.63) 48.62,135.09 51.04,135.09 51.5,135.55 53.09,135.55 53.36,135.82 57.1,135.82 58.34,137.06 60.88,137.06 61.26,136.67 64.18,136.67 64.56,136.29 65.96,136.29 66.59,136.93 68.37,136.93 68.77,136.53 78.33,136.53 78.43,136.43 78.43,136.06 78.53,135.96 78.74,135.96 78.84,136.06 78.84,136.43 78.94,136.53 79.14,136.53 79.24,136.43 79.24,136.06 79.35,135.96 79.55,135.96 79.65,136.06 79.65,136.43 79.75,136.53 79.95,136.53 80.06,136.43 80.06,136.06 80.16,135.96 82.01,135.96 82.55,136.5 96.36,136.5 99.4,139.54 101.08,139.54 101.6,140.05 102.24,140.05 102.52,139.77 103.74,139.77 v1(104.29,140.33)
  BOTTOM w0.102: U6539.BV44 104.51,140.05 104.43,140.13 v1(104.29,140.33)
  BOTTOM w0.152: v2(47.16,133.63) 47.16,133.37 46.11,132.32 JDIM1.150
M_A_BS#1: length 65.1
  IN4 w0.102: v1(104.95,138.5) 104.95,138.8 104.85,138.9 102.81,138.9 102.56,138.66 99.73,138.66 99.64,138.57 96.89,135.81 83.39,135.81 82.22,134.64 75.35,134.64 75.24,134.74 75.24,135.15 75.14,135.25 74.74,135.25 74.63,135.15 74.63,134.74 74.53,134.64 74.33,134.64 74.23,134.74 74.23,135.15 74.13,135.25 73.92,135.25 73.82,135.15 73.82,134.74 73.72,134.64 73.52,134.64 73.42,134.74 73.42,135.15 73.31,135.25 73.11,135.25 73.01,135.15 73.01,134.74 72.91,134.64 72.7,134.64 72.6,134.74 72.6,135.15 72.5,135.25 69.24,135.25 68.93,134.95 61.89,134.95 61.29,134.35 58.56,134.35 57.93,133.73 54.12,133.73 53.95,133.56 v2(50.08,133.56)
  BOTTOM w0.102: v1(104.95,138.5) 105.16,138.29 U6539.CB42
  BOTTOM w0.152: JDIM1.145 52.43,133.57 52.17,133.84 50.91,133.84 50.63,133.56 v2(50.08,133.56)
M_A_CAS#: length 65.5
  IN4 w0.102: v1(104.29,138.5) 103.88,138.09 99.93,138.09 98.72,136.88 97.19,135.36 83.82,135.36 82.29,133.83 70.18,133.83 69.88,134.13 65.27,134.13 64.51,133.37 62.2,133.37 61.77,132.94 60.57,132.94 60.12,132.48 58.78,132.48 58.35,132.91 54.83,132.91 54.66,132.74 50.8,132.74 50.04,131.98 48.43,131.98 47.8,132.61 47.16,132.61 47.04,132.48 47.04,132.1 v2(47.67,131.47)
  BOTTOM w0.102: U6539.CB44 104.51,138.29 v1(104.29,138.5)
  BOTTOM w0.152: v2(47.67,131.47) 47.29,131.47 46.65,130.82 JDIM1.156
M_A_CB0: length 1.9
  TOP w0.114: v2(46.41,149.06) 46.45,149.02 R233.2
  BOTTOM w0.114: v2(46.41,149.06) 46.17,148.82 JDIM1.92
M_A_CB1: length 3.6
  TOP w0.114: v2(50.73,149.53) 50.29,149.97 R234.2
  BOTTOM w0.114: v2(50.73,149.53) 51.18,149.07 JDIM1.91
M_A_CB2: length 2
  TOP w0.114: R235.2 52.08,146.6 v2(52.05,146.57)
  BOTTOM w0.114: JDIM1.101 v2(52.05,146.57)
M_A_CB3: length 3.4
  TOP w0.114: R236.2 51.46,145.85 v2(51.18,146.12)
  BOTTOM w0.114: JDIM1.105 52.33,145.57 52.08,145.82 51.48,145.82 v2(51.18,146.12)
M_A_CB4: length 2
  TOP w0.114: R237.2 46.45,149.78 v2(46.41,149.82)
  BOTTOM w0.114: JDIM1.88 v2(46.41,149.82)
M_A_CB5: length 3.8
  TOP w0.114: R238.2 50.34,149.03 51,149.03 51.39,149.42 v2(51.39,149.59)
  BOTTOM w0.114: v2(51.39,149.59) 51.88,150.07 JDIM1.87
M_A_CB6: length 2.4
  TOP w0.114: R239.2 46.99,146.79 v2(46.96,146.82)
  BOTTOM w0.114: JDIM1.100 v2(46.96,146.82)
M_A_CB7: length 2.6
  TOP w0.114: R240.2 47.62,145.98 v2(46.96,145.98)
  BOTTOM w0.114: JDIM1.104 46.13,145.82 46.28,145.98 v2(46.96,145.98)
M_A_CKE0: length 69.3
  IN4 w0.102: v2(49.7,146.07) 48.18,146.07 47.92,146.33 47.92,147.34 48.18,147.6 49.97,147.6 50.08,147.49 50.08,146.81 50.18,146.71 50.38,146.71 50.48,146.81 50.48,147.49 50.58,147.6 50.79,147.6 50.89,147.49 50.89,146.81 50.99,146.71 51.19,146.71 51.3,146.81 51.3,147.49 51.4,147.6 52.46,147.6 54.98,150.12 56.53,150.12 56.8,150.39 76.75,150.39 79.93,147.21 82.53,147.21 84.81,144.93 86.28,144.93 88.31,142.9 93.59,142.9 v1(94.71,141.78)
  BOTTOM w0.102: v1(94.71,141.78) 94.85,141.92 98.85,141.92 100.06,143.13 101.19,143.13 U6539.BL50
  BOTTOM w0.152: v2(49.7,146.07) 50.59,145.18 51.24,145.18 51.85,144.57 JDIM1.109
M_A_CKE1: length 65.1
  IN4 w0.102: v1(95.26,139.78) 94.55,140.48 91.46,140.48 90.68,141.26 87.02,141.26 85.87,142.41 83.71,142.41 82.47,143.66 79.17,143.66 77.01,145.82 68.88,145.82 68.35,146.35 66.29,146.35 66.18,146.25 66.18,145.88 66.08,145.78 65.88,145.78 65.78,145.88 65.78,146.22 65.68,146.33 65.47,146.33 65.37,146.22 65.37,145.89 65.26,145.78 64.86,145.78 64.41,146.22 63.46,146.22 63.21,145.97 57.64,145.97 56.14,144.47 54.28,144.47 53,143.19 53,142.64 52.45,142.08 47.72,142.08 46.78,143.02 46.78,143.41 v2(47.67,144.29)
  BOTTOM w0.102: U6539.BU52 100.62,140.28 100.27,139.93 95.4,139.93 95.26,139.79 v1(95.26,139.78)
  BOTTOM w0.152: JDIM1.110 47.64,144.32 v2(47.67,144.29)
M_A_CLKN0: length 65.1
  IN4 w0.089: v1(94.91,137.97) 94.69,137.76 94.69,137.49 94.46,137.26 92.81,137.26 92.68,137.39 85.95,137.39 85.39,137.95 72.69,137.95 72.31,138.32 72.31,139.17 72.18,139.3 71.82,139.3 71.69,139.17 71.69,138.3 71.46,138.07 70.89,138.07 70.66,138.3 70.66,139.16 70.53,139.29 70.14,139.29 70.05,139.2 70.05,138.26 69.86,138.07 69.26,138.07 69.07,138.26 69.07,139.2 68.98,139.29 68.7,139.29 68.32,138.91 66.54,138.91 66.12,138.49 65.63,138.49 65.44,138.68 65.44,139.13 65.35,139.21 64.9,139.21 64.81,139.13 64.81,138.68 64.62,138.49 57.61,138.49 56.36,137.23 52.55,137.23 52.34,137.02 49.8,137.02 49.45,136.67 49.45,136.47 49.75,136.17 v2(50.08,136.17)
  BOTTOM w0.114: v1(94.91,137.97) 94.73,137.79 94.73,137.64 94.83,137.53 100,137.53 U6539.CC53 ; JDIM1.139 52.33,137.07 52.19,136.93 49.83,136.93 49.7,136.8 49.7,136.55 v2(50.08,136.17)
M_A_CLKN1: length 66.9
  IN4 w0.089: v1(105.6,141.25) 105.38,141.46 105.38,141.6 105.15,141.83 99.57,141.83 96.62,138.88 93.44,138.88 92.68,138.12 86.25,138.12 85.46,138.92 74.25,138.92 72.89,140.28 64.23,140.28 63.93,139.98 57.71,139.98 55.92,138.19 48.04,138.19 47.08,137.22 47.08,136.93 v2(46.55,136.4)
  BOTTOM w0.102: U6539.BT41 105.81,141.03 v1(105.6,141.25)
  BOTTOM w0.114: v2(46.55,136.4) 46.91,136.4 47.04,136.53 47.04,136.73 46.84,136.92 46.22,136.92 46.12,136.82 JDIM1.140
M_A_CLKP0: length 65.3
  IN4 w0.089: v2(49.07,136.93) 49.45,136.93 49.72,137.2 52.26,137.2 52.47,137.41 56.28,137.41 57.54,138.66 64.55,138.66 64.64,138.75 64.64,139.2 64.83,139.39 65.42,139.39 65.61,139.2 65.61,138.75 65.7,138.66 66.05,138.66 66.47,139.09 68.24,139.09 68.63,139.47 69.06,139.47 69.25,139.28 69.25,138.34 69.34,138.25 69.78,138.25 69.87,138.34 69.87,139.28 70.06,139.47 70.6,139.47 70.84,139.24 70.84,138.38 70.96,138.25 71.38,138.25 71.51,138.38 71.51,139.24 71.74,139.47 72.26,139.47 72.49,139.24 72.49,138.4 72.76,138.12 85.46,138.12 86.02,137.56 92.76,137.56 92.88,137.44 94.39,137.44 94.52,137.56 94.52,137.76 v1(94.3,137.97)
  BOTTOM w0.114: U6539.CC52 100.52,137.41 100.2,137.41 100.09,137.31 94.73,137.31 94.5,137.54 94.5,137.77 v1(94.3,137.97) ; JDIM1.137 52.44,137.57 52.18,137.31 52.18,137.25 52.09,137.16 49.74,137.16 49.51,136.93 v2(49.07,136.93)
M_A_CLKP1: length 66.9
  IN4 w0.089: v2(47.82,136.4) 47.26,136.96 47.26,137.15 48.12,138.01 55.99,138.01 57.78,139.8 64,139.8 64.31,140.1 72.82,140.1 74.18,138.74 85.38,138.74 86.18,137.94 92.76,137.94 93.52,138.71 96.69,138.71 99.64,141.65 105.07,141.65 105.2,141.53 105.2,141.37 105.08,141.25 v1(104.95,141.25)
  BOTTOM w0.102: U6539.BT42 105.16,141.03 v1(104.95,141.25)
  BOTTOM w0.114: JDIM1.138 46.07,137.32 46.24,137.15 46.94,137.15 47.26,136.83 47.26,136.57 47.44,136.4 v2(47.82,136.4)
M_A_CS#0: length 64
  IN4 w0.102: v1(102.84,136.7) 102.55,136.7 102.37,136.88 99.86,136.88 97.6,134.62 84.78,134.62 82.75,132.58 69.54,132.58 69.23,132.9 68.47,132.9 68.37,132.8 68.37,132.1 68.12,131.85 66.47,131.85 66.21,131.59 65.58,131.59 64.67,130.68 61.03,130.68 60.93,130.78 60.93,131.01 60.83,131.11 60.62,131.11 60.52,131.01 60.52,130.78 60.42,130.68 58.44,130.68 58.02,131.11 56.33,131.11 55.74,130.51 54.44,130.51 54.03,130.92 50.99,130.92 50.7,130.64 49.63,130.64 v2(49.17,131.1)
  BOTTOM w0.102: U6539.CF47 103.21,136.25 102.84,136.62 v1(102.84,136.7)
  BOTTOM w0.152: JDIM1.149 50.46,132.57 49.17,131.28 v2(49.17,131.1)
M_A_CS#1: length 64.9
  IN4 w0.102: v1(104.97,136.67) 104.59,137.05 104.15,137.05 103.91,136.81 103.91,136.62 103.6,136.31 102.44,136.31 102.2,136.56 99.92,136.56 99.48,136.12 97.75,134.38 84.93,134.38 82.72,132.18 82.12,132.18 82.02,132.08 82.02,131.82 81.92,131.72 81.72,131.72 81.62,131.82 81.62,132.08 81.51,132.18 69.08,132.18 68.63,131.72 68.63,131.21 68.3,130.88 65.44,130.88 64.83,130.28 58.29,130.28 58.12,130.1 57.8,130.1 57.69,130.2 57.69,130.6 57.59,130.7 57.39,130.7 57.29,130.6 57.29,130.2 57.19,130.1 56.98,130.1 56.88,130.2 56.88,130.6 56.78,130.7 56.58,130.7 56.48,130.6 56.48,130.2 56.37,130.1 54.24,130.1 53.83,130.52 51.16,130.52 50.52,129.87 v2(50.47,129.87)
  BOTTOM w0.102: v1(104.97,136.67) 105.16,136.48 U6539.CF42
  BOTTOM w0.152: v2(50.47,129.87) 51.17,130.57 JDIM1.157
M_A_DIM0_ODT0: length 64.8
  IN4 w0.102: v2(50.59,131.21) 50.71,131.33 55.12,131.33 55.49,131.7 56.08,131.7 56.26,131.52 64.76,131.52 65.15,131.91 65.15,132.56 65.32,132.74 65.58,132.74 65.7,132.61 65.7,132.24 65.83,132.12 66.09,132.12 66.21,132.24 66.21,133.12 66.34,133.25 66.54,133.25 66.66,133.12 66.66,132.36 66.76,132.25 66.97,132.25 67.07,132.36 67.07,133.22 67.17,133.32 67.37,133.32 67.48,133.22 67.48,132.36 67.58,132.25 67.78,132.25 67.88,132.36 67.88,133.22 67.98,133.32 69.44,133.32 69.77,132.99 82.34,132.99 84.2,134.85 97.45,134.85 99.1,136.5 99.86,137.26 102.37,137.26 102.54,137.09 103.15,137.09 103.48,136.76 v1(103.48,136.73)
  BOTTOM w0.102: v1(103.48,136.73) 103.48,136.61 U6539.CF45
  BOTTOM w0.152: v2(50.59,131.21) 50.73,131.07 JDIM1.155
M_A_DIM0_ODT1: length 63.7
  IN4 w0.102: v1(104.31,136.67) 104.25,136.67 103.67,136.1 102.34,136.1 102.16,136.27 100.01,136.27 97.9,134.15 85.08,134.15 82.24,131.31 81.17,131.31 81.07,131.42 81.07,131.64 80.94,131.77 80.67,131.77 80.56,131.67 80.56,131.39 80.46,131.29 80.26,131.29 80.16,131.39 80.16,131.67 80.06,131.77 79.85,131.77 79.75,131.67 79.75,131.39 79.65,131.29 79.45,131.29 79.34,131.39 79.34,131.67 79.24,131.77 79.04,131.77 78.94,131.67 78.94,131.39 78.84,131.29 78.63,131.29 78.53,131.39 78.53,131.67 78.43,131.77 78.23,131.77 78.13,131.67 78.13,131.39 78.02,131.29 77.82,131.29 77.72,131.39 77.72,131.67 77.62,131.77 77.41,131.77 77.31,131.67 77.31,131.39 77.21,131.29 77.01,131.29 76.91,131.39 76.91,131.67 76.8,131.77 76.6,131.77 76.5,131.67 76.5,131.39 76.4,131.29 76.2,131.29 76.09,131.39 76.09,131.67 75.99,131.77 69.25,131.77 69.03,131.55 69.03,131.04 68.46,130.48 65.61,130.48 64.95,129.82 64.43,129.82 64.31,129.69 64.31,129.3 64.18,129.17 58.1,129.17 57.58,129.69 54.08,129.69 53.8,129.97 v2(51.89,129.97)
  BOTTOM w0.102: v1(104.31,136.67) 104.41,136.67 104.63,136.46 104.63,136.34 U6539.CF44
  BOTTOM w0.152: JDIM1.161 52.28,129.57 v2(51.89,129.97)
M_A_DQ0: length 64.7
  IN4 w0.089: v1(91.24,130.58) 91.24,130.07 89.78,128.62 86.99,128.62 81.63,123.26 80.23,123.26 80.12,123.15 73.9,123.15 71.81,121.07 68.2,121.07 66.21,119.08 57.14,119.08 56.18,120.04 55.71,120.04 55.62,119.95 55.62,119.69 55.53,119.61 54.33,119.61 53.93,120 50.61,120 v2(49.57,118.96)
  BOTTOM w0.079: 98.55,132 98.91,132 99.31,132.39 99.76,132.39 99.86,132.29 101.93,132.29 102.14,132.08 U6539.CU49
  BOTTOM w0.102: 98.55,132 98.08,132 97.04,130.96 91.62,130.96 v1(91.24,130.58)
  BOTTOM w0.114: JDIM1.203 52.45,119.07 52.12,119.4 49.96,119.4 49.57,119.01 v2(49.57,118.96)
M_A_DQ1: length 63.7
  IN4 w0.089: v1(93.56,129.56) 93.18,129.18 92.37,129.18 91.94,128.74 91.12,128.74 90.34,127.96 87.73,127.96 84.12,124.36 84.12,123.72 83.87,123.47 82.98,123.47 81.66,122.15 81.15,122.15 81,121.99 77.21,121.99 76.72,121.5 73.73,121.5 72.1,119.87 69.73,119.87 67.4,117.54 67.07,117.54 66.97,117.64 66.97,117.87 66.85,118 66.55,118 66.09,117.54 57.03,117.54 56.45,118.11 48.77,118.11 48.54,117.88 47.54,117.88 v2(47.09,118.32)
  BOTTOM w0.102: U6539.CU50 101.28,131.35 101.02,131.09 100.68,131.09 100.33,130.73 98.5,130.73 97.33,129.56 v1(93.56,129.56)
  BOTTOM w0.114: JDIM1.204 46.59,118.82 v2(47.09,118.32)
M_A_DQ2: length 63
  IN4 w0.089: v1(92.94,129.61) 92.94,130.45 92.82,130.58 92.12,130.58 89.96,128.42 87.17,128.42 81.61,122.86 80.84,122.86 80.79,122.81 74.06,122.81 71.98,120.72 68.34,120.72 68.1,120.48 68.1,120.35 68.46,120 68.46,119.87 68.27,119.68 68.14,119.68 67.78,120.04 67.66,120.04 67.47,119.85 67.47,119.73 67.83,119.37 67.83,119.24 67.64,119.05 67.51,119.05 67.16,119.41 67.03,119.41 66.35,118.74 56.97,118.74 56.45,119.26 54.16,119.26 53.77,119.66 53.32,119.66 53.23,119.57 53.23,118.98 53.15,118.89 52.88,118.89 52.79,118.98 52.79,119.57 52.7,119.66 51.49,119.66 51.36,119.53 v2(51.36,118.94)
  BOTTOM w0.102: v1(92.94,129.61) 92.94,129.62 93.26,129.94 97.42,129.94 98.4,130.93 100.22,130.93 100.64,131.35 U6539.CU52
  BOTTOM w0.114: v2(51.36,118.94) 52.23,118.07 JDIM1.207
M_A_DQ3: length 62.6
  IN4 w0.089: v1(92.33,129.61) 91.78,129.05 90.92,129.05 90.04,128.17 87.29,128.17 81.62,122.49 80.98,122.49 80.84,122.35 77.07,122.35 76.57,121.85 73.59,121.85 72.12,120.38 68.97,120.38 68.88,120.29 68.88,119.66 67.62,118.39 66.07,118.39 65.98,118.3 65.98,118.09 65.89,118.01 65.63,118.01 65.54,118.09 65.54,118.3 65.45,118.39 65.18,118.39 65.09,118.3 65.09,118.09 65,118.01 64.74,118.01 64.65,118.09 64.65,118.3 64.56,118.39 56.81,118.39 56.28,118.92 53.92,118.92 53.48,118.48 48.5,118.48 v2(48.44,118.42)
  BOTTOM w0.102: U6539.CU53 100,131.16 98.18,131.16 97.22,130.2 92.88,130.2 92.33,129.65 v1(92.33,129.61)
  BOTTOM w0.114: JDIM1.208 47.84,117.82 v2(48.44,118.42)
M_A_DQ4: length 65.1
  IN4 w0.089: v2(47.09,121.88) 48.24,123.03 57.5,123.03 58.17,122.36 60.54,122.36 60.65,122.47 65.35,122.47 66.47,123.59 66.72,123.59 66.97,123.34 67.23,123.34 67.36,123.47 67.36,123.72 67.48,123.85 70.78,123.85 70.91,123.97 70.91,124.36 71.98,125.42 79.09,125.42 79.29,125.63 81.72,125.63 87.1,131 93.31,131 93.52,131.21 93.52,131.84 v1(92.95,132.41)
  BOTTOM w0.079: U6539.CP49 101.95,132.56 101.52,132.99 100.61,132.99 100.46,133.14 99.01,133.14 98.68,132.81
  BOTTOM w0.102: 98.68,132.81 97.66,132.81 96.82,131.98 93.38,131.98 v1(92.95,132.41)
  BOTTOM w0.114: v2(47.09,121.88) 46.65,122.32 JDIM1.190
M_A_DQ5: length 65.5
  IN4 w0.089: v2(48.41,121.86) 48.41,122.17 48.93,122.69 56.93,122.69 58.26,121.36 60.6,121.36 61.37,122.13 65.64,122.13 66.47,122.96 67.89,122.96 67.98,123.05 67.98,123.38 68.07,123.47 68.33,123.47 68.42,123.38 68.42,123.05 68.51,122.96 68.78,122.96 68.87,123.05 68.87,123.38 68.96,123.47 71.42,123.47 71.68,123.72 71.68,123.85 71.42,124.1 71.42,124.23 71.61,124.42 71.74,124.42 71.99,124.16 72.12,124.16 72.31,124.35 72.31,124.48 72.05,124.73 72.05,124.86 72.24,125.05 72.36,125.05 72.62,124.79 72.75,124.79 73.03,125.07 79.29,125.07 79.47,125.24 81.72,125.24 87.08,130.6 v1(88.08,130.6)
  BOTTOM w0.079: 98.55,132.61 98.8,132.61 99.17,132.98 100.4,132.98 100.55,132.83 101.22,132.83 U6539.CP50
  BOTTOM w0.102: 91.91,131.85 91.99,131.85 92.12,131.72 96.91,131.72 97.8,132.61 98.55,132.61
  BOTTOM w0.114: 91.91,131.85 90.24,131.85 89.99,131.59 89.07,131.59 v1(88.08,130.6) ; JDIM1.194 47.87,121.32 v2(48.41,121.86)
M_A_DQ6: length 64.9
  IN4 w0.089: v1(89.39,130.59) 89,130.2 87,130.2 81.67,124.86 79.57,124.86 79.42,124.71 73.17,124.71 71.06,122.6 70.72,122.6 70.63,122.69 70.63,123 70.54,123.09 70.28,123.09 70.19,123 70.19,122.69 70.1,122.6 69.83,122.6 69.74,122.69 69.74,123 69.65,123.09 69.39,123.09 69.3,123 69.3,122.69 69.21,122.6 66.6,122.6 65.78,121.79 65.27,121.79 65.18,121.7 65.18,121.27 65.1,121.18 64.83,121.18 64.74,121.27 64.74,121.7 64.65,121.79 61.51,121.79 60.74,121.02 58.12,121.02 56.79,122.35 49.19,122.35 49.07,122.22 49.07,121.83 49.19,121.7 v2(49.76,121.7)
  BOTTOM w0.079: 98.55,132.41 98.87,132.41 99.29,132.82 100.33,132.82 100.59,132.56 U6539.CP52
  BOTTOM w0.102: 98.55,132.41 97.9,132.41 96.96,131.46 91.52,131.46
  BOTTOM w0.114: 91.52,131.46 90.38,131.46 90.01,131.09 89.89,131.09 v1(89.39,130.59) ; v2(49.76,121.7) 50.39,121.07 JDIM1.195
M_A_DQ7: length 64
  IN4 w0.089: v1(90.01,130.58) 89.63,130.2 89.33,130.2 89.07,129.94 87.17,129.94 81.71,124.48 79.68,124.48 79.55,124.35 73.32,124.35 71.23,122.26 66.78,122.26 65.25,120.72 64.84,120.72 64.75,120.63 64.75,120.38 64.67,120.29 64.4,120.29 64.31,120.38 64.31,121.27 64.22,121.36 63.95,121.36 63.87,121.27 63.87,120.38 63.78,120.29 63,120.29 62.91,120.38 62.91,120.63 62.82,120.72 62.56,120.72 62.47,120.63 62.47,120.42 62.34,120.29 61.89,120.29 61.77,120.42 61.77,120.8 61.54,121.03 61.36,121.03 61.01,120.67 57.83,120.67 57.23,121.28 56.77,121.28 56.68,121.36 56.68,121.82 56.56,121.94 56.36,121.94 56.24,121.82 56.24,121.36 56.15,121.28 54.35,121.28 54.23,121.4 54.23,121.88 54.11,122.01 53.88,122.01 53.75,121.88 53.75,121.39 53.64,121.28 53.42,121.28 53.32,121.37 53.32,121.91 53.22,122.01 52.97,122.01 52.86,121.9 52.86,121.36 52.78,121.28 52.57,121.28 52.5,121.35 52.5,121.85 52.34,122.01 51.75,122.01 51.38,121.64 v2(51.38,121.55)
  BOTTOM w0.079: U6539.CP53 99.25,132.56 98.89,132.2 98.55,132.2
  BOTTOM w0.102: 91.15,131.09 91.36,131.09 91.49,131.21 97,131.21 97.99,132.2 98.55,132.2
  BOTTOM w0.114: v1(90.01,130.58) 90.03,130.58 90.53,131.09 91.15,131.09 ; JDIM1.191 51.91,122.07 v2(51.38,121.55)
M_A_DQ8: length 64.7
  IN4 w0.089: v1(91.73,132.39) 90.59,131.25 86.97,131.25 81.97,126.25 71.92,126.25 70.4,124.74 66.72,124.74 66.17,124.19 65.37,124.19 65.3,124.11 65.3,123.57 65.13,123.4 64.95,123.4 64.83,123.53 64.83,124.1 64.74,124.19 64.45,124.19 64.35,124.09 64.35,123.16 64.26,123.07 61.42,123.07 61.31,123.18 61.31,123.45 61.22,123.54 60.9,123.54 60.83,123.47 60.83,123.17 60.73,123.07 60.46,123.07 60.37,123.16 60.37,123.45 60.28,123.54 60.02,123.54 59.93,123.45 59.93,123.18 59.71,122.96 58.47,122.96 57.53,123.9 54.65,123.9 54.3,124.25 53.96,124.25 53.87,124.16 53.87,123.81 53.78,123.72 53.51,123.72 53.42,123.81 53.42,124.16 53.33,124.25 53.07,124.25 52.98,124.16 52.98,123.81 52.89,123.72 52.62,123.72 52.53,123.81 52.53,124.16 52.44,124.25 51.9,124.25 v2(51.33,123.68)
  BOTTOM w0.102: 93.6,133.54 93.94,133.88 94.53,133.88 95.47,134.81 99.22,134.81 99.35,134.94 99.81,134.94 99.94,134.81 101.35,134.81 101.36,134.81 101.61,134.81 101.66,134.85 101.96,134.85 102.14,134.68 U6539.CL49
  BOTTOM w0.114: v1(91.73,132.39) 92.21,132.86 92.92,132.86 93.6,133.54 ; JDIM1.187 51.94,123.07 v2(51.33,123.68)
M_A_DQ9: length 63.5
  IN4 w0.089: v2(47.22,127.79) 46.72,128.29 45.98,128.29 45.89,128.38 45.89,128.62 45.98,128.71 48.98,128.71 49.12,128.86 53.46,128.86 54,128.32 57.42,128.32 57.61,128.13 64.78,128.13 65.58,128.93 68.5,128.93 70.28,130.71 74.09,130.71 74.59,130.2 82.04,130.2 85.55,133.7 96.37,133.7 v1(97.09,132.99)
  BOTTOM w0.079: 98.88,133.39 100.35,133.39 100.6,133.64 100.94,133.64 101.2,133.9 U6539.CL50
  BOTTOM w0.102: v1(97.09,132.99) 97.21,133.12 98.61,133.12 98.88,133.39
  BOTTOM w0.114: JDIM1.170 46.75,127.32 v2(47.22,127.79)
M_A_DQ10: length 63.1
  IN4 w0.089: v1(96.03,132.49) 96.03,133.1 95.65,133.48 85.72,133.48 82.07,129.83 74.33,129.83 73.83,130.32 70.53,130.32 68.75,128.55 65.7,128.55 64.95,127.79 57.32,127.79 57.13,127.97 53.51,127.97 53.39,128.1 53.39,128.42 53.3,128.51 53.02,128.51 52.93,128.42 52.93,128.06 52.84,127.97 52.53,127.97 52.44,128.06 52.44,128.42 52.36,128.51 49.96,128.51 49.83,128.38 v2(49.83,127.66)
  BOTTOM w0.102: U6539.CL52 100.57,133.9 100.32,133.65 98.75,133.65 98.48,133.37 96.16,133.37 96.03,133.25 v1(96.03,132.49)
  BOTTOM w0.114: JDIM1.173 52.31,126.57 51.61,127.28 51.1,127.28 50.46,127.91 50.46,128.42 50.34,128.55 49.96,128.55 49.83,128.42 v2(49.83,127.66)
M_A_DQ11: length 62.4
  IN4 w0.089: v1(95.41,133.09) 95.28,133.23 86.01,133.23 82.21,129.44 73.83,129.44 73.71,129.56 73.71,129.82 73.58,129.94 73.35,129.94 73.26,129.85 73.26,129.51 73.18,129.42 72.91,129.42 72.82,129.51 72.82,129.85 72.73,129.94 72.46,129.94 72.38,129.85 72.38,129.51 72.29,129.42 72.02,129.42 71.93,129.51 71.93,129.85 71.84,129.94 71.57,129.94 71.49,129.85 71.49,129.51 71.4,129.42 71.13,129.42 71.04,129.51 71.04,129.85 70.95,129.94 70.69,129.94 70.6,129.85 70.6,129.38 70.51,129.3 70.14,129.3 69.01,128.17 68.75,128.17 68.63,128.04 68.63,127.66 68.5,127.53 68.25,127.53 68.16,127.62 68.16,128.11 68.07,128.2 67.8,128.2 67.71,128.11 67.71,127.62 67.62,127.53 67.36,127.53 67.27,127.62 67.27,128.11 67.18,128.2 66.91,128.2 66.82,128.11 66.82,127.62 66.74,127.53 66.47,127.53 66.38,127.62 66.38,128.11 66.29,128.2 66.02,128.2 65.94,128.11 65.94,127.75 65.85,127.66 65.45,127.66 65.2,127.4 56.94,127.4 56.71,127.63 52.6,127.63 52.31,127.34 51.01,127.34 50.81,127.53 50.81,127.75 v2(51.1,128.04)
  BOTTOM w0.102: U6539.CL53 100.14,133.86 98.58,133.86 98.35,133.63 95.95,133.63 v1(95.41,133.09)
  BOTTOM w0.114: JDIM1.169 51.57,127.57 v2(51.1,128.04)
M_A_DQ12: length 66.1
  IN4 w0.089: v2(48.5,127.91) 47.29,126.7 47.29,126.39 48.05,125.63 51.99,125.63 52.24,125.88 56.31,125.88 56.5,125.69 65.51,125.69 66.09,126.26 69.39,126.26 71.24,128.12 82.16,128.12 86.41,132.36 v1(88.07,132.36)
  BOTTOM w0.079: U6539.CH49 101.88,135.12 101.45,135.55 100.57,135.55 100.4,135.72 100.4,135.74 100.21,135.92
  BOTTOM w0.102: 100.21,135.92 100.2,135.93 95.06,135.93 94.53,135.4 93.26,135.4
  BOTTOM w0.114: v2(48.5,127.91) 46.91,126.32 JDIM1.174 ; v1(88.07,132.36) 88.07,132.62 89.83,134.39 91.99,134.39 93.01,135.4 93.26,135.4
M_A_DQ13: length 65.7
  IN4 w0.089: v1(89.29,132.38) 88.89,131.98 86.56,131.98 82.3,127.72 81.37,127.72 81.28,127.63 81.28,127.37 81.19,127.28 80.92,127.28 80.83,127.37 80.83,127.63 80.74,127.72 80.48,127.72 80.39,127.63 80.39,127.37 80.3,127.28 80.03,127.28 79.94,127.37 79.94,127.63 79.85,127.72 79.59,127.72 79.5,127.63 79.5,127.37 79.41,127.28 79.14,127.28 79.05,127.37 79.05,127.63 78.97,127.72 78.7,127.72 78.61,127.63 78.61,127.37 78.52,127.28 78.25,127.28 78.17,127.37 78.17,127.63 78.08,127.72 77.73,127.72 77.64,127.63 77.64,127.37 77.56,127.28 77.29,127.28 76.84,127.72 71.48,127.72 69.64,125.88 66.34,125.88 65.68,125.22 63.19,125.22 62.54,124.57 58.32,124.57 57.91,124.98 55.04,124.98 54.74,125.28 48.73,125.28 v2(48.53,125.08)
  BOTTOM w0.079: 100.1,135.63 100.27,135.63 100.51,135.39 101.21,135.39 U6539.CH50
  BOTTOM w0.102: 93.26,135.02 94.53,135.02 95.14,135.63 100.1,135.63
  BOTTOM w0.114: v2(48.53,125.08) 46.69,123.25 46.12,123.25 46.05,123.32 JDIM1.186 ; 93.26,135.02 93.24,135.02 92.22,134.01 90.72,134.01 89.29,132.57 v1(89.29,132.38)
M_A_DQ14: length 64.6
  IN4 w0.089: v2(50.59,124.74) 50.19,124.33 50.19,124.15 50.31,124.02 50.52,124.02 51.43,124.94 54.59,124.94 54.9,124.64 57.77,124.64 58.18,124.22 62.68,124.22 63.33,124.87 65.84,124.87 66.47,125.5 69.9,125.5 71.33,126.94 71.33,126.94 71.67,127.28 72.77,127.28 72.86,127.19 72.86,127.02 72.95,126.94 73.22,126.94 73.31,127.02 73.31,127.19 73.39,127.28 73.66,127.28 73.75,127.19 73.75,127.02 73.84,126.94 74.11,126.94 74.19,127.02 74.19,127.19 74.28,127.28 74.55,127.28 74.64,127.19 74.64,127.02 74.73,126.94 74.99,126.94 75.08,127.02 75.08,127.19 75.17,127.28 75.44,127.28 75.53,127.19 75.53,127.02 75.62,126.94 75.88,126.94 75.97,127.02 75.97,127.19 76.06,127.28 76.33,127.28 76.42,127.19 76.42,127.02 76.51,126.94 81.58,126.94 81.71,127.06 81.71,127.26 81.84,127.39 82.3,127.39 86.63,131.72 89.78,131.72 89.91,131.85 v1(89.91,132.38)
  BOTTOM w0.079: 99.99,135.35 100.32,135.35 100.55,135.12 U6539.CH52
  BOTTOM w0.102: 99.99,135.35 95.24,135.35 94.53,134.64 93.39,134.64 93.26,134.52
  BOTTOM w0.114: JDIM1.183 52.4,124.07 52.24,124.23 50.97,124.23 50.36,123.62 50.18,123.62 49.92,123.88 49.92,124.06 v2(50.59,124.74) ; 93.26,134.52 92.37,133.63 90.97,133.63 89.91,132.57 v1(89.91,132.38)
M_A_DQ15: length 64
  IN4 w0.089: v1(91.12,132.38) 91.11,132.38 90.2,131.47 86.73,131.47 81.85,126.59 71.63,126.59 70.15,125.12 66.59,125.12 66.01,124.53 63.48,124.53 62.83,123.88 58.04,123.88 57.64,124.28 54.76,124.28 54.44,124.6 51.6,124.6 50.64,123.64 49.5,123.64 49.41,123.73 49.41,124.39 49.24,124.56 49.06,124.56 48.89,124.39 48.89,123.81 48.81,123.72 48.54,123.72 48.45,123.81 48.45,124.23 48.32,124.36 47.05,124.36 46.92,124.48 46.92,124.9 v2(47.14,125.12)
  BOTTOM w0.102: U6539.CH53 100.16,135.15 95.42,135.15 94.53,134.26 93.64,134.26 93.26,133.88
  BOTTOM w0.114: v2(47.14,125.12) 47.14,124.94 46.52,124.32 JDIM1.182 ; v1(91.12,132.38) 91.12,132.62 91.75,133.25 92.63,133.25 93.26,133.88
M_A_DQ16: length 74.4
  IN4 w0.089: v1(105.46,131.13) 105.03,130.71 104.83,130.71 104.56,130.43 104.56,130.06 104.33,129.83 101.69,129.83 98.29,126.44 98.29,125.32 96.57,123.59 96.57,122.96 89.07,115.47 87.68,115.47 82.85,110.64 81.83,110.64 80.94,109.75 79.8,109.75 79.32,109.27 78.48,109.27 78.38,109.37 78,109.37 77.9,109.27 75.84,109.27 75.46,109.65 69.16,109.65 66.47,106.96 57.63,106.96 57.54,106.87 57.54,106.31 57.46,106.22 57.19,106.22 57.1,106.31 57.1,106.87 57.01,106.96 56.74,106.96 56.65,106.87 56.65,106.44 56.53,106.31 56.34,106.31 56.21,106.44 56.21,106.87 56.12,106.96 50.54,106.96 50.05,107.45 v2(50.05,107.91)
  BOTTOM w0.102: U6539.CV41 105.81,130.77 v1(105.46,131.13)
  BOTTOM w0.114: v2(50.05,107.91) 50.83,107.13 51.92,107.13 52.36,107.57 JDIM1.249
M_A_DQ17: length 75.4
  IN4 w0.089: v1(105.54,132.07) 104.98,132.64 103.49,132.64 103.15,132.97 102.68,132.97 102.24,132.54 100.89,132.54 99.79,131.44 98.9,131.44 96.99,129.52 96.83,129.52 96.44,129.13 96.44,128.72 95.09,127.38 95.09,125.55 93.77,124.23 92.5,124.23 91.87,123.59 91.23,123.59 87.68,120.04 87.17,120.04 86.53,119.4 86.53,119.02 85.72,118.21 85.34,118.21 82.85,115.72 78.91,115.72 78.76,115.57 78.25,115.57 77.39,114.7 76.1,114.7 75.18,113.79 74.11,113.79 73.25,112.93 66.03,112.93 64.58,111.48 64.31,111.48 64.22,111.56 64.22,111.88 64.14,111.97 63.87,111.97 63.78,111.88 63.78,111.56 63.69,111.48 57.85,111.48 57.64,111.69 49.32,111.69 48.59,112.42 48.36,112.42 48.23,112.29 48.23,112.12 48.14,112.04 47.85,112.04 47.72,112.16 47.72,112.66 47.6,112.79 47.28,112.79 47.15,112.66 v2(47.15,111.34)
  BOTTOM w0.102: v1(105.54,132.07) 105.77,131.85 105.81,131.81 U6539.CT41
  BOTTOM w0.114: JDIM1.236 46.64,110.82 v2(47.15,111.34)
M_A_DQ18: length 73.8
  IN4 w0.089: v2(51.39,107.92) 51.97,107.34 52.71,107.34 52.8,107.43 52.8,107.88 52.89,107.97 53.15,107.97 53.24,107.88 53.24,107.43 53.33,107.34 53.6,107.34 53.69,107.43 53.69,107.88 53.78,107.97 54.04,107.97 54.13,107.88 54.13,107.43 54.22,107.34 63.57,107.34 63.66,107.43 63.66,107.76 63.75,107.85 64.02,107.85 64.11,107.76 64.11,107.43 64.2,107.34 64.46,107.34 64.55,107.43 64.55,107.76 64.64,107.85 64.91,107.85 65,107.76 65,107.43 65.09,107.34 65.35,107.34 65.44,107.43 65.44,107.76 65.53,107.85 65.8,107.85 65.89,107.76 65.89,107.43 65.97,107.34 66.33,107.34 66.48,107.48 66.48,108.24 66.59,108.35 67.35,108.35 69,110 75.84,110 75.95,109.89 75.95,109.7 76.04,109.61 76.4,109.61 76.48,109.7 76.48,109.92 76.57,110 76.93,110 77.02,109.92 77.02,109.7 77.11,109.61 77.5,109.61 77.64,109.75 77.64,110 77.77,110.13 78.13,110.13 78.63,109.62 79.17,109.62 79.64,110.09 80.7,110.09 82.27,111.66 83.23,111.66 87.42,115.85 88.95,115.85 96.31,123.21 96.31,123.79 98.04,125.52 98.04,126.46 102.03,130.45 103.17,130.45 103.37,130.66 104.3,130.66 v1(104.81,131.17)
  BOTTOM w0.102: U6539.CV42 105.16,130.82 v1(104.81,131.17)
  BOTTOM w0.114: v2(51.39,107.92) 52.04,108.57 JDIM1.245
M_A_DQ19: length 74.9
  IN4 w0.089: v2(48.48,111.34) 48.69,111.13 48.69,110.73 48.78,110.64 49.23,110.64 49.32,110.73 49.32,111.15 49.52,111.34 52.45,111.34 52.66,111.14 52.66,110.68 52.76,110.58 53.07,110.58 53.18,110.69 53.18,111.15 53.31,111.27 57.57,111.27 57.71,111.13 64.74,111.13 66.19,112.58 73.41,112.58 74.18,113.36 75.51,113.36 76.09,113.94 76.98,113.94 77.07,114.03 77.07,114.26 77.16,114.35 77.42,114.35 77.51,114.26 77.51,113.95 77.6,113.86 77.87,113.86 77.96,113.95 77.96,114.76 78.4,115.21 78.91,115.21 79.04,115.34 82.85,115.34 85.39,117.88 85.9,117.88 86.66,118.64 87.55,118.64 88.31,119.4 88.31,120.14 90.5,122.32 91.36,122.32 92.88,123.85 93.77,123.85 95.42,125.5 95.42,127.43 96.64,128.65 96.64,128.91 97.04,129.31 97.94,129.31 100.95,132.33 102.34,132.33 102.74,132.73 103.12,132.73 103.41,132.45 104.52,132.45 v1(104.89,132.07)
  BOTTOM w0.102: v1(104.89,132.07) 105.16,131.81 U6539.CT42
  BOTTOM w0.114: JDIM1.232 48,111.82 v2(48.48,111.34)
M_A_DQ20: length 72.4
  IN4 w0.089: v2(48.41,107.78) 49.27,107.78 49.84,108.35 54.15,108.35 54.78,107.72 61.36,107.72 61.45,107.81 61.45,108.14 61.54,108.23 61.81,108.23 61.9,108.14 61.9,107.81 61.99,107.72 62.25,107.72 62.34,107.81 62.34,108.14 62.43,108.23 62.7,108.23 62.79,108.14 62.79,107.81 62.88,107.72 63.14,107.72 63.23,107.81 63.23,108.14 63.32,108.23 65.25,108.23 65.74,108.72 67.23,108.72 68.87,110.36 76.94,110.36 77.13,110.55 77.13,110.64 77.3,110.8 79.13,110.8 79.5,110.44 80.36,110.44 81.96,112.04 83.1,112.04 87.29,116.23 88.95,116.23 96.06,123.34 96.06,123.85 97.79,125.57 97.79,126.54 101.95,130.71 103.06,130.71 103.47,131.11 v1(103.53,131.11)
  BOTTOM w0.102: v1(103.53,131.11) 103.53,131.11 103.86,130.78 U6539.CV45
  BOTTOM w0.114: JDIM1.246 47.87,108.32 v2(48.41,107.78)
M_A_DQ21: length 73.2
  IN4 w0.089: v1(103.57,132.07) 103.51,132.07 103.05,132.54 102.82,132.54 102.41,132.13 101.04,132.13 97.2,128.29 96.59,128.29 95.68,127.38 95.68,125.37 93.64,123.34 93.14,123.34 91.36,121.56 90.24,121.56 88.69,120.01 88.69,119.28 87.68,118.26 86.79,118.26 86.02,117.5 85.39,117.5 83.99,116.1 83.99,115.71 83.28,115 81.67,115 81.57,114.89 81.57,114.31 81.48,114.22 81.21,114.22 81.12,114.31 81.12,114.91 81.03,115 80.69,115 80.56,114.87 80.56,114.02 80.13,113.59 79.61,113.59 79.29,113.27 78.94,113.27 78.85,113.36 78.85,113.98 78.76,114.07 78.49,114.07 78.4,113.98 78.4,113.65 78.12,113.37 77.33,113.37 77.17,113.52 76.16,113.52 75.65,113.01 74.33,113.01 73.55,112.24 66.34,112.24 64.89,110.79 57.57,110.79 57.46,110.89 53.89,110.89 53.77,110.77 53.77,110.39 53.62,110.24 51.26,110.24 51.13,110.37 51.13,110.58 v2(51.39,110.84)
  BOTTOM w0.102: v1(103.57,132.07) 103.86,131.78 U6539.CT45
  BOTTOM w0.114: JDIM1.237 52.36,110.57 51.28,109.5 50.73,109.5 50.48,109.75 50.48,109.93 v2(51.39,110.84)
M_A_DQ22: length 71.8
  IN4 w0.089: v1(102.84,131.11) 102.05,131.11 97.53,126.59 97.53,125.7 95.8,123.97 95.8,123.59 88.82,116.61 87.17,116.61 82.98,112.42 81.83,112.42 80.2,110.78 79.66,110.78 79.29,111.15 77.13,111.15 76.69,110.7 68.73,110.7 67.09,109.06 65.6,109.06 65.14,108.61 61.26,108.61 60.75,108.1 58.02,108.1 57.93,108.19 57.93,108.65 57.84,108.73 57.57,108.73 57.49,108.65 57.49,108.19 57.4,108.1 57.13,108.1 57.04,108.19 57.04,108.65 56.95,108.73 56.69,108.73 56.6,108.65 56.6,108.19 56.51,108.1 54.91,108.1 54.31,108.7 49.7,108.7 49.49,108.49 47.8,108.49 v2(47.09,107.78)
  BOTTOM w0.102: U6539.CV47 102.84,131.1 v1(102.84,131.11)
  BOTTOM w0.114: JDIM1.250 46.63,107.32 v2(47.09,107.78)
M_A_DQ23: length 73.2
  IN4 w0.089: v2(50.07,110.85) 49.75,110.53 49.75,110.02 49.87,109.9 50.23,109.9 50.51,110.18 50.69,110.18 50.97,109.9 53.85,109.9 54.47,110.51 57.32,110.51 57.4,110.44 60.96,110.44 61.51,109.88 64.48,109.88 66.5,111.9 73.69,111.9 74.47,112.67 75.79,112.67 76.3,113.18 76.59,113.18 76.78,112.99 76.78,112.67 76.87,112.58 77.16,112.58 77.25,112.67 77.25,112.93 77.34,113.01 77.69,113.01 77.78,112.93 77.78,112.67 77.87,112.58 78.22,112.58 78.31,112.67 78.31,112.93 78.4,113.01 78.7,113.01 79.13,112.58 79.63,112.58 80.92,113.88 82.02,113.88 82.21,114.07 82.21,114.32 82.47,114.58 83.36,114.58 84.37,115.59 84.37,116.1 85.52,117.24 86.28,117.24 86.91,117.88 87.8,117.88 89.2,119.28 89.2,119.99 90.52,121.31 91.49,121.31 93.26,123.09 93.77,123.09 95.93,125.24 95.93,127.33 96.64,128.04 97.28,128.04 101.14,131.9 102.46,131.9 102.67,132.11 v1(102.94,132.11)
  BOTTOM w0.102: U6539.CT47 103.21,131.84 102.94,132.11 v1(102.94,132.11)
  BOTTOM w0.114: v2(50.07,110.85) 50.07,111.78 50.32,112.04 50.85,112.04 51.31,111.57 JDIM1.233
M_A_DQ24: length 73.3
  IN4 w0.089: v2(47.07,116.35) 47.07,117.12 47.2,117.24 48.75,117.24 49.02,117.52 54.51,117.52 54.78,117.24 56.43,117.24 56.73,116.94 67.65,116.94 69.3,118.59 69.42,118.59 69.76,118.25 69.89,118.25 70.08,118.44 70.08,118.57 69.74,118.91 69.74,119.03 69.98,119.28 72.35,119.28 73.89,120.82 75.08,120.82 75.36,120.55 76.63,120.55 77.48,121.4 81.54,121.4 83.23,123.09 84.75,123.09 85.14,123.47 85.14,124.23 87.93,127.02 88.56,127.02 89.2,127.66 91.23,127.66 92.5,128.93 93.58,128.93 94.03,129.37 94.03,130.32 95.78,132.07 96.72,132.07 98.09,133.44 98.09,133.65 99.66,135.23 102.06,135.23 102.51,135.68 103.71,135.68 103.94,135.44 105.02,135.44 v1(105.6,134.87)
  BOTTOM w0.102: U6539.CK41 105.81,134.65 v1(105.6,134.87)
  BOTTOM w0.114: JDIM1.212 46.24,116.82 46.34,116.92 46.85,116.92 47.07,116.7 v2(47.07,116.35)
M_A_DQ25: length 72.3
  IN4 w0.089: v2(48.48,113.38) 49.54,112.32 54.43,112.32 54.68,112.57 64.82,112.57 65.9,113.64 72.39,113.64 73.13,114.39 74.94,114.39 75.86,115.31 77.13,115.31 78.25,116.43 80.51,116.43 80.69,116.61 83.1,116.61 85.01,118.51 85.52,118.51 85.9,118.89 85.9,120.16 86.96,121.23 87.74,121.23 91.12,124.61 92.17,124.61 93.44,125.88 94.53,125.88 94.9,126.24 94.9,127.51 96.24,128.85 96.24,129.23 96.81,129.8 96.96,129.8 98.8,131.64 99.72,131.64 100.81,132.74 102.14,132.74 102.57,133.17 103.26,133.17 103.48,133.39 105.03,133.39 v1(105.6,133.95)
  BOTTOM w0.102: U6539.CM41 105.81,133.74 v1(105.6,133.95)
  BOTTOM w0.114: JDIM1.224 48.03,113.82 v2(48.48,113.38)
M_A_DQ26: length 72.1
  IN4 w0.089: v2(50.04,113.06) 50.44,112.66 52.24,112.66 52.47,112.89 52.92,112.89 53.14,112.66 54.29,112.66 54.54,112.91 64.68,112.91 65.75,113.98 72.18,113.98 73,114.8 74.87,114.8 75.73,115.67 76.98,115.67 78.13,116.81 78.61,116.81 78.79,116.99 79.55,116.99 79.72,116.81 80.22,116.81 80.31,116.9 80.31,117.5 80.44,117.62 80.85,117.62 80.98,117.5 80.98,117.08 81.07,116.99 81.62,116.99 81.75,117.12 81.75,117.66 82.09,118.01 82.72,118.01 82.85,118.13 82.85,118.39 82.98,118.51 83.27,118.51 83.78,118.01 83.99,118.01 84.25,118.26 84.25,118.39 84.02,118.61 84.02,118.79 84.25,119.02 84.25,119.28 84.63,119.66 85.39,119.66 85.52,119.78 85.52,120.16 86.91,121.56 87.68,121.56 91.03,124.92 92.1,124.92 93.7,126.51 94.41,126.51 94.69,126.79 94.69,127.61 96.01,128.93 96.01,129.31 96.77,130.07 96.95,130.07 99.59,132.71 100.5,132.71 101.29,133.5 102.3,133.5 102.41,133.38 103.2,133.38 103.4,133.58 104.57,133.58 104.6,133.61 v1(104.95,133.95)
  BOTTOM w0.102: v1(104.95,133.95) 105.16,133.74 U6539.CM42
  BOTTOM w0.114: v2(50.04,113.06) 50.56,113.57 JDIM1.225
M_A_DQ27: length 72.8
  IN4 w0.089: v1(104.95,134.87) 104.57,135.24 103.8,135.24 103.56,135.49 102.59,135.49 102.13,135.03 100.6,135.03 99.71,134.13 99.05,134.13 96.77,131.85 95.93,131.85 94.28,130.2 94.28,129.35 93.6,128.67 92.63,128.67 91.36,127.4 89.33,127.4 88.69,126.77 88.17,126.77 85.52,124.12 85.52,123.47 84.88,122.83 83.36,122.83 81.58,121.05 77.64,121.05 76.75,120.16 75.23,120.16 74.93,120.47 74.02,120.47 72.45,118.89 70.78,118.89 70.53,118.64 70.53,118.26 69.9,117.63 69.77,117.63 69.39,118.01 69.27,118.01 69.02,117.77 69.02,117.64 69.6,117.07 69.6,116.94 69.41,116.75 69.28,116.75 68.71,117.33 68.58,117.33 67.86,116.6 56.4,116.6 56.1,116.9 54.95,116.9 54.78,116.74 54.53,116.74 54.4,116.86 54.4,117.05 54.27,117.17 54.01,117.17 53.92,117.09 53.92,116.19 53.83,116.1 53.56,116.1 53.47,116.19 53.47,117.09 53.39,117.17 53.12,117.17 53.03,117.09 53.03,116.19 52.94,116.1 52.67,116.1 52.59,116.19 52.59,117.05 52.46,117.17 51.39,117.17 51.26,117.05 v2(51.26,116.69)
  BOTTOM w0.102: v1(104.95,134.87) 105.16,134.65 U6539.CK42
  BOTTOM w0.114: JDIM1.215 51.88,116.07 v2(51.26,116.69)
M_A_DQ28: length 70.9
  IN4 w0.089: v1(103.64,133.95) 103.5,133.95 103.12,133.58 102.54,133.58 102.42,133.7 101.22,133.7 100.43,132.91 99.51,132.91 96.92,130.32 96.69,130.32 95.78,129.41 95.78,129.03 94.48,127.73 94.48,126.97 94.25,126.74 93.54,126.74 91.98,125.18 90.92,125.18 87.67,121.94 87.41,121.94 86.79,121.94 84.75,119.91 83.87,119.91 82.28,118.32 81.72,118.32 81.63,118.23 81.63,117.97 81.54,117.88 81.28,117.88 81.19,117.97 81.19,118.23 81.1,118.32 80.75,118.32 80.5,118.07 79.46,118.07 78.9,118.63 78.72,118.63 78.59,118.5 78.59,118.37 79.26,117.71 79.26,117.59 79.07,117.4 78.94,117.4 78.28,118.06 78.15,118.06 77.97,117.87 77.97,117.74 78.25,117.46 78.25,117.34 78.06,117.15 77.93,117.15 77.65,117.43 77.46,117.43 77.23,117.2 77.23,117.02 77.39,116.86 77.39,116.61 76.8,116.02 75.6,116.02 74.87,115.29 72.71,115.29 71.75,114.33 65.61,114.33 64.54,113.25 57.42,113.25 57.34,113.34 57.34,113.6 57.25,113.69 56.98,113.69 56.89,113.6 56.89,113.34 56.8,113.25 54.45,113.25 54.12,113.57 53.78,113.57 53.69,113.48 53.69,113.09 53.6,113 53.34,113 53.25,113.09 53.25,113.48 53.16,113.57 51.9,113.57 v2(51.39,113.06)
  BOTTOM w0.102: U6539.CM45 103.86,133.74 v1(103.64,133.95)
  BOTTOM w0.114: v2(51.39,113.06) 51.88,112.57 JDIM1.229
