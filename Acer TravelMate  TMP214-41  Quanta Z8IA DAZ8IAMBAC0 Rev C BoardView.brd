# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDI0+_1: length 21.7
  IN4 w0.081: CN8.1 16.39,188.27 19.1,185.57 30.48,185.57 30.87,185.96 30.87,186.4 v2(30.62,186.65)
  BOTTOM w0.089: v2(30.62,186.65) 30.89,186.93 30.89,187.11 30.5,187.5 U25.16
MDI0-: length 28.8
  TOP w0.089: v2(23.76,170.94) 23.51,170.68 23.07,170.68 22.4,170.02 22.4,169.76 22.29,169.66 U6521.14
  BOTTOM w0.089: v2(23.76,170.94) 23.54,170.71 23.23,170.71 22.5,171.44 22.5,172.88 22.64,173.02 22.82,173.02 23.73,172.1 24.3,172.1 24.6,172.4 24.6,172.77 24.21,173.16 24.21,173.34 24.52,173.66 24.69,173.66 25.15,173.2 25.52,173.2 25.93,173.61 25.93,174.11 25.42,174.61 25.42,174.88 25.7,175.16 25.88,175.16 27.13,173.91 27.5,173.91 27.92,174.34 27.92,174.71 27.07,175.56 27.07,175.82 27.2,175.94 27.72,175.94 28.99,174.68 29.36,174.68 30.02,175.33 30.02,175.79 28.86,176.95 28.86,177.11 29.2,177.44 30.77,177.44 31.07,177.73 31.07,178.13 31.5,178.56 U25.8
MDI0-_1: length 21.6
  IN4 w0.081: CN8.2 14.45,187.78 14.68,188.01 16.29,188.01 18.99,185.31 30.59,185.31 31.13,185.85 31.13,186.4 v2(31.38,186.65)
  BOTTOM w0.089: v2(31.38,186.65) 31.12,186.92 31.12,187.13 31.5,187.51 U25.17
MDI1+: length 33.7
  TOP w0.089: U6521.17 21.09,169.73 21,169.82 21,171.01 21.19,171.2 21.37,171.2 v2(21.6,170.97)
  BOTTOM w0.089: U25.12 27.5,178.56 27.9,178.16 27.9,177.94 27,177.03 20.92,177.03 20.65,176.76 20.65,176.3 20.91,176.04 23.19,176.04 23.43,175.8 23.43,175.55 23.16,175.28 20.24,175.28 19.87,175.65 17.49,175.65 16.96,175.12 16.96,173.92 17.33,173.55 19.01,173.55 19.5,174.04 21.36,174.04 21.53,173.86 21.53,173.4 21.38,173.25 20.62,173.25 20.26,172.89 20.26,171.89 20.91,171.24 21.33,171.24 v2(21.6,170.97)
MDI1+_1: length 18
  IN1 w0.081: CN8.3 14.75,186.23 15.67,185.32 27.22,185.32 27.86,185.95 27.86,186.55 v2(27.64,186.76)
  BOTTOM w0.089: v2(27.64,186.76) 27.89,187.01 27.89,187.19 27.5,187.58 U25.13
MDI1-: length 33.7
  TOP w0.089: v2(21.6,171.73) 21.29,171.43 21.09,171.43 20.77,171.11 20.77,169.85 20.69,169.77 U6521.18
  BOTTOM w0.089: v2(21.6,171.73) 21.34,171.47 21,171.47 20.49,171.98 20.49,172.8 20.71,173.02 21.48,173.02 21.76,173.31 21.76,173.95 21.45,174.27 19.41,174.27 18.92,173.78 17.43,173.78 17.19,174.01 17.19,175.03 17.59,175.43 19.77,175.43 20.14,175.05 23.25,175.05 23.66,175.46 23.66,175.9 23.29,176.27 21,176.27 20.87,176.4 20.87,176.66 21.02,176.81 27.1,176.81 28.13,177.84 28.13,178.2 28.5,178.56 U25.11
MDI1-_1: length 18.1
  IN1 w0.081: CN8.6 15.29,184.01 15.29,184.55 15.79,185.06 27.33,185.06 28.12,185.84 28.12,186.47 v2(28.41,186.76)
  BOTTOM w0.089: v2(28.41,186.76) 28.12,187.05 28.12,187.19 28.5,187.57 U25.14
MDI2+: length 34.5
  TOP w0.089: U6521.20 19.89,169.79 19.83,169.85 19.83,170.18 19.91,170.25 19.91,171.36 19.57,171.7 19.43,171.7 v2(19.18,171.95)
  BOTTOM w0.089: U25.2 37.5,177.64 36.79,176.93 33.83,176.93 30.03,173.13 29.18,173.13 24.49,168.44 17.74,168.44 16.84,169.35 16.84,171.24 17.29,171.7 18.93,171.7 v2(19.18,171.95)
MDI2+_1: length 28.1
  IN4 w0.081: CN8.4 14.45,184.75 14.75,184.45 33.34,184.45 34.97,186.08 34.97,187.09 35.61,187.73 36.73,187.73 37.13,187.33 37.13,186.98 v2(37.38,186.73)
  BOTTOM w0.089: U25.23 37.5,187.57 37.13,187.2 37.13,186.98 v2(37.38,186.73)
MDI2-: length 34.5
  TOP w0.089: U6521.21 19.49,169.84 19.6,169.95 19.6,170.27 19.68,170.35 19.68,171.27 19.48,171.47 19.1,171.47 19.03,171.4 19.03,171.13 v2(19.18,170.98)
  BOTTOM w0.089: U25.3 36.5,178.43 36.73,178.2 37.09,178.2 37.27,178.02 37.27,177.74 36.7,177.16 33.73,177.16 29.93,173.36 29.09,173.36 24.39,168.67 17.84,168.67 17.06,169.44 17.06,171.15 17.39,171.47 19.14,171.47 19.26,171.34 19.26,171.07 v2(19.18,170.98)
MDI2-_1: length 28.2
  IN4 w0.081: v2(36.62,186.73) 36.87,186.98 36.87,187.23 36.62,187.47 35.72,187.47 35.23,186.99 35.23,185.97 33.45,184.19 CN8.5
  BOTTOM w0.089: U25.22 36.5,187.57 36.9,187.17 36.9,187.01 v2(36.62,186.73)
MDI3+: length 25.6
  TOP w0.089: v2(17.59,170.99) 17.92,170.66 18.07,170.66 18.64,170.09 18.64,169.72 18.69,169.67 U6521.23
  BOTTOM w0.089: U25.6 33.5,178.56 33.87,178.2 33.87,178.05 33.74,177.92 33.35,177.92 29.63,174.21 28.74,174.21 27.98,173.44 26.58,173.44 26.1,172.96 26.1,172.13 24.43,170.46 24.43,169.95 23.95,169.47 18.83,169.47 18.44,169.86 18.44,170.46 18.17,170.72 17.86,170.72 v2(17.59,170.99)
MDI3+_1: length 25.1
  IN1 w0.081: v2(33.62,186.73) 33.92,186.43 33.92,185.92 32.18,184.17 17.06,184.17 15.04,182.15 CN8.7
  BOTTOM w0.089: U25.19 33.5,187.55 33.88,187.17 33.88,186.99 v2(33.62,186.73)
MDI3-: length 25.6
  TOP w0.089: U6521.24 18.29,169.68 18.42,169.8 18.42,169.99 17.98,170.43 17.8,170.43 v2(17.59,170.23)
  BOTTOM w0.089: U25.5 34.5,178.56 34.1,178.16 34.1,177.96 33.83,177.7 33.45,177.7 29.73,173.98 28.84,173.98 28.07,173.21 26.67,173.21 26.33,172.86 26.33,172.03 24.66,170.36 24.66,169.85 24.04,169.24 18.74,169.24 18.21,169.77 18.21,170.37 18.08,170.49 17.85,170.49 v2(17.59,170.23)
MDI3-_1: length 25
  IN1 w0.081: v2(34.38,186.73) 34.18,186.53 34.18,185.81 32.28,183.91 17.17,183.91 15.15,181.89 14.66,181.89 14.45,181.69 CN8.8
  BOTTOM w0.089: v2(34.38,186.73) 34.11,187.01 34.11,187.18 34.5,187.57 U25.20
ME_WR#: length 86.7
  TOP w0.114: v1(101.52,98.29) 101.65,98.42 101.65,99.84 102.03,100.23 v2(102.03,100.99) 102.03,101.75 103.01,102.73 103.01,106.29 103.4,106.68 104.04,106.68 104.85,107.49 v1(104.85,108.23) ; v2(161.06,103.91) 160.82,104.15 160.82,110.07 161.06,110.31 U37.109
  IN3 w0.102: v2(110.13,96.03) 110.92,96.82 116.1,96.82 116.89,97.61 118.49,97.61 118.99,98.12 124.63,98.12 125.12,98.6 131.26,98.6 132.89,100.23 135.05,100.23 135.3,100.48 136.75,100.48 138.15,101.88 141.5,101.88 142.25,101.13 142.78,101.13 143.96,99.95 148.99,99.95 149.8,100.76 149.8,101.27 150.57,102.03 156.37,102.03 156.65,102.31 159.23,102.31 160.83,103.91 v2(161.06,103.91)
  IN4 w0.089: v2(110.13,96.03) 109.62,96.54 109.14,96.54 108.88,96.29 104.06,96.29 102.79,97.56 102.79,98.19 102.28,98.7 101.93,98.7 v1(101.52,98.29)
  BOTTOM w0.114: Q6649.2 105.27,108.93 104.85,108.51 v1(104.85,108.23)
MEM_VREF_CTL_QA:
  vias: v2(160.75,191.56)
MIC2-VREFO: length 12
  TOP w0.381: v2(20.21,24.23) 20.37,24.38 R471.1 R468.1
  IN1 w0.381: v2(20.21,24.23) 20.21,24.5 18.63,26.09 18.63,28.08 17.85,28.86 17.1,28.86 16.62,29.34 16.62,31.25 16.24,31.63 16.14,31.63 v1(16.12,31.65)
  BOTTOM w0.203: U20.29 16.29,31.81 v1(16.12,31.65)
MINICAR_PME#: length 6.3
  TOP w0.114: v2(182.64,109.72) 182.54,109.82 182.54,110.77 v2(182.98,111.2) 183.02,111.25 R651.1 R69029.1 184.34,111.94 184.37,111.91 Q33.3
  BOTTOM w0.114: v2(182.64,109.72) 183.14,109.72 183.57,110.15 CN17.55
MIPI60_CFG0#: length 6.6
  BOTTOM w0.102: U6539.E7 121,163.97 121.13,164.1 121.13,164.23 121.38,164.49 121.69,164.49 121.76,164.56 122.27,164.56 122.45,164.74 122.45,165.14 122.59,165.28 122.59,167.4 122.85,167.66 R68323.1
MIPI60_CFG0#_R: length 4.4
  BOTTOM w0.114: TP13286.1 123.84,172.01 R68324.1 123.84,171.06 122.85,170.08 R68323.2 R68291.2
MIPI60_CFG1#: length 11.3
  TOP w0.114: R68292.2 127.71,168.9 127.53,169.08 125.95,169.08 125.8,168.93 R68331.1 125.27,168.68 v2(125.12,168.53) 124.84,168.25 124.84,167.03 124.66,166.85 124.66,166.09 124.33,165.76 123.11,165.76 122.52,165.17 121.2,165.17 120.57,164.54 120.38,164.54 v1(120.38,164.55)
  BOTTOM w0.102: U6539.D9 120.07,164.24 120.38,164.54 v1(120.38,164.55)
MIPI60_CFG2#: length 11.3
  TOP w0.114: R68293.2 127.71,167.69 127.46,167.44 127.3,167.44 127.14,167.28 126.79,167.28 126.63,167.44 125.95,167.44 125.8,167.58 R68325.1 125.27,167.92 125.12,167.76 125.12,166.9 124.96,166.75 124.96,166.01 124.33,165.38 123.39,165.38 v2(123.08,165.07) 122.88,164.87 121.32,164.87 120.38,163.93 v1(120.38,163.93)
  BOTTOM w0.102: U6539.E9 120.33,163.93 v1(120.38,163.93)
MIPI60_CFG3#: length 8
  TOP w0.114: v1(122.14,163.03) 122.14,163.14 123.03,164.03 124.3,164.03 124.76,164.49 125.27,164.49 125.65,164.87 R68332.1 125.8,165.15 125.93,165.27 126.51,165.27 v2(126.92,164.87) 127.33,165.27 127.58,165.27 127.71,165.15 R68294.2
  BOTTOM w0.102: v1(122.14,163.03) 122.14,162.95 121.89,162.7 U6539.H5
MIPI60_CFG4#: length 8.6
  TOP w0.114: R68295.2 127.71,165.68 127.58,165.55 125.9,165.55 125.8,165.65 R68326.1 125.65,166.01 125.52,165.88 125.52,165.73 125.14,165.35 v2(125.14,165.15) 124.86,164.87 124.63,164.87 124.07,164.31 121.79,164.31 121.51,164.03 v1(121.49,164.03)
  BOTTOM w0.089: v1(121.49,164.03) 121.65,163.87 U6539.E6
MIPI60_CFG5#: length 9.6
  TOP w0.114: v1(120.25,163.03) 119.92,163.35 119.92,164.73 120.21,165.02 120.65,165.02 121.13,165.5 122.42,165.5 123.76,166.84 123.76,166.84 123.83,166.91 123.83,166.99 124.09,167.25 R68333.1 124.23,167.64 v2(123.95,167.92) 124.25,168.22 R68296.2
  BOTTOM w0.102: v1(120.25,163.03) 119.93,162.71 119.93,162.53 U6539.H9
MIPI60_CFG6#: length 8.5
  TOP w0.102: 122.98,162.73 122.66,162.73 122.37,162.44 121.3,162.44 v1(120.92,162.06)
  TOP w0.114: 122.98,162.73 123.26,162.73 123.87,163.34 v2(125.01,163.34) 125.09,163.34 125.47,162.96 R68334.1 125.8,163.25 125.95,163.39 127,163.39 127.17,163.22 R68297.2
  BOTTOM w0.102: U6539.K8 120.92,161.93 v1(120.92,162.06)
MIPI60_CFG7#: length 11.1
  TOP w0.114: v1(121.53,163.03) 121,163.56 121,164.16 121.43,164.59 123.92,164.59 125.24,165.91 125.24,166.49 125.52,166.77 R68327.1 125.8,167.08 125.9,167.17 126.52,167.17 v2(126.92,166.77) 127.03,166.77 127.43,167.17 127.58,167.17 127.71,167.05 R68298.2
  BOTTOM w0.102: v1(121.53,163.03) 121.24,162.74 U6539.H7
MIPI60_CFG8#: length 7.5
  TOP w0.114: R68299.2 127.71,162.21 127.6,162.1 127.45,162.1 127.07,161.72 R68335.1 124.6,161.72 124.51,161.82 123.36,161.82 123.14,161.6 122.03,161.6 v1(121.57,162.06)
  BOTTOM w0.102: v1(121.57,162.06) 121.57,161.93 U6539.K7
MIPI60_CFG9#: length 11.6
  TOP w0.114: R68300.2 117.14,168.93 v1(117.27,168.81) 117.17,168.7 R68322.1
  IN4 w0.089: v1(116.63,159.92) 116.38,160.17 116.38,165.63 117.27,166.52 v1(117.27,168.81)
  BOTTOM w0.102: v1(116.63,159.92) 116.63,159.41 116.41,159.18 U6539.T17
MIPI60_CFG10#: length 9.8
  TOP w0.102: v2(123.49,163.6) 122.91,163.6 122.6,163.29 122.6,162.94 122.29,162.63 120.84,162.63 v1(120.27,162.06)
  TOP w0.114: v2(123.49,163.6) 123.62,163.73 124.38,163.73 124.76,164.11 R68328.1 125.8,163.8 125.94,163.66 127.57,163.66 127.71,163.8 R68301.2
  BOTTOM w0.102: v1(120.27,162.06) 120.27,161.93 U6539.K9
MIPI60_CFG11#: length 9.9
  TOP w0.114: R68302.2 117.9,169.06 117.77,168.93 117.77,168.55 117.9,168.42 R68317.1 118.18,168.27 118.31,168.14 118.31,167.51 118.03,167.23 118.03,166.75 118.54,166.24 118.54,165.86 v2(118.05,165.38) 118.03,165.35 118.03,161.53 118.41,161.14 v1(118.42,161.14)
  BOTTOM w0.102: v1(118.42,161.14) 118.44,161.14 118.64,161.35 U6539.K12
MIPI60_CFG12#: length 9.6
  TOP w0.114: v1(119.62,162.06) 119.62,162.26 119.04,162.84 119.04,164.49 v2(119.17,164.61) 119.17,164.74 119.93,165.5 119.93,166.06 120.37,166.49 121.31,166.49 121.84,167.03 121.84,167.63 121.97,167.76 R68320.1 R68303.2
  BOTTOM w0.102: U6539.K11 119.62,161.93 v1(119.62,162.06)
MIPI60_CFG13#: length 13.5
  TOP w0.114: R68304.2 127.55,161.69 127.17,161.31 124.51,161.31 124.38,161.44 123.74,161.44 123.52,161.21 R68321.1 123.24,160.93 122.98,160.68 119.81,160.68 119.55,160.42 119.55,160.04 119.3,159.79 118.79,159.79 116.92,157.92 v1(116.84,157.92)
  BOTTOM w0.102: v1(116.84,157.92) 116.92,157.98 U6539.U15
MIPI60_CFG14#: length 15.1
  TOP w0.114: R68306.2 R68329.1 118.79,168.27 118.59,168.06 118.59,167 v2(118.51,166.93) 118.69,166.75 v1(119.38,166.75)
  IN4 w0.102: v1(119.38,166.75) 117.27,164.64 117.27,162.58 117.01,162.33 117.01,159.53 116.33,158.85 v1(116.33,157.12)
  BOTTOM w0.102: U6539.V17 116.41,157.2 v1(116.33,157.12)
MIPI60_CFG15#: length 14.1
  TOP w0.114: v1(119.68,167.28) 120.37,167.28 v2(120.52,167.43) 120.52,167.97 120.22,168.27 R68330.1 119.76,168.78 119.81,168.83 R68307.2
  IN4 w0.102: v1(116.83,158.56) 116.89,158.56 117.14,158.82 117.14,159.03 118,159.89 118,164.46 119.81,166.27 119.81,167.15 v1(119.68,167.28)
  BOTTOM w0.102: v1(116.83,158.56) 116.97,158.56 U6539.T15
MIPI60_CFG16_STB_DN: length 8.5
  TOP w0.114: R68312.2 123.41,167.76 123.54,167.63 123.54,167.03 123.44,166.93 123.19,166.93 v2(122.91,166.65) 122.91,166.37 122.32,165.78 121.03,165.78 120.62,165.38 120.19,165.38 119.68,164.87 119.68,163.21 v1(119.5,163.03)
  BOTTOM w0.102: v1(119.5,163.03) 119.29,162.82 U6539.H11
MIPI60_CFG17_STB_DP: length 18.5
  TOP w0.114: TP13268.1 131.19,155.34 130.05,154.21 123.08,154.21 122.83,154.45 121.84,154.45 121.1,155.19 119.83,155.19 118.92,156.11 117.37,156.11 v1(116.91,156.56)
  BOTTOM w0.102: U6539.U17 116.08,157.94 116.08,157.46 115.96,157.34 115.96,156.91 116.3,156.56 v1(116.91,156.56)
MODE1: length 203.8
  TOP w0.114: v1(139.42,119.2) 139.24,119.2 138,117.96 138,117.95 137.74,117.69 137.73,117.69 137.71,117.67 135.86,117.67 134.35,116.16 133.71,116.16 v2(133.52,115.97) 133.01,115.47 133.01,114.83 130.6,112.42 128.01,112.42 v2(127.81,112.21) v1(124.96,112.21) ; v1(147.62,112.54) 147.62,112.67 149.27,114.32 151.43,114.32 152.01,113.74 154.46,113.74 155.15,114.43 155.31,114.43 R69087.1
  IN3 w0.102: v1(147.62,112.54) 147.62,112.42 147.37,112.16 140.51,112.16 139.24,113.43 139.24,119.02 v1(139.42,119.2) 139.39,119.2 139.24,119.35 139.24,119.91 139.61,120.28 139.88,120.28 142.05,122.45 146.73,122.45 152.06,127.78 152.06,134.36 150.26,136.17 144.32,136.17 142.41,138.07 142.41,145.18 140.94,146.66 140.94,147.98 140.76,148.15 140.76,164.74 v2(137.84,167.66) ; v2(148.28,208.68) 148.28,208.68 147.02,207.41 146.48,207.41 145.21,206.14 138.6,206.14 137.46,207.29 133.01,207.29 132.63,207.67 125.78,207.67 124.18,206.07 124.18,205 124.25,204.92 124.25,204.24 123.87,203.86 123.87,195.98 123.63,195.75 123.63,194.73 123.49,194.59 123.49,189.09 124,188.59 124,187.27 123.03,186.3 123.03,183.6 124.94,181.7 124.94,180.69 125.27,180.36 127.81,180.36 128.82,179.35 128.85,179.35 v1(128.87,179.32)
  IN4 w0.089: v1(128.87,179.32) 128.87,179.17 129.84,178.2 129.84,174.65 130.73,173.76 132.13,173.76 133.78,175.41 136.32,175.41 137.08,176.17 140.76,176.17 141.27,175.66 141.27,173.38 137.84,169.95 v2(137.84,167.66)
  BOTTOM w0.114: U6556.12 133.15,121.95 132.76,121.56 132.76,120.5 133.66,119.6 133.66,118.25 133.98,117.93 133.98,116.43 v2(133.52,115.97) ; v1(124.96,112.21) 125.18,112.21 125.47,112.51 Q6638.3 ; v2(148.28,208.68) 148,208.68 147.22,209.46 Q6631.3
MODE1_HUB: length 8.6
  TOP w0.114: v2(153.46,214.14) U6516.A3
  BOTTOM w0.114: v2(153.46,214.14) 153.08,213.76 v2(152.19,213.76) 151.18,213.76 150.13,212.72 R68992.2 148.66,212.72 148.53,212.85 147.72,212.85 147.22,212.35 Q6631.4
MODE1_ISH: length 28.7
  IN4 w0.089: v1(112.16,112.04) 112.67,111.53 113.1,111.53 114.24,110.39 115.13,110.39 115.9,109.62 v1(115.91,109.62)
  BOTTOM w0.102: U6539.DR24 113.51,123.14 112.97,122.6 112.69,122.6 112.44,122.35 112.44,121.31 112.54,121.21 112.54,120.49 111.98,119.94 111.98,119.1 112.19,118.89 112.19,115.41 112.16,115.39 112.16,113.55
  BOTTOM w0.114: Q6638.4 125.31,114.11 125.17,113.97 R69016.1 124.53,113.97 123.13,112.57 120.29,112.57 120.01,112.29 119.73,112.29 119.12,111.68 117.93,111.68 v2(116.58,110.33) 115.91,109.66 v1(115.91,109.62) ; v1(112.16,112.04) 112.16,113.55
MODE2: length 232.5
  TOP w0.114: R69085.1 170.34,107.15 170.34,107.19 170.81,107.67 170.81,108.02 171.06,108.28 171.06,109.93 171.04,109.95 v1(171.04,109.98) ; v1(131.72,112.24) 131.72,113.15 133.48,114.92 v2(133.48,115.25) 133.82,115.25 135.94,117.37 138.22,117.37 v2(138.93,118.07) 140,119.15 140,119.48 v1(139.81,119.67)
  IN1 w0.089: v1(171.04,109.98) 171.01,109.95 171.01,109.93 169.44,108.35 168.5,108.35 167.79,107.64 165.86,107.64 164.51,108.99 161.72,108.99 160.68,107.95 155.39,107.95 155.24,108.1 152.19,108.1 150.57,109.72 141.37,109.72 140.75,109.1 137.47,109.1 134.34,112.24 v1(131.72,112.24)
  IN3 w0.102: v2(137.21,168.04) 137.33,168.17 137.97,168.17 141.52,164.61 141.52,156.11 141.02,155.6 141.02,148.23 141.17,148.08 141.17,146.81 142.67,145.31 142.67,138.33 144.44,136.55 150.36,136.55 152.45,134.46 152.45,127.4 146.98,121.94 141.9,121.94 139.81,119.85 v1(139.81,119.67) ; v1(128.27,179.32) 128.24,179.35 128.24,179.55 127.81,179.98 124.12,179.98 123.62,180.49 122.85,180.49 122.22,181.12 122.22,184.38 122.78,184.93 122.78,186.63 123.62,187.47 123.62,188.24 123.08,188.77 123.08,194.61 122.68,195.02 122.68,195.81 123.62,196.75 123.62,203.93 124,204.31 124,204.81 123.94,204.87 123.94,206.21 125.67,207.94 132.74,207.94 133.14,207.54 137.59,207.54 138.73,206.4 144.83,206.4 145.97,207.54 145.97,208.63 v2(145.92,208.68)
  IN4 w0.089: v1(128.27,179.32) 129.59,178 129.59,174.52 130.6,173.5 132.25,173.5 133.9,175.16 136.57,175.16 137.33,175.92 140.63,175.92 140.76,175.79 140.76,173.63 137.21,170.08 v2(137.21,168.04)
  BOTTOM w0.114: Q6638.6 127.43,114.11 127.81,113.73 127.81,112.54 129.59,110.77 130.73,110.77 131.72,111.76 v1(131.72,112.24) ; U6556.11 133.17,121.45 133.04,121.32 133.04,120.6 133.93,119.71 133.93,118.36 134.26,118.03 134.26,116.02 v2(133.48,115.25) ; v2(145.92,208.68) 146.73,209.5 146.73,210.46 146.98,210.72 148.25,210.72 148.52,210.98 Q6631.6
MODE2_HUB: length 7.9
  TOP w0.079: 153.64,213.22 153.81,213.4 154.36,213.4 U6516.B2
  TOP w0.114: v2(153.58,213.16) 153.64,213.22
  BOTTOM w0.114: v2(153.58,213.16) 153.58,213.06 v2(153,212.49) 151.76,211.25 R68993.2 149.43,211.25 148.52,210.35 Q6631.1
MODE2_ISH: length 28.3
  IN4 w0.089: v1(116.52,109.61) 115.49,110.64 114.85,110.64 113.46,112.04 v1(112.82,112.04)
  BOTTOM w0.102: 112.39,113.78 112.39,119.07 112.19,119.28 112.19,119.83 112.75,120.39 112.75,121.33 112.62,121.46 112.62,122.04 U6539.DU25
  BOTTOM w0.114: v1(112.82,112.04) 112.39,112.47 112.39,113.78 ; v1(116.52,109.61) v2(117.9,110.99) 118.31,111.4 119.22,111.4 119.73,111.91 120.11,111.91 120.49,112.29 123.24,112.29 124.1,113.15 R69017.1 125.11,113.15 125.27,113.31 126.78,113.31 127.06,113.02 Q6638.1
MODEM_CLKREQ: length 186.1
  TOP w0.114: U36.2 186.35,114.83 186.1,114.58 R68873.2 ; R68873.2 186.38,114.42 186.55,114.26 186.55,114 186.86,113.69 188.01,113.69 189.78,111.91 189.78,110.64 189.4,110.26 188.26,110.26 v2(188.13,110.13) 187.24,109.24 187.24,108.86 185.08,106.7 185.08,102.77 185.97,101.88 190.66,101.88 191.8,100.73 192.45,100.73 v1(193.57,99.62) ; R68873.2 185.83,114.42 185.7,114.55 U36.1
  IN1 w0.089: v1(122.35,95.78) 122.35,95.91 122.47,96.03 137.16,96.03 137.38,95.81 143.53,95.81 144.83,94.51 200.69,94.51 201.81,93.4 201.95,93.4 v2(202.23,93.11)
  IN4 w0.089: v1(122.35,95.78) 122.35,96.92 121.2,98.07 120.31,98.07 117.75,100.63 115.26,100.63 114.17,101.72 106.17,101.72 104.53,103.36 104.22,103.36 103.7,103.88 103.7,104.19 100.5,107.39 100.5,108.48 99.87,109.12 97.71,109.12 94.91,111.91 94.91,115.34 99.64,120.06 99.64,121.21 100.2,121.76 100.2,124.56 101.65,126.01 102.36,126.01 v1(102.64,125.73) ; v2(202.23,93.11) 198.55,96.8 195.88,96.8 193.85,98.83 193.85,99.34 v1(193.57,99.62)
  BOTTOM w0.102: v1(102.64,125.73) 102.56,125.73 102.15,125.31 U6539.DL49 101.98,124.91 101.75,125.14 100.59,125.14 100.41,125.32 99.96,125.32 99.58,124.94 98.75,124.94 97.45,123.64 97.45,123.34 97.33,123.21 96.39,123.21 95.68,122.5 94.61,122.5 R68472.2
MODEM_CLKREQ_L: length 19
  TOP w0.114: R68873.1 185.69,113.97 185.08,114.58 185.08,117.62 185.29,117.83 185.29,120.88 185.58,121.17 186.42,121.17 v1(186.91,120.67) 186.91,120.09 v2(186.81,119.98) 186.58,119.75 R678.1 186.58,118.71 187,118.29 U36.4
  IN1 w0.089: v1(188.87,121.56) 188.13,121.56 187.75,121.18 187.42,121.18 v1(186.91,120.67)
  BOTTOM w0.114: CN17.14 189.68,120.4 188.87,121.21 v1(188.87,121.56)
MX0: length 49
  TOP w0.114: v2(186.23,100.23) 186.23,99.89 v2(186.51,99.62) 186.51,99.36 186.2,99.05 C725.1 ; U37.58 163.46,96.35 164.68,97.58 164.68,98.68 163.72,99.64 163.72,100.46 162.27,101.91 162.27,103.8 v2(162.38,103.91)
  IN3 w0.102: v2(162.38,103.91) 162.2,103.73 162.2,101.54 163.28,100.46 166.31,100.46 167.27,101.42 172.78,101.42 173.24,101.88 181.95,101.88 183.26,100.56 185.56,100.56 v2(186.51,99.62)
  BOTTOM w0.114: v2(186.51,99.62) 187.05,100.15 CN18.10 ; v2(162.38,103.91) 162.38,104.91 159.56,107.73 159.56,108.86 159.4,109.02 CN19.10
MX1: length 48.6
  TOP w0.114: C727.1 187.11,99.05 v2(187.68,99.62) 187.68,99.67 187.45,99.89 187.45,100.78 v2(187.24,100.99) ; U37.59 163.86,96.38 164.95,97.47 164.95,98.79 164,99.73 164,100.56 162.73,101.83 v2(162.73,102.5)
  IN3 w0.102: v2(162.73,102.5) 162.73,101.87 163.92,100.68 165.96,100.68 166.92,101.65 172.69,101.65 173.14,102.1 182.04,102.1 183.36,100.79 185.66,100.79 186.23,100.23 187.12,100.23 187.68,99.67 v2(187.68,99.62)
  BOTTOM w0.114: v2(162.73,102.5) 162.73,103.22 162.84,103.32 162.84,104.82 160.55,107.11 160.55,108.89 160.4,109.04 CN19.9 ; v2(187.68,99.62) 188.05,99.98 CN18.9
MX2: length 47.4
  TOP w0.114: U37.60 164.26,96.4 165.22,97.36 165.22,98.9 164.28,99.83 164.28,100.71 163.21,101.78 v2(163.21,102) ; v2(188.39,100.35) 188.39,99.67 v2(188.34,99.62) 188.34,99.41 187.98,99.05 C723.1
  IN3 w0.102: v2(188.34,99.62) 187.47,100.48 186.36,100.48 185.82,101.02 183.45,101.02 182.14,102.33 172.97,102.33 172.51,101.88 166.83,101.88 165.86,100.91 164.3,100.91 v2(163.21,102)
  BOTTOM w0.114: v2(163.21,102) 163.21,102.67 163.11,102.77 163.11,104.93 160.83,107.21 160.83,108.73 161.4,109.31 CN19.8 ; v2(188.34,99.62) 189.05,100.32 CN18.8
MX3: length 50.9
  TOP w0.114: C722.1 188.87,99.05 189,99.18 v2(189,99.62) 189,99.69 189.4,100.1 v2(189.4,101.24) ; U37.61 164.66,96.42 165.48,97.25 165.48,99.01 164.56,99.93 164.56,100.91 163.68,101.79 v2(163.68,102.51)
  IN3 w0.102: v2(163.68,102.51) 163.68,101.89 164.43,101.14 165.77,101.14 167.49,102.87 170.91,102.87 171.39,102.38 171.7,102.38 172.46,103.15 173.85,103.15 174.44,102.56 182.23,102.56 183.54,101.25 185.97,101.25 186.49,100.73 188.01,100.73 189,99.74 v2(189,99.62)
  BOTTOM w0.114: CN19.7 162.4,109.54 162,109.14 161.62,109.14 161.09,108.62 161.09,107.32 163.37,105.04 163.37,102.89 163.68,102.58 v2(163.68,102.51) ; CN18.7 190.05,100.23 189.92,100.1 189.48,100.1 v2(189,99.62)
MX4: length 50.5
  TOP w0.114: U37.62 165.06,96.45 165.75,97.14 165.75,99.12 164.84,100.03 164.84,101.24 164.14,101.94 v2(164.14,102.04) ; C720.1 v2(189.66,99.62) 190.16,100.12 v2(190.16,100.23)
  IN3 w0.102: v2(164.14,102.04) 164.14,101.99 164.76,101.37 165.68,101.37 167.4,103.1 171.04,103.1 171.47,102.66 171.65,102.66 172.39,103.4 173.92,103.4 174.53,102.79 182.32,102.79 183.64,101.48 186.12,101.48 186.61,100.99 188.29,100.99 v2(189.66,99.62)
  BOTTOM w0.114: CN19.6 163.4,109.55 162.71,108.86 161.72,108.86 161.36,108.51 161.36,107.43 164.26,104.54 164.26,104.11 164,103.86 164,103.03 164.14,102.89 v2(164.14,102.04) ; CN18.6 191.05,100.34 190.8,100.09 190.49,100.09 190.01,99.62 v2(189.66,99.62)
MX5: length 49.9
  TOP w0.114: C726.1 190.55,99.46 190.67,99.59 v2(190.67,99.62) 190.67,99.74 191.28,100.35 v2(191.43,100.35) ; U37.63 165.46,96.47 166.02,97.03 166.02,99.23 165.12,100.12 165.12,101.35 164.65,101.83 164.65,102.47 v2(164.61,102.51)
  IN3 w0.102: v2(190.67,99.62) 190.37,99.92 190.36,99.92 189.04,101.24 186.74,101.24 186.27,101.7 185.26,101.7 183.94,103.02 174.62,103.02 173.93,103.71 171.44,103.71 171.05,103.32 167.3,103.32 165.58,101.6 164.86,101.6 164.61,101.85 v2(164.61,102.51)
  BOTTOM w0.114: v2(190.67,99.62) 191.33,99.62 191.78,100.06 191.9,100.06 192.05,100.2 CN18.5 ; CN19.5 164.4,109.35 165.02,108.73 165.02,107.67 164.51,107.16 164.51,105.81 165.3,105.03 165.3,104.24 164.97,103.91 164.97,103.22 164.61,102.86 v2(164.61,102.51)
MX6: length 52.3
  TOP w0.114: v2(165.11,102.04) 165.4,101.75 165.4,100.22 166.28,99.34 166.28,96.92 165.86,96.49 U37.64 ; v2(192.04,99.62) 191.71,99.62 191.43,99.34 C721.1
  IN3 w0.102: v2(192.04,99.62) 192.04,100.38 190.93,101.5 186.86,101.5 186.43,101.93 185.41,101.93 184.09,103.25 174.72,103.25 174.03,103.94 171.35,103.94 170.96,103.55 167.21,103.55 165.7,102.04 v2(165.11,102.04)
  BOTTOM w0.114: CN18.4 193.05,100.3 192.84,100.09 192.52,100.09 v2(192.04,99.62) ; v2(165.11,102.04) 165.07,102.08 165.07,102.77 165.35,103.04 166.19,103.04 166.8,103.65 166.8,106.7 166.42,107.08 165.78,107.08 165.3,107.57 165.3,109.01 165.4,109.12 CN19.4 165.4,111.18 165.13,111.45 TP13180.1
MX7: length 51.2
  TOP w0.114: U37.65 166.71,97.14 166.55,97.3 166.55,99.45 165.73,100.27 165.73,102.38 v2(165.54,102.58) ; C724.1 192.42,99.05 192.7,99.34 v2(192.7,99.62)
  IN3 w0.102: v2(165.54,102.58) 165.91,102.58 167.12,103.78 170.86,103.78 171.25,104.17 174.12,104.17 174.81,103.48 186.56,103.48 186.74,103.65 187.88,103.65 188.51,103.02 190.8,103.02 191.18,102.64 191.18,101.88 192.7,100.35 v2(192.7,99.62)
  BOTTOM w0.114: CN18.3 194.05,100.2 193.92,100.07 193.24,100.07 192.78,99.62 v2(192.7,99.62) ; v2(165.54,102.58) 166.23,102.58 167.1,103.45 167.1,108.52 166.4,109.23 CN19.3 TP13181.1
MY0: length 50.6
  TOP w0.114: v2(171.62,99.62) 172.03,99.21 C719.1 ; U37.36 154.66,96.34 154.88,96.57 154.88,97.2 156.26,98.57 156.26,99.39 v1(156.18,99.46)
  BOTTOM w0.114: CN19.26 143.4,109.5 143.55,109.34 143.74,109.34 146.1,106.99 146.1,103.65 148.25,101.5 148.25,100.48 148.69,100.05 155.29,100.05 155.62,99.72 156,99.72 156.18,99.54 v1(156.18,99.46) 156.18,99.29 157.6,97.86 162.46,97.86 163.17,98.57 164.06,98.57 164.64,97.99 164.64,97.65 165.2,97.09 168.11,97.09 169.57,98.55 169.57,98.75 169.05,99.26 168.86,99.26 168.02,100.11 168.02,101.59 168.3,101.87 170.05,101.87 170.3,101.62 170.94,101.62 171.04,101.51 CN18.26 171.04,100.22 171.6,99.67 171.6,99.64 v2(171.62,99.62)
MY1: length 45.1
  TOP w0.114: U37.37 155.06,96.36 155.16,96.47 155.16,97.1 156.79,98.73 v1(156.79,99.46) ; v2(172.28,99.62) 172.28,99.51 172.74,99.05 C716.1
  BOTTOM w0.114: v2(172.28,99.62) 172.26,99.64 172.26,99.92 172.04,100.13 CN18.25 172.04,101.65 171.75,101.95 170.44,101.95 170.17,102.22 170.17,102.37 169.71,102.82 168.56,102.82 166.24,100.51 164.73,100.51 162.37,98.15 157.82,98.15 156.79,99.18 v1(156.79,99.46) 156.79,99.82 156.59,100.02 155.7,100.02 155.39,100.33 152.6,100.33 150.41,102.51 148.76,102.51 148.25,103.02 148.25,105.29 144.4,109.14 CN19.25
MY2: length 45.6
  TOP w0.114: U37.38 155.46,96.89 157.4,98.83 v1(157.4,99.46) ; C717.1 173.45,99.03 172.94,99.54 v2(172.94,99.62)
  BOTTOM w0.114: v2(172.94,99.62) 173.04,99.72 CN18.24 173.04,101.51 172.42,102.13 172.26,102.13 171.9,102.49 171.34,102.49 170.74,103.09 168.45,103.09 166.13,100.78 164.62,100.78 162.26,98.42 158.07,98.42 157.4,99.08 v1(157.4,99.46) 157.4,99.72 156.83,100.29 155.84,100.29 154.63,101.5 151.94,101.5 150.62,102.82 150.06,102.82 149.37,103.5 149.37,105.97 147.24,108.1 145.82,108.1 145.23,108.69 145.23,109.27 145.4,109.43 CN19.24
MY3: length 46.5
  TOP w0.114: v2(174.66,99.62) 174.62,99.58 C708.1 ; U37.39 155.86,96.82 158.01,98.96 v1(158.01,99.46)
  BOTTOM w0.114: v2(174.66,99.62) 174.04,100.23 CN18.23 174.04,101.61 173.91,101.75 173.59,101.75 173.27,102.07 173.27,102.64 172.64,103.27 172.38,103.27 171.88,102.77 171.45,102.77 170.85,103.36 168.34,103.36 166.02,101.04 164.51,101.04 162.15,98.68 158.56,98.68 158.01,99.23 v1(158.01,99.46) 158.01,99.74 157.2,100.56 155.95,100.56 154.71,101.8 152.14,101.8 150.85,103.1 150.16,103.1 149.65,103.6 149.65,106.07 147.34,108.38 146.41,108.38 146.18,108.61 146.18,109.18 146.4,109.39 CN19.23
MY4: length 45.1
  TOP w0.114: v1(158.62,99.46) 158.62,99.2 156.26,96.84 U37.40 ; C718.1 175.36,99.58 v2(175.32,99.62)
  BOTTOM w0.114: v2(175.32,99.62) 175.04,99.89 CN18.22 175.04,101.62 174.92,101.75 174.34,101.75 v2(173.81,102.28) 173.81,102.61 172.64,103.78 171.27,103.78 171.11,103.62 168.23,103.62 165.91,101.31 164.4,101.31 162.04,98.95 159.06,98.95 158.62,99.39 v1(158.62,99.46) 158.62,99.64 157.44,100.82 156.07,100.82 154.82,102.07 152.26,102.07 150.87,103.45 150.87,105.36 147.79,108.44 147.79,109.1 147.4,109.49 CN19.22
MY5: length 43.2
  TOP w0.114: U37.41 156.66,96.86 158.32,98.52 159,98.52 159.23,98.75 v1(159.23,99.46) ; C707.1 176.09,99.5 v2(175.98,99.62)
  IN3 w0.102: v1(159.23,99.46) 159.86,98.83 161.79,98.83 162.17,98.45 164.51,98.45 164.89,98.07 169.21,98.07 170.1,98.96 175.56,98.96 175.98,99.37 v2(175.98,99.62)
  BOTTOM w0.114: CN19.21 148.4,109.43 148.85,108.98 148.85,108.14 151.15,105.84 151.15,103.57 152.39,102.33 154.94,102.33 156.18,101.09 158.06,101.09 159.23,99.92 v1(159.23,99.46) ; CN18.21 176.04,99.68 v2(175.98,99.62)
MY6: length 55.8
  TOP w0.114: C706.1 177.82,99.52 v2(177.9,99.59) 177.9,100.15 v2(177.26,100.78) ; U37.42 157.06,96.88 158.43,98.25 159.75,98.25 160.32,98.83 160.32,99.72 160.07,99.97 159.85,99.97 159.59,100.23 158.49,100.23 v2(157.14,101.57)
  IN3 w0.102: v2(157.14,101.57) 155.49,99.92 155.49,98.95 156.41,98.04 161.03,98.04 161.79,97.28 165.42,97.28 165.7,97.56 169.44,97.56 170.38,98.49 177.11,98.49 177.9,99.28 v2(177.9,99.59)
  BOTTOM w0.114: v2(177.9,99.59) 177.33,99.59 177.04,99.88 CN18.20 ; v2(157.14,101.57) 156.08,101.57 155.05,102.6 152.5,102.6 151.43,103.67 151.43,106.19 149.11,108.51 149.11,109.13 149.4,109.42 CN19.20
MY7: length 57
  TOP w0.114: v2(157.81,101.57) 158.85,100.53 159.68,100.53 159.92,100.3 160.19,100.3 160.7,99.79 160.7,98.7 159.99,97.99 158.54,97.99 157.46,96.91 U37.43 ; C709.1 v2(178.56,99.62) 178.43,99.74 v2(178.43,100.28)
  IN3 w0.102: v2(157.81,101.57) 157.37,102 156.97,102 155.24,100.28 155.24,98.83 156.26,97.81 160.93,97.81 161.7,97.05 165.51,97.05 165.79,97.33 169.54,97.33 170.47,98.26 177.2,98.26 v2(178.56,99.62)
  BOTTOM w0.114: CN18.19 178.04,100.13 v2(178.56,99.62) ; CN19.19 150.4,109.43 150.08,109.11 150.08,108.44 151.71,106.8 151.71,103.88 152.73,102.87 155.16,102.87 156,102.03 157.57,102.03 157.81,101.8 v2(157.81,101.57)
MY8: length 56.3
  TOP w0.114: U37.44 157.86,96.93 158.65,97.72 160.18,97.72 161.08,98.62 161.08,99.84 160.36,100.57 160.03,100.57 159.79,100.81 159.23,100.81 v2(158.47,101.57) ; C711.1 179.29,99.54 v2(179.22,99.62) 179.22,100.73 179.47,100.99 v2(179.47,101.01)
  IN3 w0.102: v2(179.22,99.62) 178.79,100.05 177.59,100.05 176.27,98.73 170.25,98.73 169.34,97.81 164.76,97.81 164.38,98.19 161.41,98.19 161.21,98.4 156.43,98.4 155.75,99.08 155.75,99.72 157.02,100.99 157.88,100.99 v2(158.47,101.57)
  BOTTOM w0.114: v2(179.22,99.62) 179.04,99.79 CN18.18 ; CN19.18 151.4,108.35 152.06,107.69 152.06,103.91 152.83,103.15 155.27,103.15 156.03,102.38 157.65,102.38 v2(158.47,101.57)
MY9: length 51.2
  TOP w0.114: v2(159.13,101.57) 159.61,101.09 159.89,101.09 160.14,100.83 160.71,100.83 161.44,100.1 161.44,98.55 160.34,97.45 158.76,97.45 158.26,96.95 U37.45 ; C713.1 180.03,99.46 v2(179.88,99.62) 179.88,100.71 v2(180.72,101.55)
  IN3 w0.102: v2(179.88,99.62) 179.22,100.28 173.96,100.28 173.4,99.72 173.4,99.34 173.25,99.18 167.3,99.18 166.97,98.86 162.59,98.86 160.54,100.91 159.79,100.91 v2(159.13,101.57)
  BOTTOM w0.114: CN19.17 152.4,108.23 154.1,106.53 154.1,104.9 153.72,104.52 153.72,103.65 153.96,103.41 155.43,103.41 155.77,103.07 158.84,103.07 159.13,102.79 v2(159.13,101.57) ; CN18.17 180.04,99.78 v2(179.88,99.62)
MY10: length 48
  TOP w0.114: v2(180.54,100.28) v2(180.54,99.62) 180.77,99.39 C714.1 ; U37.46 158.66,96.34 158.57,96.43 158.57,96.88 158.87,97.19 160.71,97.19 161.7,98.18 161.7,100.22 160.82,101.1 160.26,101.1 v2(159.79,101.57)
  IN3 w0.102: v2(180.54,99.62) 179.65,100.5 173.81,100.5 173.35,100.05 167.84,100.05 166.88,99.08 162.69,99.08 160.63,101.14 160.22,101.14 v2(159.79,101.57)
  BOTTOM w0.114: CN19.16 153.4,109.3 153.59,109.12 153.59,107.97 155.49,106.07 155.49,103.78 155.93,103.35 158.94,103.35 159.39,102.9 159.39,101.96 v2(159.79,101.57) ; CN18.16 181.04,100.12 v2(180.54,99.62)
MY11: length 45.5
  TOP w0.114: v2(181.81,100.28) 181.61,100.07 v2(181.61,99.62) 181.66,99.56 C715.1 ; v2(160.45,101.57) 160.73,101.57 161.97,100.33 161.97,98.07 160.89,96.99 160.89,96.53 160.66,96.3 U37.51
  IN3 w0.102: v2(160.45,101.57) 160.52,101.57 162.78,99.31 166.78,99.31 167.74,100.28 173.26,100.28 173.71,100.73 181.02,100.73 181.61,100.15 v2(181.61,99.62)
  BOTTOM w0.114: v2(160.45,101.57) 159.66,102.36 159.66,103.43 158.54,104.54 158.54,105.08 157.3,106.32 155.75,106.32 154.4,107.67 CN19.15 ; v2(181.61,99.62) 182.04,100.06 CN18.15
MY12: length 48.7
  TOP w0.114: U37.52 161.06,96.25 162.24,97.42 162.24,100.44 160.22,102.46 v2(160.22,102.46) ; v2(182.04,101.55) 182.04,100.76 182.42,100.38 182.42,99.74 v2(182.27,99.59) 182.54,99.31 C728.1
  IN3 w0.102: v2(160.22,102.46) 161.16,101.52 161.16,101.26 162.88,99.54 166.69,99.54 167.65,100.5 173.16,100.5 173.62,100.96 181.48,100.96 182.29,100.15 182.29,99.62 v2(182.27,99.59)
  BOTTOM w0.114: v2(182.27,99.59) 182.75,100.07 182.92,100.07 183.05,100.2 CN18.14 ; v2(160.22,102.46) 160.06,102.62 160.06,104.37 159.41,105.02 159.41,105.37 157.96,106.83 156.26,106.83 155.11,107.98 155.11,108.73 155.4,109.02 CN19.14
MY13: length 46.4
  TOP w0.114: U37.53 161.46,96.27 162.5,97.31 162.5,100.55 160.88,102.17 v2(160.88,102.46) ; C729.1 183.43,99.41 183.26,99.59 v2(182.95,99.59)
  IN3 w0.102: v2(182.95,99.59) 182.87,99.67 182.87,99.98 181.66,101.19 173.52,101.19 173.07,100.73 167.55,100.73 166.59,99.77 162.97,99.77 161.48,101.26 161.48,101.52 160.88,102.12 v2(160.88,102.46)
  BOTTOM w0.114: CN19.13 156.4,109.1 156.81,108.68 156.81,108.05 157.53,107.34 158.82,107.34 160.49,105.67 160.49,104.48 160.33,104.32 160.33,103.01 v2(160.88,102.46) ; CN18.13 184.05,100.23 183.92,100.1 183.46,100.1 v2(182.95,99.59)
MY14: length 46.2
  TOP w0.114: v2(185.01,99.62) 184.68,99.29 184.66,99.29 184.32,98.96 C730.1 ; U37.54 161.86,96.29 162.77,97.2 162.77,100.66 161.54,101.89 v2(161.54,102.46)
  IN3 w0.102: v2(185.01,99.62) 184.55,100.07 183.1,100.07 181.76,101.42 173.43,101.42 172.97,100.96 167.46,100.96 166.5,100 163.07,100 161.71,101.35 161.71,102.29 v2(161.54,102.46)
  BOTTOM w0.114: v2(185.01,99.62) 185.05,99.65 CN18.12 ; v2(161.54,102.46) 160.59,103.41 160.59,104.21 160.75,104.37 160.75,105.78 158.87,107.66 158.34,107.66 158.03,107.97 158.03,108.61 157.4,109.24 CN19.12
MY15: length 47.2
  TOP w0.114: C731.1 185.21,98.96 185.67,99.41 v2(185.67,99.62) ; U37.55 162.26,96.32 163.04,97.09 163.04,100.77 162,101.8 162,103.62 v2(161.72,103.91)
  IN3 w0.102: v2(161.72,103.91) 161.97,103.65 161.97,101.44 163.19,100.23 166.4,100.23 167.36,101.19 172.88,101.19 173.33,101.65 181.85,101.65 183.17,100.33 184.95,100.33 v2(185.67,99.62)
  BOTTOM w0.114: v2(161.72,103.91) 161.72,105.19 159.18,107.73 159.18,108.61 158.4,109.38 CN19.11 ; v2(185.67,99.62) 186.05,99.99 CN18.11
MY16: length 45.6
  TOP w0.114: v2(163.52,97.74) 163.52,97.2 162.66,96.34 U37.56 ; C732.1 170.61,99.31 v2(170.3,99.62)
  BOTTOM w0.114: CN18.28 169.04,100.35 169.59,99.8 170.15,99.8 170.28,99.67 170.28,99.64 v2(170.3,99.62) 170.3,99.59 170.33,99.56 170.33,98.55 168.33,96.56 164.69,96.56 v2(163.52,97.74) 163.24,97.74 162.81,97.3 156.13,97.3 154.86,98.57 148.64,98.57 146.22,100.99 146.22,102.51 145.54,103.2 145.54,106.8 143.55,108.78 143.28,108.78 143.07,108.99 141.65,108.99 141.4,109.24 CN19.28
MY17: length 48.9
  TOP w0.114: C733.1 171.32,99.26 v2(170.96,99.62) ; U37.57 163.06,96.36 164.18,97.48 v2(164.18,97.74)
  BOTTOM w0.114: CN19.27 142.4,109.47 142.6,109.27 143.2,109.27 143.4,109.06 143.65,109.06 145.82,106.89 145.82,103.43 146.6,102.65 146.6,101.24 148.13,99.72 155.11,99.72 157.25,97.58 162.56,97.58 163.2,98.23 163.69,98.23 v2(164.18,97.74) 165.09,96.83 168.22,96.83 169.83,98.44 169.83,98.86 169.16,99.53 168.97,99.53 168.29,100.22 168.29,101.48 168.41,101.61 169.92,101.61 170.04,101.48 CN18.27 170.04,100.36 170.31,100.09 170.79,100.09 170.96,99.92 170.96,99.64 170.96,99.64 v2(170.96,99.62)
N12E_SCL: length 9.1
  BOTTOM w0.102: 122.15,179.38 122.81,180.04 124.42,180.04 125.4,181.02 126.05,181.02 126.46,181.43 126.46,182.05 126.3,182.2 126.3,182.92 126.5,183.12 126.5,183.37 126.9,183.77 U8.C9
  BOTTOM w0.114: R367.1 121.81,178.68 121.94,178.81 121.94,179.07 122.15,179.27 122.15,179.38
N12E_SDA: length 9
  BOTTOM w0.102: U8.C8 126.06,183.77 125.62,183.33 125.62,181.57 124.32,180.27 122.6,180.27 122.02,179.7 121.2,179.7 120.89,179.38
  BOTTOM w0.114: R368.1 120.82,179.31 120.89,179.38
NBSWON#: length 142.9
  TOP w0.114: U37.107 161.86,112.31 162.1,112.54 162.61,112.54 162.81,112.75 R25314.1 163.3,112.95 v2(164.03,113.69) ; R720.2 195.24,99.44 v1(195.4,99.59) ; v2(209.24,97.94) 209.07,97.77 C6615.2 209.07,96.9 208.71,96.54 208.71,96.03 208.19,95.52 206.76,95.52 206.29,95.98 v2(206.29,96.42) 206.22,96.49 R67861.2 205.33,97.26 204.62,97.96 v2(204.62,98.04)
  IN1 w0.089: v1(195.4,99.59) 196.16,98.83 197.28,98.83 197.66,98.45 201.09,98.45 201.34,98.19 204.47,98.19 v2(204.62,98.04) ; v2(227.83,112.39) 226.05,110.61 226.05,105.38 221.17,100.5 218.5,100.5 215.52,97.51 209.67,97.51 v2(209.24,97.94)
  IN4 w0.089: v2(164.03,113.69) 164.03,114.22 165.65,115.85 167.81,115.85 168.45,116.48 168.45,117.12 168.7,117.37 172.06,117.37 173.25,118.56 177.01,118.56 178.23,119.78 180.89,119.78 181.4,120.29 181.4,123.47 181.68,123.75 184.81,123.75 186.23,122.32 191.31,122.32 192.44,123.46 arc(192.45,123.46) 192.46,123.47 193.34,123.47 194.36,124.48 201.98,124.48 202.48,124.99 203.75,124.99 204.71,124.04 204.71,122.77 205.53,121.94 206.8,121.94 208.45,120.29 221.03,120.29 222.88,118.44 224.28,118.44 224.96,117.75 224.96,113.69 226.26,112.39 v2(227.83,112.39)
  BOTTOM w0.114: v2(164.03,113.69) 164.03,113.46 163.62,113.05 C96346.1 ; v2(209.24,97.94) 209.35,98.05 CN52.4 ; SW5.1 232.93,113.81 230.81,113.81 SW5.2 228.84,113.4 v2(227.83,112.39)
NBSWON#_R: length 46.2
  TOP w0.114: v2(167.74,111.27) 168.56,112.09 169.51,112.09 170.25,112.82 172.03,112.82 172.59,113.38 177.95,113.38 178.99,112.34 179.5,112.34 179.93,111.91 181.66,111.91 v2(181.78,111.78) 182.04,111.53 v2(182.04,110.77) ; D33.2 195.24,97.77 R720.1 196.04,98.6 196.64,99.21 196.64,101.62 v1(196.26,102)
  IN3 w0.102: v2(196.77,106.45) 193.72,106.45 192.24,107.93 186.14,107.93 183.31,110.77 v2(182.04,110.77)
  BOTTOM w0.114: v2(196.77,106.45) 196.77,105.98 196.64,105.86 196.64,102.38 v1(196.26,102) 196.26,101.62 196.05,101.41 CN18.1 ; CN19.1 168.4,110.6 v2(167.74,111.27)
NFC_DWL_REQ: length 10.3
  TOP w0.114: R67563.2 67.96,93.47 v2(68.12,93.62) 68.24,93.75 R67567.2 69.05,94.43 69.4,94.77 Q6558.1
  BOTTOM w0.114: CN58.5 65.7,96.04 v2(68.12,93.62)
NFC_I2C_SCL: length 10.2
  TOP w0.114: R67568.2 64.08,93.24 v2(63.7,93.62) 63.81,93.73 Q6556.1 63.81,95.77 63.66,95.92 R67570.2
  BOTTOM w0.114: CN58.8 64.2,94.12 v2(63.7,93.62)
NFC_I2C_SDA: length 11.4
  TOP w0.114: R67564.2 62.54,94.9 62.37,94.73 Q6559.1 62.91,93.95 63.04,93.82 v2(63.04,93.62) 63.04,93.06 v2(62.91,92.94) 62.83,92.86 R67571.2
  BOTTOM w0.114: v2(63.04,93.62) 63.78,94.36 63.78,98.06 63.7,98.14 CN58.9
NFC_INT: length 11.9
  TOP w0.114: Q6555.1 59.16,94.44 59.05,94.33 v2(59.05,93.62) 59.05,93.16 v2(59.35,92.86) R67561.2
  BOTTOM w0.114: v2(59.05,93.62) 61.13,93.62 62.57,95.06 62.57,98.57 62.7,98.7 CN58.11
NFC_RST#: length 71.4
  TOP w0.114: v1(71.32,107.92) 71.32,107.11 69.08,104.87 69.08,103.55 68.37,102.84 68.37,100.99 v2(67.36,99.97) 66.97,99.59 66.97,98.07 66.62,97.71 R67572.2 66.62,96.31 R67566.1 66.6,95.41 66.59,95.4 Q6557.3
  IN3 w0.089: 112.11,123.34 112.11,125.2 v1(112.66,125.75)
  IN3 w0.102: 112.11,123.34 112.11,121.23 111.68,120.8 111.68,119.76 111.07,119.15 110.15,119.15 109.52,119.78 109.14,119.78 107.87,121.05 102.53,121.05 101.65,120.16 101.01,120.16 100.45,120.72 92.47,120.72 90.57,118.82 82.21,118.82 80.26,116.86 78.71,116.86 76.68,114.83 76.68,114.17 76.3,113.79 75.97,113.79 71.32,109.14 v1(71.32,107.92)
  BOTTOM w0.102: v1(112.66,125.75) 112.83,125.75 U6539.DJ25
NFC_RST#_Q: length 10
  TOP w0.114: R67573.2 65.99,93.47 v2(65.83,93.62) 66.09,93.88 Q6557.1 66.09,95.53 65.82,95.8 R67566.2
  BOTTOM w0.114: v2(65.83,93.62) 65.4,94.05 65.4,98.42 65.2,98.62 CN58.6
NFC_SWP: length 9.6
  TOP w0.114: TP13163.1 58.39,93.16 v2(58.39,93.62)
  BOTTOM w0.114: v2(58.39,93.62) 59.02,94.26 61.01,94.26 61.62,94.87 61.62,98.24 61.7,98.32 CN58.13
NOVRP1: length 2
  TOP w0.114: U6544.25 77.74,112.67 v2(77.57,112.49) 77.39,112.32 R68552.1
NOVRP2: length 1.9
  TOP w0.114: U6544.24 77.33,113.17 77.21,113.05 R68553.1
NOVRP3: length 3.8
  TOP w0.114: U6544.20 80.33,115.97 80.06,116.24 79.34,116.24 79.09,116.49 R69072.1 79.09,116.56 v2(79.09,117.32) 78.4,117.32 R68554.1
NOVRP4: length 2.1
  TOP w0.114: R69002.1 R68557.1 80.56,116.35 80.83,116.09 U6544.19
NTC1N_R: length 42.5
  TOP w0.178: PR7062.2 165.31,143.96 165.52,143.75 v2(165.52,143.23)
  IN2 w0.178: v2(165.52,143.23) 165.52,143.21 166.01,142.72 166.01,142.41 165.7,142.1 164.52,142.1 161.46,139.04 161.46,137.69 159.94,136.17 152.19,136.17 149.09,139.26 143.76,139.26 142.79,140.23 142.79,145.56 142.16,146.2 142.16,148.49 142.03,148.61 141.55,148.61 v1(141.45,148.51)
  BOTTOM w0.178: PR7061.1 165.07,144.12 165.52,143.66 v2(165.52,143.23) ; PR7060.1 141.87,148.51 v1(141.45,148.51)
NV_PLLVDD: length 13.1
  TOP w0.254: C458.2 124.71,190.32 v1(123.94,191.09) 123.49,191.54 122.9,191.54 120.69,193.75 118.74,193.75 117.24,195.25 v2(116.43,195.25) 115.99,195.68 C457.2 115.19,195.68 115.02,195.52 L7.2
  BOTTOM w0.254: v1(123.94,191.09) U8.L6
PBA_FP_PWREN#: length 104.8
  TOP w0.114: R69107.1 171.34,105.38 171.22,105.26 171.22,104.08 171.57,103.73 171.57,102.71 171.27,102.41 170.63,102.41 v2(170.63,102.41)
  IN1 w0.089: v1(113.2,104.16) 113.61,104.57 114.73,104.57 114.88,104.42 116.86,104.42 116.96,104.52 121.66,104.52 123.29,106.14 128.94,106.14 129.07,106.02 132.83,106.02 133.5,105.35 135.73,105.35 136.2,104.89 139.01,104.89 139.52,104.38 145.23,104.38 145.31,104.3 147.88,104.3 148.07,104.11 152.2,104.11 152.41,104.33 155,104.33 155.99,103.34 158.78,103.34 160.56,105.11 163.61,105.11 164.75,103.97 166.21,103.97 167.23,102.96 170.09,102.96 v2(170.63,102.41) 170.98,102.41 171.63,101.76 174.27,101.76 174.82,101.21 192.71,101.21 193.11,101.61 198.77,101.61 199.38,102.22 201.14,102.22 201.85,101.51 205.77,101.51 v2(206.29,102.03)
  BOTTOM w0.114: CN52.11 205.85,101.58 v2(206.29,102.03) ; R609.1 113.05,104.32 v1(113.2,104.16)
PCBEEP_EC: length 201.7
  TOP w0.114: v2(24.13,22.07) 23.4,22.07 v2(23.37,22.1) ; v1(152.57,94.94) 152.57,94.64 152.95,94.26 153.71,94.26 153.86,94.41 U37.34
  IN2 w0.102: v2(23.37,22.1) 23.37,23.98 24.43,25.04 25.92,25.04 28.44,27.56 31.51,27.56 32.42,28.47 32.42,47.91 31.88,48.45 31.88,64.88 32.3,65.3 32.3,77.58 33.86,79.14 33.86,88.34 36.53,91 73.51,91 75.42,92.91 77.06,92.91 78.76,94.61 93.09,94.61 93.5,95.02 95.8,95.02 96.46,94.36 116.61,94.36 117.57,95.32 120.24,95.32 121.2,96.29 123.36,96.29 123.87,95.78 136.7,95.78 137.08,95.4 142.54,95.4 143.43,94.51 152.14,94.51 v1(152.57,94.94)
  BOTTOM w0.114: D6543.2 23.07,21.79 v2(23.37,22.1)
PCH_AZ_CODEC_BITCLK: length 183
  IN3 w0.102: v1(105.53,116.74) 105.05,117.22 103.09,117.22 102.66,116.79 101.06,116.79 99.21,118.64 95.68,118.64 93.9,116.86 84.59,116.86 81.29,113.56 80.03,113.56 75.48,109.01 75.48,108.78 73.53,106.83 70.99,106.83 70.58,106.42 68.12,106.42 65.98,104.29 63.16,104.29 61.69,102.82 60.07,102.82 59.1,103.78 58.47,103.78 57.96,104.29 55.29,104.29 55.16,104.16 51.86,104.16 50.52,102.82 48.51,102.82 47.59,103.73 45.77,103.73 45.44,103.4 38.48,103.4 38.15,103.73 34.31,103.73 31.95,106.09 26.23,106.09 23.79,103.65 23.03,103.65 22.14,102.77 22.14,99.72 20.52,98.09 20.52,89.33 19.6,88.41 19.6,85.85 19.45,85.69 19.45,80.77 18.38,79.7 18.38,75 16.43,73.05 16.43,72.29 15.67,71.52 15.67,67.97 16.43,67.2 16.43,60.58 18.21,58.8 18.21,58.44 18.71,57.93 19.27,57.93 19.73,57.48 19.73,57.17 21.51,55.39 22.14,55.39 22.47,55.72 23.16,55.72 23.69,55.19 24.89,55.19 25.32,54.76 25.32,44.47 28.75,41.04 28.75,38.76 30.02,37.49 30.02,36.6 29.38,35.96 28.37,35.96 27.92,35.52 27.92,35.14 25.95,33.17 v2(25.95,32.68)
  BOTTOM w0.102: R68451.2 105.23,117.27 105.46,117.05 105.46,116.81 v1(105.53,116.74)
  BOTTOM w0.114: v2(25.95,32.68) 25.9,32.63 C587.2 25.04,32.63 24.94,32.53 v2(24.43,32.53) 24.36,32.61 U20.6
PCH_AZ_CODEC_RST#: length 187.6
  IN3 w0.102: v1(104.31,116.74) 103.86,116.28 100.88,116.28 99.03,118.13 95.93,118.13 93.75,115.95 85.43,115.95 82.41,112.93 80.08,112.93 76.12,108.96 76.12,108.73 73.73,106.35 71.19,106.35 70.79,105.94 68.32,105.94 64.71,102.33 59.2,102.33 58.69,102.85 55.84,102.85 55.01,103.68 52.12,103.68 50.77,102.33 48.23,102.33 47.32,103.25 46.02,103.25 45.66,102.89 38.12,102.89 37.76,103.25 34.11,103.25 31.75,105.61 26.89,105.61 25.83,104.54 25.83,103.4 25.17,102.74 25.17,99.69 24.43,98.96 22.4,98.96 21.2,97.76 21.2,89.33 20.09,88.21 20.09,81.89 19.93,81.74 19.93,80.46 18.87,79.4 18.87,74.6 16.94,72.67 16.94,72.03 16.17,71.27 16.17,69.49 16.51,69.16 16.51,68.02 16.94,67.59 16.94,60.75 17.72,59.97 17.93,59.97 20.97,56.92 22.65,56.92 23.9,55.67 25.29,55.67 25.95,55.01 25.95,44.52 29.38,41.09 29.38,38.88 30.53,37.74 30.53,35.71 29.95,35.14 29.32,35.14 27.22,33.04 v2(26.97,33.04)
  IN4 w0.089: v1(27.15,29.64) 26.87,29.92 26.87,32.94 v2(26.97,33.04)
  BOTTOM w0.102: v1(104.31,116.74) 104.21,116.83 R68454.2
  BOTTOM w0.114: v2(26.97,33.04) 27.6,33.04 27.73,32.92 27.73,32.41 27.99,32.15 29.64,32.15 30.18,31.61 30.18,31.33 v4(30.3,31.21) 30.37,31.14 31.03,31.14 31.81,30.36 Q21.1 ; R738.1 27.26,29.75 v1(27.15,29.64)
PCH_AZ_CODEC_SDIN0: length 185.8
  IN3 w0.102: v2(25.95,31.39) 26.08,31.39 26.21,31.26 27.48,31.26 27.99,31.77 27.99,32.53 29.45,33.99 30.08,33.99 31.29,35.2 31.29,38.76 30.53,39.52 30.53,42.82 27.1,46.25 27.1,54.96 25.58,56.47 24.24,56.47 23.03,57.68 21.31,57.68 19.35,59.64 19.35,61.11 18.59,61.87 18.59,67.46 17.9,68.14 17.9,68.45 17.77,68.58 17.77,72.35 19.55,74.14 19.55,78.89 21.56,80.9 21.56,85.55 20.77,86.33 20.77,87.63 21.92,88.77 21.92,95.93 22.91,96.92 23.54,96.92 25.9,99.29 25.9,102.43 26.59,103.12 26.59,104.19 27.27,104.87 31.49,104.87 33.8,102.56 37.21,102.56 37.59,102.18 45.06,102.18 45.59,101.65 51.25,101.65 51.77,102.16 58.31,102.16 58.82,101.65 65.17,101.65 68.7,105.18 71.01,105.18 71.47,105.64 74.16,105.64 77.01,108.48 77.01,108.86 78.84,110.69 80.23,110.69 81.71,112.16 82.72,112.16 85.77,115.21 94.41,115.21 96.44,117.24 98.93,117.24 100.68,115.49 106.24,115.49 106.98,116.23 107.23,116.23 v1(107.74,116.74)
  BOTTOM w0.102: v1(107.74,116.74) 107.36,117.12 107.36,117.67 107.11,117.93 107.11,118.49 107.64,119.02 107.64,120.67 107.49,120.82 107.49,121.5 U6539.DV37 ; v2(25.95,31.39) R69059.2
PCH_AZ_CODEC_SDOUT: length 184.4
  IN3 w0.102: v2(27.35,32.03) 27.48,32.15 27.48,32.53 29.38,34.44 30.02,34.44 31.03,35.46 31.03,38.5 30.14,39.39 30.14,42.69 26.72,46.12 26.72,54.98 25.51,56.18 24.15,56.18 22.91,57.43 21.23,57.43 19.1,59.56 19.1,60.98 18.36,61.72 18.36,67.31 17.67,67.99 17.67,68.35 17.52,68.5 17.52,72.51 19.32,74.32 19.32,79.02 21.2,80.9 21.2,82.41 20.54,83.07 20.54,87.91 21.68,89.04 21.68,97.35 22.59,98.26 24.49,98.26 25.67,99.44 25.67,102.54 26.33,103.2 26.33,104.29 27.17,105.13 31.57,105.13 33.9,102.79 37.38,102.79 37.76,102.41 45.23,102.41 45.76,101.88 51.05,101.88 52.34,103.17 54.76,103.17 55.54,102.39 58.46,102.39 58.97,101.88 65.02,101.88 68.58,105.43 70.94,105.43 71.39,105.89 74.04,105.89 76.75,108.61 76.75,108.94 80.26,112.44 82.61,112.44 85.63,115.47 94.05,115.47 96.21,117.62 98.88,117.62 100.78,115.72 105.96,115.72 106.98,116.74 v1(107.11,116.74)
  BOTTOM w0.102: R68453.2 106.7,117.65 107.11,117.24 v1(107.11,116.74)
  BOTTOM w0.114: v2(27.35,32.03) 26.82,32.56 26.69,32.56 26.51,32.74 26.51,32.97 v4(26.36,33.12) 26.31,33.17 25.57,33.17 25.44,33.03 24.07,33.03 24.05,33.01 U20.5
PCH_AZ_CODEC_SYNC: length 186.4
  IN3 w0.102: v1(25.04,30.5) 25.04,31.37 25.52,31.85 26.13,31.85 26.33,31.65 26.72,31.65 26.89,31.82 26.89,32.33 29.32,34.76 29.9,34.76 30.78,35.63 30.78,38.12 29.76,39.14 29.76,41.17 26.33,44.6 26.33,55 25.41,55.92 24.03,55.92 22.78,57.17 21.1,57.17 18.84,59.43 18.84,60.86 18.13,61.57 18.13,67.15 17.44,67.84 17.44,68.22 17.29,68.37 17.29,69.14 16.48,69.95 16.48,71.07 17.19,71.78 17.19,72.51 19.1,74.42 19.1,79.27 20.98,81.15 20.98,82.32 20.32,82.98 20.32,88.06 21.43,89.18 21.43,97.48 22.52,98.57 24.43,98.57 25.42,99.56 25.42,102.64 26.08,103.3 26.08,104.42 27.02,105.36 31.67,105.36 34.01,103.02 37.51,103.02 37.88,102.65 45.35,102.65 45.89,102.1 50.92,102.1 52.24,103.43 54.88,103.43 55.69,102.62 58.59,102.62 59.1,102.1 64.84,102.1 68.44,105.7 70.87,105.7 71.29,106.12 73.88,106.12 76.47,108.71 76.47,108.99 80.18,112.7 82.5,112.7 85.5,115.69 93.87,115.69 96.06,117.88 98.95,117.88 100.78,116.05 105.79,116.05 106.88,117.14 107.13,117.14 v1(107.74,117.75)
  BOTTOM w0.102: R68452.2 107.42,117.95 107.61,117.75 v1(107.74,117.75)
  BOTTOM w0.114: U20.10 23.93,31.01 24.43,30.5 v1(25.04,30.5)
PCH_BLON_C: length 6
  BOTTOM w0.114: Q6521.5 85.04,189.22 84.78,189.48 v2(84.78,189.81) 84.58,190.01 R25369.1 ; R440.2 83.79,191.92 84.12,191.59 84.12,191.59 84.25,191.47 84.41,191.31 R25366.2 84.41,190.86 84.17,190.62 84.17,190.49 84.09,190.41 R25369.1 ; R25369.1 84.09,189.55 83.78,189.24 R25365.2
PCH_BLON_EC: length 260
  TOP w0.114: v2(209.72,121.43) 210.26,120.89 v2(210.26,120.42) 210.26,119.24 211.98,117.52 211.98,111.81 212.19,111.6 212.19,109.04 v2(207.56,104.42) ; U37.88 166.47,106.34 166.37,106.45 v1(166.26,106.45)
  IN1 w0.089: v1(166.26,106.45) 166.41,106.6 173.03,106.6 176.13,103.5 181.5,103.5 185.21,107.21 197.66,107.21 198.17,106.7 198.17,104.42 198.31,104.28 207.42,104.28 v2(207.56,104.42)
  IN3 w0.102: v2(209.72,121.43) 205.29,121.43 arc(205.28,121.43) 205.27,121.42 204.48,120.63 arc(204.47,120.63) 204.46,120.62 191.37,120.62 191.1,120.36 189.22,120.36 188.49,119.63 184.89,119.63 184.45,120.07 182.3,120.07 181.32,121.05 179.56,121.05 178.24,122.37 170,122.37 169.24,121.61 167.41,121.61 167.2,121.82 165.65,121.82 164.92,121.08 163.82,121.08 163.59,121.31 157.44,121.31 156.66,122.08 156.66,122.37 156.26,122.78 156.26,131.98 155.37,132.86 154.6,132.86 150.62,136.85 144.65,136.85 142.97,138.53 142.97,145.44 141.9,146.5 141.9,150.14 141.24,150.8 141.24,155.47 141.9,156.13 141.9,165 138.35,168.55 135.94,168.55 135.17,167.79 131.62,167.79 131.24,168.17 131.24,170.46 128.09,173.61 124.56,173.61 121.18,176.98 119.38,176.98 118.66,177.7 115.92,177.7 115.06,178.56 115.06,179.07 115.51,179.52 115.51,181.23 114.73,182.01 114.73,184.05 113.71,185.06 113.71,185.44 113,186.15 103.73,186.15 102.79,187.09 97.84,187.09 97.58,186.84 97.58,185.06 96.69,184.17 95.55,184.17 94.18,185.54 94.18,186.48 93.72,186.94 93.72,188.67 91.36,191.03 87.93,191.03 87.19,191.77 v2(82.72,191.77)
  BOTTOM w0.114: R25366.1 83.2,191.13 83.1,191.03 82.98,191.03 82.72,191.28 v2(82.72,191.77)
