# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN14-3X2-4-11P-0_8H
  custom 0.125x0.125 smd: 1(-1.2,-0.9) 6(0.8,-0.9) 8(1.2,0.9) 13(-0.8,0.9)
  rect 0.203x0.508 smd: 3(-0.4,-0.9) 4(0,-0.9) 5(0.4,-0.9) 10(0.4,0.9) 11(0,0.9) 12(-0.4,0.9)
  rect 2.591x0.889 smd: 15(0,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
DSUB-DHR4U-15K1202-15P
  round 0.965 hole 0.711: 1(-4.58,-0.7) 2(-2.29,-0.7) 3(0,-0.7) 4(2.29,-0.7) 5(4.58,-0.7) 6(-5.725,-0.7) 7(-3.435,-0.7) 8(-1.145,-0.7) 9(1.145,-0.7) 10(3.435,-0.7)
  round 0.991 hole 0.711: 11(-4.58,0.7) 12(-2.29,0.7) 13(0,0.7) 14(2.29,0.7) 15(4.58,0.7)
  oval 1.194x3.099 hole 0.61x2.489: 16(-8.6,0) 17(8.6,0)
ESD10-2_5X1-5-9P-AZ1143
  rect 0.254x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.381x1.549 smd: 3(0,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
FILTER-NFG0QHB372HS2D-4P-SMT
  rect 0.203x0.229 smd: 1(-0.199,0.225) 2(0.199,0.225) 3(0.199,-0.225) 4(-0.199,-0.225)
FPC-50506-0060N-V01-6P-L
  rect 0.305x0.889 smd: 1(-1.25,3.05) 2(-0.75,3.05) 3(-0.25,3.05) 4(0.25,3.05) 5(0.75,3.05) 6(1.25,3.05)
  rect 0.991x2.007 smd: 7(-3.35,0) 8(3.35,0)
FPC-51540-02201-V01-22P-L
  rect 0.305x0.838 smd: 1(-5.25,3.175) 2(-4.75,3.175) 3(-4.25,3.175) 4(-3.75,3.175) 5(-3.25,3.175) 6(-2.75,3.175) 7(-2.25,3.175) 8(-1.75,3.175) 9(-1.25,3.175) 10(-0.75,3.175) 11(-0.25,3.175) 12(0.25,3.175) 13(0.75,3.175) 14(1.25,3.175) 15(1.75,3.175) 16(2.25,3.175) 17(2.75,3.175) 18(3.25,3.175) 19(3.75,3.175) 20(4.25,3.175) 21(4.75,3.175) 22(5.25,3.175)
  rect 0.787x2.007 smd: 23(-6.95,0) 24(6.95,0)
H-C87D87N
  round 2.21 hole 2.21 unplated: (0,0)
H-C106X87D106X87N
  oval 2.692x2.21 hole 2.692x2.21 unplated: (0,0)
H-C315D118P2
  round 8.001 hole 2.997: 1(0,0)
H-C354D177P2
  round 8.992 hole 4.496: 1(0,0)
H-S157D157N
  rect 3.988x3.988 hole 3.988 unplated: (0,0)
H-TBC236IC166D126P2
  round 5.994 hole 3.2: 1(0,0)
H-TBC244IC166D126P2
  round 6.198 hole 3.2: 1(0,0)
H-TBC264IC146D146P2
  round 6.706 hole 3.708: 1(0,0)
H-TBC354IC158D118P2
  round 8.992 hole 2.997: 1(0,0)
H-TC354IC158BC315D118P2
  round 8.992 hole 2.997: 1(0,0)
H-Z8I-1P2
  custom 2x2 hole 2.997: 1(0,0)
H-Z8IA-1P2
  round 8.992 hole 2.997: 1(0,0)
H-Z8IA-5P2
  round 8.992 hole 2.997: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3_2X2_5-3_2
  rect 1.194x2.007 smd: 1(-1.6,0) 2(1.6,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3H
  rect 1.854x3.505 smd: 1(-2.775,0) 2(2.775,0)
LGA12-2X2-5-1H
  rect 0.279x0.406 smd: 1(-0.75,-0.815) 2(-0.25,-0.815) 3(0.25,-0.815) 4(0.75,-0.815) 7(0.75,0.815) 8(0.25,0.815) 9(-0.25,0.815) 10(-0.75,0.815)
  rect 0.406x0.279 smd: 5(0.815,-0.25) 6(0.815,0.25) 11(-0.815,0.25) 12(-0.815,-0.25)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
MSOP8-4_9-65-G547
  rect 0.356x1.397 smd: 1(-0.975,-2.5) 2(-0.325,-2.5) 3(0.325,-2.5) 4(0.975,-2.5) 5(0.975,2.5) 6(0.325,2.5) 7(-0.325,2.5) 8(-0.975,2.5)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-Z8I-1P2
  custom 1.925x1.925 hole 2.997: 1(0,0)
O-Z8I-2P2
  custom 1.925x1.925 hole 2.997: 1(0,0)
O-Z8IA-B1P2
  round 8.001 hole 2.997: 1(0,0)
O-Z8IA-B2P2
  round 8.001 hole 2.997: 1(0,0)
O-ZI8-3P2
  custom 3.13x3.13 hole 6.096: 1(0,0)
POWER-3X3-65-5P-ADNR21357
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-SLGC55544C
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN17-4X4-5-14P
  rect 1.321x0.61 smd: 1(-1,-1.85) 15(-1,1.85)
  rect 0.305x0.61 smd: 4(0,-1.85) 5(0.5,-1.85) 6(1,-1.85) 12(1,1.85) 13(0.5,1.85) 14(0,1.85)
  rect 0.61x0.305 smd: 7(1.85,-1) 8(1.85,-0.5) 9(1.85,0) 10(1.85,0.5) 11(1.85,1)
  rect 2.972x2.591 smd: 18(-0.187,0)
QFN20-3X3-4-21P-RT6543B
  custom 0.05x0.05 smd: 1(-0.8,-1.475) 5(0.8,-1.475) 6(1.475,-0.8) 10(1.475,0.8) 11(0.8,1.475) 15(-0.8,1.475) 16(-1.475,0.8) 20(-1.475,-0.8)
  rect 0.203x0.838 smd: 2(-0.4,-1.475) 3(0,-1.475) 4(0.4,-1.475) 12(0.4,1.475) 13(0,1.475) 14(-0.4,1.475)
  rect 0.838x0.203 smd: 7(1.475,-0.4) 8(1.475,0) 9(1.475,0.4) 17(-1.475,0.4) 18(-1.475,0) 19(-1.475,-0.4)
  rect 1.702x1.702 smd: 21(0,0)
QFN20-4X4-5-21P-IT8013FN
  rect 0.305x0.991 smd: 1(-1,-2.1) 2(-0.5,-2.1) 3(0,-2.1) 4(0.5,-2.1) 5(1,-2.1) 11(1,2.1) 12(0.5,2.1) 13(0,2.1) 14(-0.5,2.1) 15(-1,2.1)
  rect 0.991x0.305 smd: 6(2.1,-1) 7(2.1,-0.5) 8(2.1,0) 9(2.1,0.5) 10(2.1,1) 16(-2.1,1) 17(-2.1,0.5) 18(-2.1,0) 19(-2.1,-0.5) 20(-2.1,-1)
  rect 2.565x2.565 smd: 21(0,0)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-ALC5629
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.261x2.261 smd: 25(0,0)
QFN24-4X4-5-25P-RT8813D
  custom 0.075x0.075 smd: 1(-1.25,-1.975) 6(1.25,-1.975) 7(1.975,-1.25) 12(1.975,1.25) 13(1.25,1.975) 18(-1.25,1.975) 19(-1.975,1.25) 24(-1.975,-1.25)
  rect 0.305x0.838 smd: 2(-0.75,-1.975) 3(-0.25,-1.975) 4(0.25,-1.975) 5(0.75,-1.975) 14(0.75,1.975) 15(0.25,1.975) 16(-0.25,1.975) 17(-0.75,1.975)
  rect 0.838x0.305 smd: 8(1.975,-0.75) 9(1.975,-0.25) 10(1.975,0.25) 11(1.975,0.75) 20(-1.975,0.75) 21(-1.975,0.25) 22(-1.975,-0.25) 23(-1.975,-0.75)
  rect 2.54x2.54 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN28-5X5-5-29P-GL850G
  rect 0.305x0.991 smd: 1(-1.5,-2.6) 2(-1,-2.6) 3(-0.5,-2.6) 4(0,-2.6) 5(0.5,-2.6) 6(1,-2.6) 7(1.5,-2.6) 15(1.5,2.6) 16(1,2.6) 17(0.5,2.6) 18(0,2.6) 19(-0.5,2.6) 20(-1,2.6) 21(-1.5,2.6)
  rect 0.991x0.305 smd: 8(2.6,-1.5) 9(2.6,-1) 10(2.6,-0.5) 11(2.6,0) 12(2.6,0.5) 13(2.6,1) 14(2.6,1.5) 22(-2.6,1.5) 23(-2.6,1) 24(-2.6,0.5) 25(-2.6,0) 26(-2.6,-0.5) 27(-2.6,-1) 28(-2.6,-1.5)
  rect 3.505x3.505 smd: 29(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-4X4-4-33P-RT8845B
  custom 0.05x0.05 smd: 1(-1.4,-2) 8(1.4,-2) 9(2,-1.4) 16(2,1.4) 17(1.4,2) 24(-1.4,2) 25(-2,1.4) 32(-2,-1.4)
  rect 0.203x0.787 smd: 2(-1,-2) 3(-0.6,-2) 4(-0.2,-2) 5(0.2,-2) 6(0.6,-2) 7(1,-2) 18(1,2) 19(0.6,2) 20(0.2,2) 21(-0.2,2) 22(-0.6,2) 23(-1,2)
  rect 0.787x0.203 smd: 10(2,-1) 11(2,-0.6) 12(2,-0.2) 13(2,0.2) 14(2,0.6) 15(2,1) 26(-2,1) 27(-2,0.6) 28(-2,0.2) 29(-2,-0.2) 30(-2,-0.6) 31(-2,-1)
  rect 2.794x2.794 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN40-6X6-5-41P-0_6H
  rect 0.305x0.991 smd: 1(-2.25,-3.1) 2(-1.75,-3.1) 3(-1.25,-3.1) 4(-0.75,-3.1) 5(-0.25,-3.1) 6(0.25,-3.1) 7(0.75,-3.1) 8(1.25,-3.1) 9(1.75,-3.1) 10(2.25,-3.1) 21(2.25,3.1) 22(1.75,3.1) 23(1.25,3.1) 24(0.75,3.1) 25(0.25,3.1) 26(-0.25,3.1) 27(-0.75,3.1) 28(-1.25,3.1) 29(-1.75,3.1) 30(-2.25,3.1)
  rect 0.991x0.305 smd: 11(3.1,-2.25) 12(3.1,-1.75) 13(3.1,-1.25) 14(3.1,-0.75) 15(3.1,-0.25) 16(3.1,0.25) 17(3.1,0.75) 18(3.1,1.25) 19(3.1,1.75) 20(3.1,2.25) 31(-3.1,2.25) 32(-3.1,1.75) 33(-3.1,1.25) 34(-3.1,0.75) 35(-3.1,0.25) 36(-3.1,-0.25) 37(-3.1,-0.75) 38(-3.1,-1.25) 39(-3.1,-1.75) 40(-3.1,-2.25)
  rect 4.597x4.597 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
QFN48-6X6-4-49P-PS8409
  custom 0.05x0.05 smd: 1(-2.2,-2.975) 2(-1.8,-2.975) 3(-1.4,-2.975) 4(-1,-2.975) 5(-0.6,-2.975) 6(-0.2,-2.975) 7(0.2,-2.975) 8(0.6,-2.975) 9(1,-2.975) 10(1.4,-2.975) 11(1.8,-2.975) 12(2.2,-2.975) 13(2.975,-2.2) 14(2.975,-1.8) 15(2.975,-1.4) 16(2.975,-1) 17(2.975,-0.6) 18(2.975,-0.2) 19(2.975,0.2) 20(2.975,0.6) 21(2.975,1) 22(2.975,1.4) 23(2.975,1.8) 24(2.975,2.2) 25(2.2,2.975) 26(1.8,2.975) 27(1.4,2.975) 28(1,2.975) 29(0.6,2.975) 30(0.2,2.975) 31(-0.2,2.975) 32(-0.6,2.975) 33(-1,2.975) 34(-1.4,2.975) 35(-1.8,2.975) 36(-2.2,2.975) 37(-2.975,2.2) 38(-2.975,1.8) 39(-2.975,1.4) 40(-2.975,1) 41(-2.975,0.6) 42(-2.975,0.2) 43(-2.975,-0.2) 44(-2.975,-0.6) 45(-2.975,-1) 46(-2.975,-1.4) 47(-2.975,-1.8) 48(-2.975,-2.2)
  rect 4.496x4.496 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RC3720-SMT
  rect 3.759x1.016 smd: 1(0,1.008) 2(0,-1.008)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-156-1000302610-11P-SMT
  round 1.194 hole 1.194 unplated: (13.05,17)
  round 0.991 hole 0.991 unplated: (13.05,-2.6)
  rect 0.787x1.397 smd: 1(8.375,21.8) 2(5.875,21.8) 3(3.375,21.8) 4(0.875,21.8) 5(-1.625,21.8) 6(-4.125,21.8) 7(-6.625,21.8) 8(-8.125,21.8) 9(-9.625,21.8) 10(-11.125,21.8) 11(-12.625,21.8)
  rect 2.108x2.489 smd: 12(-14.65,0) 13(14.65,0)
SENSOR-1_3X0_9-5-4P
  rect 0.457x0.254 smd: 1(-0.625,0.25) 2(-0.625,-0.25) 3(0.625,-0.25) 4(0.625,0.25)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-6-1_27-PM25LV010A
  rect 0.533x1.727 smd: 1(-1.905,-2.733) 2(-0.635,-2.733) 3(0.635,-2.733) 4(1.905,-2.733) 5(1.905,2.733) 6(0.635,2.733) 7(-0.635,2.733) 8(-1.905,2.733)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-2_825-95-5P
  rect 0.991x0.711 smd: 1(1.3,-0.95) 2(1.3,0) 3(1.3,0.95) 4(-1.3,0.95) 5(-1.3,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P-G5126TB1U
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT563-1_6-5-6P-PJX138K
  rect 0.457x0.305 smd: 1(0.675,-0.5) 2(0.675,0) 3(0.675,0.5) 4(-0.675,0.5) 5(-0.675,0) 6(-0.675,-0.5)
SSOP28-7_8-65-2H
  rect 0.381x1.651 smd: 1(-4.225,-3.675) 2(-3.575,-3.675) 3(-2.925,-3.675) 4(-2.275,-3.675) 5(-1.625,-3.675) 6(-0.975,-3.675) 7(-0.325,-3.675) 8(0.325,-3.675) 9(0.975,-3.675) 10(1.625,-3.675) 11(2.275,-3.675) 12(2.925,-3.675) 13(3.575,-3.675) 14(4.225,-3.675) 15(4.225,3.675) 16(3.575,3.675) 17(2.925,3.675) 18(2.275,3.675) 19(1.625,3.675) 20(0.975,3.675) 21(0.325,3.675) 22(-0.325,3.675) 23(-0.975,3.675) 24(-1.625,3.675) 25(-2.275,3.675) 26(-2.925,3.675) 27(-3.575,3.675) 28(-4.225,3.675)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-560Q10-010H-24P
  round 0.61 hole 0.61 unplated: (-3.675,0) (3.675,0)
  oval 0.838x2.159 hole 0.559x1.854: 1(-4.925,-0.45) 2(4.925,-0.45)
  oval 0.991x0.711 hole 0.711x0.406: 3(-3.775,-1.1) 4(3.775,-1.1)
  oval 1.041x2.362 hole 0.559x1.854: 5(-5.85,-6.05) 6(5.85,-6.05)
  rect 0.254x0.94 smd: A1(-2.625,0.275) A2(-2.125,0.275) A3(-1.625,0.275) A4(-1.125,0.275) A5(-0.625,0.275) A6(-0.125,0.275) A7(0.375,0.275) A8(0.875,0.275) A9(1.375,0.275) A10(1.875,0.275) A11(2.375,0.275) A12(2.875,0.275)
  rect 0.254x0.838 smd: B1(2.625,-1.375) B2(2.125,-1.375) B3(1.625,-1.375) B4(1.125,-1.375) B5(0.625,-1.375) B6(0.125,-1.375) B7(-0.375,-1.375) B8(-0.875,-1.375) B9(-1.375,-1.375) B10(-1.875,-1.375) B11(-2.375,-1.375) B12(-2.875,-1.375)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
WTB-GS12201-1011-7H-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(-4.75,2.325) 2(-4.25,2.325) 3(-3.75,2.325) 4(-3.25,2.325) 5(-2.75,2.325) 6(-2.25,2.325) 7(-1.75,2.325) 8(-1.25,2.325) 9(-0.75,2.325) 10(-0.25,2.325) 11(0.25,2.325) 12(0.75,2.325) 13(1.25,2.325) 14(1.75,2.325) 15(2.25,2.325) 16(2.75,2.325) 17(3.25,2.325) 18(3.75,2.325) 19(4.25,2.325) 20(4.75,2.325)
  rect 1.295x1.397 smd: 21(-5.8,2.2) 22(5.8,2.2) 23(-5.8,-1.8) 24(5.8,-1.8)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_8-4P
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)

## Nets
1V8_AON_S: PC9057.1 PC9058.1 PR9068.2 PU9002.8
1V8_MAIN_EN: PD1.1(CATHODE) PQ9083.2 PR9072.1 PR9105.1 PR9284.2 R374.2 R403.1
1V8_MAIN_EN_N17: R374.1 U8.F9
8813VID: PR9015.2 PR9017.2 PU9000.5
8813VOUT1: PC9027.1 PC9028.1 PR9028.1 PU9000.11(VSNS)
8813VREF: PC9023.1 PR9021.1 PR9033.2 PU9000.8
+1.0V_PWRGD_G1: C96719.1 Q6589.2 R68487.2 R68488.2 R68494.1
+1.0V_PWRGD_G2: Q6588.2 Q6589.3 R68489.2
+1.2V: PQ9087.1(S) PR9286.1 R68236.1
+1.2V_HDMI: C96555.2 C96556.2 C96557.2 C96558.2 C96559.2 C96566.2 C96567.2 C96568.2 C96569.2 C96570.2 C96571.2 C96572.1 R68236.2 U6537.6 U6537.11 U6537.15(VDDTX12#2) U6537.18 U6537.30 U6537.43 U6537.46
+1.2VSUS: C250.1 C252.1 C254.1 C256.1 C258.1 C260.1 C262.1 C263.1 C267.1 C268.1 C270.1 C272.1 C274.1 C276.1 C277.1 C279.1 C20104.1 C20107.1 C20110.1 C20113.1 C20116.1 C20118.1 C20120.1 C20121.1 C20122.1 C20123.1 C20124.1 C20125.1 C20126.1 C20127.1 C20128.1 C20129.1 C96648.1 C96649.1 C96650.1 C96651.1 C96652.1 C96653.1 C96654.1 C96655.1 C96656.1 C96657.1 C96658.1 C96659.1 C96660.1 C96661.1 C96662.1 C96663.1 C96664.1 C96665.1 C96666.1 C96667.1 C96668.1 C96669.1 C96670.1 C96671.1 C96672.1 C96673.1 C96674.1 C96675.1 C96676.1 C96677.1 C96678.1 C96679.1 C96680.1 C96681.1 C96682.1 C96683.1 C96684.1 C96685.1 C96686.1 C96687.1 C96688.1 C96689.1 C96690.1 C96691.1 C96692.1 C96693.1 C96694.1 C96695.1 C96696.1 EC5.2 EC6.2 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 JDIM02.12 JDIM02.33 JDIM02.54 JDIM02.75 JDIM02.111 JDIM02.112 JDIM02.117 JDIM02.118 JDIM02.123 JDIM02.124 JDIM02.129 JDIM02.130 JDIM02.135 JDIM02.136 JDIM02.141 JDIM02.142 JDIM02.147 JDIM02.148 JDIM02.153 JDIM02.154 JDIM02.159 JDIM02.160 JDIM02.163 JDIM02.178 JDIM02.199 JDIM02.220 JDIM02.241 PC9065.1 PC9066.1 PJ5002.2 PQ9008.5 PQ9087.3 R224.2 R231.2 R232.2 R233.1 R234.1 R235.1 R236.1 R237.1 R238.1 R239.1 R240.1 R241.1 R1684.1 R25602.1 R25603.1 R25604.1 R25605.1 R25606.1 R25607.1 R25608.1 R25609.1 R25610.1 R25611.1 R25612.1 R68252.1 R69022.1 R69023.1 R69024.2 R69025.1 U6539.AA39 U6539.AB40 U6539.AC39 U6539.AD40 U6539.AD51 U6539.AD52 U6539.AE39 U6539.AF40 U6539.AG39 U6539.AH40 U6539.AJ39 U6539.AK40 U6539.AK51 U6539.AK52 U6539.AL39 U6539.AM40 U6539.AN39 U6539.AP40 U6539.AR39 U6539.AT52 U6539.AU40 U6539.AW40 U6539.AW51 U6539.AW52 U6539.BD51 U6539.BD52 U6539.BK51 U6539.BK52 U6539.BV51 U6539.BV52 U6539.CA40 U6539.CC40 U6539.CC49 U6539.CC50 U6539.CE40 U6539.CG40 U6539.CH39 U6539.CJ40 U6539.CL40 U6539.CN40 U6539.CP47 U6539.CR40 U6539.D50 U6539.E51 U6539.F49 U6539.T51 U6539.T52
+1.2VSUS_TEMP: PC5009.1 PC5010.1 PC5011.1 PC5012.1 PC5015.1 PC5016.1 PC5017.1 PJ5002.1 PL5000.2 PR5012.1 PU5001.19
+1.2VSUS_VIN: PC5002.1 PC5003.1 PC5004.1 PC5005.1 PC5007.1 PJ5001.1 PQ5001.5 PR5007.1
+1.5V: PJ3008.2 R449.1 R69076.2
+1.05V_EXT: R68499.1 U6539.DA15 U6539.DA17
+1.05V_LAN: C631.1 C632.1 C633.1 C634.1 C635.1 C636.1 C96304.1 C96305.1 C96311.2 C96312.2 C96922.1 C96923.1 C96924.1 L4000.2 R67598.2 R67599.2 R69018.2 U6521.8 U6521.11 U6521.16 U6521.22 U6521.37 U6521.40 U6521.43
+1.05V_LAN_REGOUT: C20000.1 L4000.1 R69018.1 U6521.7
+1.8V: PQ9.1(S) PR9227.1 Q6651.5 QG15.2 R462.2 R68488.1 R68839.1 R68987.2 R69075.1 R69077.2 R69078.1
+1.8V_DEEP_SUS: C96724.2 C96733.2 R68379.2 R68389.1 R68391.2 R68392.1 R68409.1 R68428.1 R68430.1 R68497.2 R68505.2 R68509.1 R68510.1 R68772.2 R68774.2 R68776.2 R68778.2 R68794.2 R68812.2 R68859.2 U35.5(VCC) U36.5(VCC) U6539.CV39 U6539.CY18 U6539.CY20 U6539.CY24 U6539.CY26 U6539.DA18 U6539.DA20 U6539.DA22 U6539.DA24 U6539.DA26 U6539.DC18 U6539.DC20 U6539.DC22 U6539.DC24 U6539.DC26 U6539.DD20 U6539.DD22 U6539.DV22
+1.8V_S5: C96880.2 CN49.16 PC9053.1 PC9054.1 PJ9005.2 PQ9.3 PU9002.1 PU9002.6 R25317.1 R68796.2 R68812.1 R68988.1
+1.8V_SENSOR: C20141.1 R68987.1 R68988.2 U6516.C1
+1.8V_SM: C20046.1 C20047.2 U6509.15 U6509.16 U6509.17
+1.35V_GFX: C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.1 C485.1 C486.1 C487.1 C488.1 C489.1 C490.1 C491.2 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.1 C501.1 C502.1 C503.1 C504.1 PJ9002.2 PR9099.1 R314.2 R316.1 R318.1 R321.1 R322.1 R407.1 R25284.1 U8.B26 U8.C25 U8.E23 U8.E26 U8.F14 U8.F21 U8.G13 U8.G14 U8.G15 U8.G16 U8.G18 U8.G19 U8.G20 U8.G21 U8.H24 U8.H26 U8.J21 U8.K21 U8.L22 U8.L24 U8.L26 U8.M21 U8.N21 U8.R21 U8.T21 U8.V21 U8.W21 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM2.B1 VRAM2.B3 VRAM2.B12 VRAM2.B14 VRAM2.C5 VRAM2.C10 VRAM2.D1 VRAM2.D3 VRAM2.D11 VRAM2.D12 VRAM2.D14 VRAM2.E5 VRAM2.E10 VRAM2.F1 VRAM2.F3 VRAM2.F12 VRAM2.F14 VRAM2.G1 VRAM2.G2 VRAM2.G4 VRAM2.G11 VRAM2.G13 VRAM2.G14 VRAM2.H3 VRAM2.H12 VRAM2.K3 VRAM2.K12 VRAM2.L1 VRAM2.L2 VRAM2.L4 VRAM2.L11 VRAM2.L13 VRAM2.L14 VRAM2.M1 VRAM2.M3 VRAM2.M12 VRAM2.M14 VRAM2.N5 VRAM2.N10 VRAM2.P1 VRAM2.P3 VRAM2.P11 VRAM2.P12 VRAM2.P14 VRAM2.R5 VRAM2.R10 VRAM2.T1 VRAM2.T3 VRAM2.T12 VRAM2.T14
+1V8_AON: C371.1 C376.1 C378.1 C433.2 PR9018.1 PR9068.1 PR9076.2 Q13.2 Q13.5 Q6512.2 R297.2 R326.2 R330.2 R339.1 R344.2 R345.2 R346.2 R347.2 R348.2 R349.2 R362.2 R364.2 R365.2 R382.2 R391.2 R395.2 R397.2 R399.2 R403.2 R404.2 R25322.2 R25490.2 R25492.2 RG67.1 RG77.1 RG79.1 U8.G10 U8.G12 U9.5(VCC)
+1V8_GFX_MAIN: C360.2 C362.1 C377.2 C379.2 C381.2 C383.2 C392.1 C394.1 C395.1 C398.1 C399.1 C401.1 C402.1 L4.1 L5.1 L6.1 L7.1 L8.1 PR9067.2 PR9085.1 PR9103.1 R299.1 U8.AA10 U8.AA12 U8.AA13 U8.AA16 U8.AA18 U8.AA19 U8.AA20 U8.AA21 U8.AB22 U8.AC23 U8.AD24 U8.AE25 U8.AF26 U8.AF27 U8.G8 U8.G9
+1V8_MAIN_EN_G: PQ9083.3 PQ9084.2 PR9102.2 PR9104.1
+2.5V_SUS: C269.1 C271.1 C273.1 C275.1 C20106.2 C20109.2 C20112.1 C20115.1 JDIM1.257 JDIM1.259 JDIM02.257 JDIM02.259 PJ5000.1
+3V: C278.1 C280.1 C452.2 C546.2 C559.2 C20099.2 C20100.1 C96560.2 CN49.29 CN49.30 EC10.1 EC11.1 JDIM1.255 JDIM02.255 L17.1 L4003.1 PC9099.1 PR106.1 PR5001.1 PR6416.1 PR7040.1 PR7073.1 PR9009.1 PR9075.1 PR9088.1 PR9245.1 PU9006.5(VCC) Q6555.2 Q6556.2 Q6557.2 Q6558.2 Q6559.2 Q6585.2 Q6585.5 Q6612.2 Q6652.2 R225.1 R226.1 R227.1 R378.2 R385.2 R386.2 R439.1 R440.1 R452.2 R455.1 R460.2 R509.1 R576.2 R732.2 R753.1 R1239.1 R2661.2 R2666.2 R25271.2 R25307.1 R25312.2 R25346.1 R25348.2 R25367.2 R25372.1 R25459.1 R25482.1 R25526.2 R25596.1 R25597.2 R25598.1 R25625.2 R67556.1 R67557.1 R67560.1 R67561.1 R67563.1 R67568.1 R67571.1 R67572.1 R67573.1 R67606.2 R67855.1 R67865.1 R67888.1 R68237.1 R68278.1 R68355.1 R68356.1 R68357.1 R68358.1 R68359.1 R68361.2 R68363.2 R68364.1 R68377.1 R68420.2 R68436.1 R68437.1 R68439.1 R68440.1 R68441.1 R68442.1 R68468.1 R68469.1 R68563.1 R68602.1 R68687.1 R68780.1 R68884.2 R68940.1 R69051.2 U11.5 U19.4 U19.5 U67.14
+3V3_TPM: C740.1 C741.1 C742.1 C744.1 R580.2 R25344.2 R25346.2 U33.8 U33.22
+3V3_TPM_VSB: C743.2 C745.2 R25347.1 R25348.1 U33.1(VSB)
+3V_CCD_PWR1_C: CN29.32 CN29.33 R25459.2
+3V_CR: C1650.1 C1652.2 R753.2 U40.4
+3V_DEEP_SUS: C96774.2 Q62.2 Q62.5 Q6616.2 Q6616.5 Q6622.2 Q6624.2 Q6625.2 R36.2 R68247.1 R68248.1 R68346.2 R68347.2 R68348.2 R68349.2 R68350.2 R68351.2 R68365.1 R68366.1 R68367.1 R68368.1 R68369.1 R68378.2 R68380.1 R68382.1 R68388.1 R68390.2 R68418.2 R68419.2 R68463.2 R68485.2 R68496.2 R68506.2 R68507.2 R68511.2 R68513.2 R68516.2 R68518.2 R68520.2 R68522.2 R68525.2 R68527.2 R68529.2 R68531.2 R68536.1 R68537.1 R68538.1 R68539.1 R68544.1 R68545.1 R68728.2 R68789.2 R68927.2 R69019.1 R69091.1
+3V_EC: C1189.1 R25307.2 R25317.2 U37.11
+3V_HDMI: C96561.1 C96562.2 C96563.2 C96564.2 C96565.1 R68203.1 R68204.1 R68210.1 R68216.1 R68217.1 R68218.1 R68219.2 R68237.2 U6537.1 U6537.24
+3V_LAN: C641.1 C642.1 C96300.1 C96301.1 C96302.2 C96303.2 C96308.1 C96309.1 C96310.1 Q6531.2 Q6554.2 Q6554.5 Q6618.2 Q6619.2 Q6620.2 R4023.2 R4024.2 R9340.2 R25445.2 R25617.2 R25618.1 R67474.1 R67475.1 R67509.1 R67510.1 R67511.1 R67512.1 R68924.2 R68929.2 U6521.4 U6521.5(VDDREG) U6521.15 U6521.19 U6521.29
+3V_LDO_EC: C96879.2 D63.1(CATHODE) D13148.1(CATHODE) PD8004.1(CATHODE) PQ8014.1(S) PQ8016.4(E2) PR6017.1 PR8010.2 PR8020.1 Q6606.2 Q6606.5 Q6626.2 Q6627.2 Q6628.2 R359.1 R361.2 R369.2 R383.2 R25300.2 R25304.2 R25306.1 R25309.2 R25314.2 R67484.2 R67485.2 R67486.2 R67487.2 R67604.2 R67871.1 R68795.1 R68799.2 R68802.1 R68803.1 R68804.1 R68813.2 R68814.2 R69012.2
+3V_RTC: C1214.1 C96903.1 D72.3(CATHODE) R971.1 R979.1 R25310.1 R68401.1 R68500.2 R68986.1
+3V_RTC_0: CN1.1 Q28.1(EMITTER) R953.1
+3V_RTC_1: D72.1 R953.2
+3V_RTC_2: D72.2 R978.2
+3V_S5: C96773.2 PC242.1 PC571.1 PC572.1 PR5000.1 PR5020.1 PR7063.1 PR9244.2 PR9255.1 PU3003.4(VIN) PU3004.3(VIN) PU9005.5 Q6600.1(S) Q6638.2 Q6638.5 R101.2 R566.2 R567.2 R574.2 R608.1 R2667.2 R25330.1 R25618.2 R25622.1 R68250.1 R68251.1 R68314.2 R68408.1 R68410.1 R68460.2 R68461.1 R68490.2 R68501.2 R68511.1 R68562.1 R68635.2 R68737.2 R68738.2 R68739.2 R68740.2 R68741.2 R68742.2 R68743.2 R68744.2 R68745.2 R68747.2 R68757.1 R68916.1 R68920.2 R69016.2 R69017.2 R69034.1 R69044.1 R69048.1 R69054.1 R69065.1 R69094.1 U6565.5
+3V_SM: C20041.1 C20043.1 C20048.1 C20049.2 R25555.1 U6509.10 U6509.14 U6509.18
+3V_SPI: C96793.2 C96794.1 R583.2 R586.2 R25344.1 R25347.2 R68591.1 R68592.2 R68789.1 U6546.8 U6547.8 U6548.8(VCC)
+3V_SSD: C785.2 C786.2 C2616.2 CN16.2 CN16.4 CN16.12 CN16.14 CN16.16 CN16.18 CN16.70 CN16.72 CN16.74 EC9.2 R2661.1 R69092.2
+3V_TCSS: C96889.1 C96890.1 C96894.1 C96897.1 C96898.1 R68843.2 R68845.2 R68916.2 R68917.2 U6558.5(VCC) U6559.5(VCC) U6561.5(VCC) U6562.5(VCC) U6563.5(VCC)
+3V_THM: C96269.1 C96271.1 Q6564.2 Q6564.5 R67855.2 R67857.1 R67858.1 R69026.1 R69027.2 U2.1(VCC) U6517.1(VCC)
+3V_USB: C96776.2 C96780.2 C96781.2 C96782.2 C96783.2 C96784.2 C96785.2 C96786.2 R68550.2 R68551.2 R68552.2 R68553.2 R68554.2 R68556.2 R68562.2 R68563.2 R69002.2 U6544.5 U6544.9 U6544.14 U6544.28
+3V_USB_D: R68550.1 U6544.21
+3V_WLAN: Q6600.3 R68756.1
+3V_WLAN_P: C800.1 C801.1 C802.1 C804.1 C805.2 C2609.1 C96344.1 C96871.2 C96872.2 C96873.2 C96876.2 CN17.2 CN17.4 CN17.72 CN17.74 Q33.2 Q63.2 R651.2 R652.2 R671.2 R672.2 R2666.1 R2667.1 R68756.2
+3VLCD_CON: C560.1 C561.1 C562.1 R25458.1 R69073.1 U19.1(VOUT)
+3VLCD_CON_R: C543.2 C544.1 CN29.34 CN29.35 CN29.36 R25456.1 R25458.2
+3VLCD_CON_R_C: CN29.37 R25456.2
+3VPCU: C212.1 C20131.2 C96918.1 C96929.1 CN46.1 CN48.6 CN52.2 CN55.5 PC6015.1 PC6016.1 PJ6001.2 PR9.2 PR15.2 PR18.2 PR204.2 PR6003.1 PR8011.1 PR8019.1 PR8037.2 PR8038.1 PR8048.2 PR8058.1 PU6001.1 PU6001.6 Q23.1(S) Q6602.2 Q6603.2 Q6642.1(S) Q6655.1(S) R736.1 R978.1 R25295.1 R25323.2 R25368.2 R25370.1 R25519.1 R25619.1 R68459.2 R68495.2 R68503.2 R68508.2 R68751.1 R68752.1 R68880.2 R68917.1 R68919.2 R68985.1 R69010.1 R69043.1 R69056.1 R69093.1
+3VPCU_EC: C6565.1 C6569.1 C6570.1 C6574.1 C6575.1 C6577.1 C6578.1 L29.1 L30.2 R25306.2 U37.26 U37.50 U37.92 U37.114 U37.121
+3VPCU_ECPLL: C6573.1 L30.1 U37.127
+3VPCU_GMR: C96343.1 CN4.4 R68985.2 R68986.2 U6525.3(VDD)
+4.6V_PD_C1: PC8009.1 PC8010.1 PQ8017.3 PR8053.1 PR8063.2 PU8001.5
+5V: C545.1 C550.1 C596.1 C597.2 C734.2 C770.1 C771.1 C772.1 C96247.1 C96248.1 C96249.2 CN66.6 L15.1 L16.1 PR126.1 PR9249.1 Q30.1(S) Q6508.3 Q6534.3 Q6604.1(S) R575.1 R579.1 R25373.1 R25528.1 R25529.1 R67359.1 R67565.1 R68567.1 R68790.1 R68792.1 R69050.1
+5V_FAN: FAN3.1 R575.2
+5V_HDD: C669.1 C670.1 C680.1 C689.1 C20143.1 C96242.1 CN11.3 CN11.4 CN11.5 CN11.6 R67359.2 R69046.2
+5V_HDMIC: C6560.1 CN37.18 D50.2 Q6508.1(VOUT) R490.1 R491.1
+5V_KB: C736.1 C737.2 Q30.3 R69055.1
+5V_PD: PD8005.1(CATHODE) PQ8018.4(E2) PR8051.2
+5V_PVDD: C574.1 C575.1 C576.1 C577.1 L15.2 U20.41 U20.46
+5V_S5: C512.1 C524.1 PR5011.1 PR5016.2 PR7002.2 PR7008.2 PR7072.2 PR7086.1 PR9001.1 PR9013.1 PR9074.1 PR9087.1 PR9091.2 PR9100.1 PR9248.2 R68489.1 R68915.1 U15.5 U18.5
+5V_SMARTCARD: C20039.1 C20044.1 C20045.2 R68791.2 U6509.4 U6509.13
+5V_SMARTCARD_R: C96788.2 C96789.2 C96790.2 Q6604.3 R68791.1
+5V_TCSS: C96883.1 C96891.1 R68835.1 R68854.1 R68914.2 R68915.2 U6557.5 U6560.5
+5V_TP: Q6591.3 R25462.1
+5VA: C568.1 C569.1 C598.2 C599.1 L16.2 U20.26
+5VPCU: C508.1 C96851.1 C96852.1 C96853.1 C96854.2 C96920.1 CN49.1 CN49.2 CN49.3 CN49.4 PC6036.1 PC6037.1 PC9072.1 PJ6003.2 PR6013.2 PR6023.2 PR8049.1 PR9069.1 PU6002.1 PU6002.6 PU9003.1(VCC) Q6644.1(S) R417.1 R418.1 R67360.1 R67361.1 R68677.1 R68694.1 R68697.1 R68914.1 R69047.1 U14.1 U6553.1
+A3VPCU: C6566.1 C96797.1 L29.2 U37.74
+V3.3DX_RT_TCP0: C96836.2 C96902.2 L4002.1 U6550.A1 U6550.B1(VOUT#2)
+V3A_LX: PC6001.2 PL6000.1 PR6001.1 PU6000.2 PU6000.3
+V3A_LX_R: PC6006.1 PR6001.2
+V3A_OUT: PC6008.1 PC6009.1 PC6010.1 PC6011.1 PC6012.1 PC6013.1 PC6014.1 PJ6001.1 PL6000.2 PR6008.2
+V5P5A_LX: PC6035.2 PL6001.1 PR6019.1 PU6003.2 PU6003.3
+V5P5A_LX_R: PC6038.1 PR6019.2
+V5P5A_OUT: PC6044.1 PC6045.1 PC6046.1 PC6047.1 PC6048.1 PC6049.1 PC6050.1 PJ6003.1 PL6001.2 PR6026.2
+VCC0P9_LC_TCP0: C96824.2 U6549.J3
+VCC0P9_LVR_TCP0: C96825.2 C96826.2 U6549.L6 U6549.M6
+VCC0V9_SVR_TCP0: C96827.1 C96828.2 C96829.1 C96830.2 C96831.2 C96832.2 C96833.2 C96834.2 L4001.2 U6549.E3 U6549.E9 U6549.F6 U6549.G3 U6549.G6 U6549.G9
+VCC0V9_SVR_TCP0_PHASE: L4001.1 U6549.L1 U6549.M1
+VCC1.05_OUT_FET: C96882.1 C96892.1 Q6607.3 Q6609.3 R68400.2 U6539.BR3 U6539.BR4 U6539.BT5
+VCC1.05_OUT_PCH: TP13429.1 U6539.DA31 U6539.DC31 U6539.DC33
+VCC3P3_ANA_TCP0: C96819.2 U6549.L2
+VCC3P3_LC_TCP0: C96820.1 R68621.2 R68622.2 R68623.2 R68624.2 U6549.E5
+VCC3V3_SX_TCP0: C96816.1 C96817.1 C96818.1 L4002.2 R68609.2 R68614.2 R68616.2 R68617.2 R68625.2 R68631.2 R68633.2 R68879.2 U6549.E6 U6549.M4 U6549.M5
+VCC3V3_SX_TCP0_DBRONLY: R68879.1 U6549.J5
+VCC3V3A_SX_TCP0: C96821.2 C96822.2 C96823.2 R68633.1 U6549.J7
+VCC_V3A: PC6022.1 PU6000.9
+VCC_V5P5A: PC6058.1 PU6003.11
+VCC_XD: C1653.2 C96319.1 C96320.1 F1.1 U40.5
+VCCDPHY_1P24: C96767.1 U6539.DV28
+VCCDSW_1P05: C96768.2 U6539.DD38
+VCCFPGM: C96625.2 R68281.1 U6539.AG10 U6539.AM9 U6539.AN10
+VCCIN: C96575.1 C96576.1 C96577.1 C96578.1 C96579.1 C96580.1 C96581.1 C96582.1 C96583.1 C96584.1 C96585.1 C96586.1 C96587.1 C96588.1 C96590.1 C96591.1 C96593.1 C96594.1 C96595.1 C96596.1 C96597.1 C96598.1 C96599.1 C96600.1 C96603.1 C96604.1 C96605.1 C96606.1 C96607.1 C96608.1 C96609.1 C96610.1 C96611.1 C96612.1 C96613.1 C96614.1 C96615.1 C96616.1 C96617.1 C96618.1 C96619.1 C96620.1 C96621.1 C96622.1 C96623.1 C96624.1 C96626.1 C96627.1 C96628.1 C96629.1 C96630.1 C96631.1 C96632.1 C96633.1 C96634.1 C96635.1 C96636.1 C96637.1 C96638.1 C96639.1 C96640.1 C96641.1 C96642.1 C96644.1 C96645.1 C96646.1 C96647.1 PC7013.1 PC7014.1 PC7015.1 PC7016.1 PC7017.1 PC7028.1 PC7029.1 PC7030.1 PC7031.1 PC7032.1 PL7000.2 PL7001.2 PR7012.1 PR7031.1 PR7052.1 U6539.A24 U6539.A26 U6539.A29 U6539.A30 U6539.A33 U6539.A35 U6539.AY39 U6539.B24 U6539.B26 U6539.B29 U6539.B30 U6539.B33 U6539.B35 U6539.BA10 U6539.BA40 U6539.BB9 U6539.BB39 U6539.BC10 U6539.BC40 U6539.BD9 U6539.BD39 U6539.BE10 U6539.BE40 U6539.BF9 U6539.BG10 U6539.BG40 U6539.BH9 U6539.BH12 U6539.BH39 U6539.BJ10 U6539.BJ40 U6539.BK39 U6539.BL10 U6539.BL40 U6539.BM39 U6539.BN40 U6539.BP12 U6539.BP39 U6539.BR10 U6539.BR40 U6539.BT12 U6539.BT39 U6539.BU10 U6539.BU40 U6539.BV12 U6539.BY12 U6539.CA10 U6539.CB12 U6539.D24 U6539.D26 U6539.D29 U6539.D30 U6539.D33 U6539.D35 U6539.E24 U6539.E26 U6539.E27 U6539.E29 U6539.E30 U6539.E32 U6539.E33 U6539.G2 U6539.G24 U6539.G26 U6539.G30 U6539.G32 U6539.H24 U6539.H26 U6539.H30 U6539.H32 U6539.J1 U6539.J2 U6539.K1 U6539.K2 U6539.K24 U6539.K26 U6539.K30 U6539.K32 U6539.L24 U6539.L26 U6539.L30 U6539.L32 U6539.N24 U6539.N26 U6539.N30 U6539.N32 U6539.P24 U6539.P26 U6539.P28 U6539.P30 U6539.P32 U6539.T21 U6539.T23 U6539.T25 U6539.T27 U6539.T31 U6539.U23 U6539.U27 U6539.U29 U6539.U31 U6539.U33 U6539.V23 U6539.V25 U6539.V27 U6539.V29 U6539.V31 U6539.V33 U6539.W22 U6539.W24 U6539.W28 U6539.W32
+VCCIN_AUX: C96720.1 C96721.1 C96722.1 C96723.1 C96725.1 C96726.1 C96727.1 C96728.1 C96729.1 C96730.1 C96731.1 C96732.1 C96734.1 C96735.1 C96736.1 C96737.1 C96738.1 C96739.1 C96740.1 C96741.1 C96742.1 C96743.1 C96744.1 C96745.1 C96746.1 C96747.1 C96748.1 C96749.1 C96750.1 C96751.1 C96752.1 C96753.1 C96754.1 C96755.1 C96756.1 C96757.1 C96759.1 C96760.1 C96762.1 C96763.1 C96765.1 PC7055.1 PC7056.1 PC7057.1 PC7058.1 PC7059.1 PC7060.1 PC7062.1 PC7063.1 PC7064.1 PC7065.1 PL7002.2 PR7085.2 U6539.AB12 U6539.AC10 U6539.AE10 U6539.AK1 U6539.AK2 U6539.AR10 U6539.AT12 U6539.AU10 U6539.AW10 U6539.BV1 U6539.BV39 U6539.BW40 U6539.BY39 U6539.CC1 U6539.CD12 U6539.CF10 U6539.CG12 U6539.CH10 U6539.CJ1 U6539.CJ12 U6539.CK10 U6539.CL12 U6539.CM10 U6539.CP1 U6539.CP10 U6539.CR12 U6539.CT10 U6539.CU12 U6539.CY1
+VCCIO_OUT: R68291.1 R68292.1 R68293.1 R68294.1 R68295.1 R68296.1 R68297.1 R68298.1 R68299.1 R68300.1 R68301.1 R68302.1 R68303.1 R68304.1 R68306.1 R68307.1 R68308.1 R68309.1 R68310.1 R68311.1 U6539.V15
+VCCLDOSTD_OUT_0P85: C96764.2 U6539.DV46
+VCCPFUSE_3P3: R68507.1 R68508.1 U6539.CY31 U6539.CY33
+VCCPRIM_3P3: C96758.2 C96761.2 R68495.1 R68496.1 U6539.DA35 U6539.DC28 U6539.DC30 U6539.DD30
+VCCRTC: C96769.2 C96770.2 C96771.2 R68500.1 U6539.DC35
+VCCST: C96601.2 C96602.1 PC756.1 PR22.2 PR7001.1 Q85.3 R822.2 R68257.1 R68283.2 R68284.2 R68487.1 R68491.1 R68842.1 R68847.1 U6539.BT1 U6539.BT2 U6539.BT4
+VCCST_EN: R68840.1 U6560.4(Y)
+VCCST_S2: C96895.1 C96896.1 Q6609.1(S) R68842.2
+VCCSTG: R68277.2 R68830.1 R68833.1 R69058.2 U6539.BP1 U6539.BP2 U6539.BP4
+VCCSTG_FUSE: C96589.2 C96592.1 C96643.2 R68282.2 U6539.AD12 U6539.AF12
+VCCSTG_OUT_FUSE: R68281.2 R68282.1 U6539.AF9
+VCCSTG_OUT_LGC: R68280.1 U6539.M9
+VCCSTG_S2: C96886.2 C96887.1 C96888.1 Q6607.1(S) R68830.2
+VCCSTG_TERM: Q6654.2 R68259.2 R68261.2 R68263.2 R68266.2 R68270.2 R68280.2 R69058.1
+VDD_IO: CN58.2 CN58.3 CN58.15 R67560.2 R67562.1
+VDD_SIM: CN58.10 R67562.2
+VDDQ: PC5013.1 PR5009.1 R67574.2 R67575.2
+VDDQ_VTT: C251.1 C253.1 C255.1 C257.1 C259.1 C261.1 C20105.1 C20108.1 C20111.1 C20114.1 C20117.1 C20119.1 JDIM1.258(VTT) JDIM02.258(VTT) PR9288.1
+VIN: C542.1 PC7.1 PC12.1 PC170.1 PC172.1 PC6000.1 PC6002.2 PC6003.2 PC6004.1 PC6005.1 PC6030.1 PC6031.2 PC6032.1 PC6033.1 PC6034.2 PC9007.1 PJ5001.2 PJ7000.2 PJ7001.2 PJ9008.2 PJ9009.2 PJ9010.2 PQ2.5 PQ30.5 PR2.2 PR3.2 PR59.1 PR116.1 PR9102.1 PU6000.5 PU6003.5 R67551.1 R69105.1
+VIN_BLIGHT: C536.1 C537.1 CN29.39 CN29.40 R67551.2
+VIN_VCCIN_AUX: PC7046.1 PC7047.1 PC7048.1 PC7049.1 PC7050.1 PC7051.2 PC7052.1 PJ7001.1 PQ7002.5 PR7066.2
+VIN_VCORE: PC7000.1 PC7004.1 PC7005.1 PC7006.1 PC7007.1 PC7008.1 PC7009.2 PC7010.1 PC7020.1 PC7021.1 PC7022.1 PC7023.1 PC7024.1 PC7025.2 PC7026.1 PJ7000.1 PQ7000.3 PQ7000.4 PQ7000.9 PQ7001.3 PQ7001.4 PQ7001.9 PR7003.1
+VIN_VGPU_CORE1: PC9001.1 PC9002.1 PC9003.1 PC9005.1 PC9006.1 PJ9008.1 PQ9000.3 PQ9000.4 PQ9000.9 PR9000.1
+VIN_VGPU_CORE2: PC9015.1 PC9016.1 PC9017.1 PC9018.1 PC9019.1 PJ9010.1 PQ9001.3 PQ9001.4 PQ9001.9
AVDD2: C845.1 L28.2 U20.40
DVDD_IO: C584.1 C585.1 R460.1 R462.1 U20.9
