# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DISP_ON: length 117.3
  TOP w0.114: R445.2 79.69,194.72 v2(79.8,194.61) 81.48,194.61 82.21,193.87 82.21,191.72 81.78,191.28 v2(81.78,190.2)
  IN3 w0.089: v1(119.94,124.36) 119.55,124.74 119.55,125.22 119.4,125.37 117.72,125.37 117.57,125.52 117.57,128.7 117.14,129.13 117.14,131.34
  IN3 w0.102: v2(90.31,189.33) 89.86,189.79 82.2,189.79 v2(81.78,190.2) ; 117.14,131.34 117.14,131.47 116.91,131.7 116.91,154.86 117.14,155.09 117.14,155.98 117.39,156.23 117.39,158.77 118.41,159.79 119.68,159.79 119.81,159.92 119.81,160.42 120.06,160.68 123.06,160.68 123.49,161.11 123.49,163.34 122.22,164.61 122.22,168.93 121.25,169.9 121.25,170.96 120.94,171.28 117.84,171.28 116.52,172.6 116.34,172.6 v1(116.33,172.59)
  IN4 w0.089: v2(90.31,189.33) 90.71,189.73 92.22,189.73 93.19,190.7 93.8,190.7 96.9,187.6 96.9,183.21 97.45,182.65 98.6,182.65 100.12,181.12 100.12,180.74 101.14,179.73 101.14,175.41 102.85,173.69 102.85,173.44 103.7,172.59 112.19,172.59 112.34,172.74 113.3,172.74 113.46,172.59 v1(116.33,172.59)
  BOTTOM w0.102: v1(119.94,124.36) 120.02,124.36 U6539.DM8
PCH_DPST_PWM: length 127.8
  TOP w0.114: v2(64.84,188.11) 64.84,188.68 v2(65.16,189)
  IN3 w0.089: 117.42,131.24 117.39,131.21 117.39,129.13 117.75,128.77 117.75,127.43 117.9,127.28 118.77,127.28 v1(119.03,127.02)
  IN3 w0.102: v2(89.43,188.62) 89.43,188.59 88.95,188.11 87.17,188.11 85.9,189.38 77.9,189.38 77.52,189 75.61,189 74.42,190.19 71.47,190.19 71.17,189.89 69.9,189.89 68.88,188.87 65.29,188.87 v2(65.16,189) ; 117.42,131.24 117.42,131.85 117.32,131.95 117.32,154.61 117.42,154.71 117.42,155.62 117.65,155.85 117.65,158.65 117.9,158.9 122.98,158.9 123.9,159.81 123.9,163.7 122.73,164.87 122.73,169.19 121.69,170.23 121.69,171.12 121.12,171.69 118.19,171.69 117.37,172.51 v1(117.34,172.51)
  IN4 w0.089: v1(117.34,172.51) 116.86,173 115.36,173 115.11,173.25 112.06,173.25 111.93,173.12 103.8,173.12 103.55,173.38 103.55,173.63 101.9,175.28 101.9,179.73 100.63,181 100.63,181.25 98.72,183.16 97.96,183.16 97.33,183.79 97.33,187.73 93.95,191.11 92.96,191.11 91.99,190.14 90.47,190.14 89.57,189.24 89.57,188.74 89.44,188.62 v2(89.43,188.62)
  BOTTOM w0.102: v1(119.03,127.02) 119.15,127.02 U6539.DG10
  BOTTOM w0.114: v2(65.16,189) 65.17,189.01 65.35,189.01 65.58,188.78 R443.1
PCH_DSWROK: length 29.8
  TOP w0.114: R68476.1 84.88,119.91 84.75,120.04 R68479.2 84.47,120.52 84.55,120.6 v1(84.55,120.62) 84.34,120.83 R68482.1
  IN3 w0.089: 108.25,123.59 108.25,124.04 108.47,124.26 108.47,124.69 v1(108.11,125.05)
  IN3 w0.102: 108.25,123.59 107.61,122.96 106.85,122.96 106.6,123.21 103.17,123.21 102.56,122.6 98.75,122.6 98.6,122.45 97.45,122.45 97.07,122.83 92.44,122.83 92.06,122.45 89.33,122.45 88.56,121.69 85.62,121.69 v1(84.55,120.62)
  BOTTOM w0.102: U6539.DK35 108.23,125.05 v1(108.11,125.05)
PCH_IST_TP_0: length 8.1
  BOTTOM w0.102: U6539.DU53 100.05,122.38 99.61,121.94 99.61,121.31 98.81,120.51 96.05,120.51 94.41,118.87 TP13260.1
PCH_IST_TP_1: length 7.5
  BOTTOM w0.102: U6539.DT52 100.82,122.52 100.36,122.06 100.03,122.06 99.84,121.87 99.84,121.15 98.98,120.29 ; 95.68,119.78 95.68,119.4 TP13255.1
  BOTTOM w0.114: 95.68,119.78 96.18,120.29 98.98,120.29
PCH_JTAGX: length 6.3
  BOTTOM w0.102: U6539.D8 120.82,164.43 121.12,164.74 121.12,167.92 120.7,168.35 120.7,169.82 120.85,169.98 R68265.1
PCH_LVDS_BLON: length 98.8
  IN3 w0.089: v1(119.94,123.75) 119.41,123.21 117.01,123.21 116.66,123.57 116.66,127.78 116.47,127.97 116.07,127.97
  IN3 w0.102: 116.07,127.97 115.87,128.17 115.87,129.82 116,129.94 116,155.34 116.4,155.75 116.4,156.11 115.62,156.89 115.62,157.63 116,158.01 116,158.72 116.66,159.38 116.73,159.38 117.13,159.77 117.13,160.06 116.63,160.55 116.63,162.46 117.39,163.22 117.39,163.6 117.14,163.85 117.14,164.61 117.39,164.87 117.39,165.25 117.01,165.63 117.01,166.39 117.55,166.93 117.55,167.76 116,169.31 116,169.83 115.51,170.31 115.51,173.54 111.68,177.37 111.68,178.28 111.32,178.63 111.32,179.19 110.82,179.7 110.82,180.67 110.54,180.95 110.54,181.68 109.49,182.72 105.89,182.72 105.25,183.36 103.56,183.36 102.77,182.57 100.3,182.57 100.2,182.47 93.64,182.47 91.74,184.38 91.74,185.44 91.27,185.92 89.89,185.92 89.47,186.33 86.66,186.33 84.91,188.08 v2(84.88,188.08)
  BOTTOM w0.102: v1(119.94,123.75) 120.06,123.75 U6539.DN8
  BOTTOM w0.114: v2(84.88,188.08) 84.88,188.11 84.56,188.43 R25365.1
PCH_OPI_RCOMP: length 12
  TOP w0.254: R68264.2 130.22,135.79 v1(129.84,136.17)
  IN4 w0.254: v1(129.84,136.17) 124.51,136.17 122.73,137.94 122.09,137.94 121.96,137.81 120.68,137.81 120.24,138.24 v1(120.24,138.27)
  BOTTOM w0.254: v1(120.24,138.27) 120.24,138.11 U6539.CB9
PCH_PWROK: length 88.9
  TOP w0.114: U37.78 166.45,102.34 166.27,102.53 166.27,102.94 166.06,103.15 v1(166.06,103.58) ; R68593.1 108.02,109.29 107.92,109.29 107.54,108.91 107.54,107.77 107.28,107.51 105.66,107.51 104.55,106.4 103.63,106.4 103.28,106.05 103.28,102.49 102.53,101.75 102.53,99.84 102.13,99.44 v2(102.13,99.21) v1(102.13,98.29)
  IN3 w0.102: v1(166.06,103.58) 166.06,103.45 165.7,103.1 163.99,103.1 162.68,104.4 160.94,104.4 159.07,102.54 156.55,102.54 156.27,102.26 150.29,102.26 149.46,101.42 148.56,101.42 147.34,100.2 144.09,100.2 142.92,101.37 142.33,101.37 141.57,102.13 138.02,102.13 137.13,101.24 133.52,101.24 131.11,98.83 125.01,98.83 124.53,98.35 119.12,98.35 118.92,98.55 117.5,98.55 116,97.05 110.79,97.05 110.28,96.54 109.9,96.54 v2(109.39,96.03)
  IN4 w0.089: v2(109.39,96.03) 103.68,96.03 102.13,97.58 v1(102.13,98.29)
PCH_PWROK_R: length 32.9
  TOP w0.089: 108.68,122.07 108.68,122.4 108.61,122.48 108.61,122.86 109.02,123.27 v1(109.02,123.8)
  TOP w0.114: D13108.2 97.97,108.61 98.34,108.99 v2(98.98,108.99) 99.23,108.73 v1(99.23,108.38) ; R68918.2 R68466.1 R68467.1 R68593.2 108.12,110.23 v1(108.42,110.51) 109.14,111.25 109.14,112.44 108.83,112.75 108.83,116.05 108.5,116.38 108.5,117.14 108.68,117.32 108.68,122.07
  BOTTOM w0.102: v1(109.02,123.8) 108.73,124.09 U6539.DN35
  BOTTOM w0.114: v1(99.23,108.38) 99.24,108.38 99.59,108.38 101.14,106.83 103.8,106.83 104.74,107.77 107.41,107.77 108.42,108.78 108.42,109.04 v1(108.42,110.51)
PCH_SMBCLK: length 55.6
  TOP w0.089: v1(114.47,125.08) 114.84,124.71 114.84,122.34 115.11,122.07
  TOP w0.114: v1(79.42,119.15) 79.55,119.28 R68362.2 78.69,119.69 78.55,119.54 Q6585.6 ; 115.11,122.07 115.49,121.69 115.49,119.28 v2(114.98,118.77) 115.36,118.39 115.74,118.39 116,118.13 116.25,118.13 116.38,118.01 R68346.1
  IN1 w0.089: v1(79.42,119.15) 79.42,121.13 84.68,126.39 92.37,126.39 92.76,126.01 94.91,126.01 95.42,126.51 96.82,126.51 97.07,126.77 99.11,126.77 100.76,128.42 101.39,128.42 101.9,128.93 105.07,128.93 105.2,128.8 107.61,128.8 108.5,127.91 109.39,127.91 109.9,127.4 114.71,127.4 114.84,127.28 114.84,125.45 v1(114.47,125.08)
  BOTTOM w0.102: U6539.DK21 114.62,125.08 v1(114.47,125.08)
PCH_SMBDATA: length 58.8
  TOP w0.089: v1(115.38,125.07) 115.02,124.7 115.02,122.54 115.49,122.07
  TOP w0.114: v1(75.71,119.03) 75.79,119.11 75.79,119.93 75.99,120.14 R68360.2 76.98,120.14 77.25,120.4 Q6585.3 ; 115.49,122.07 115.74,121.82 115.74,119.17 v2(116.26,118.65) 116.53,118.39 116.76,118.39 117.14,118.01 R68347.1
  IN1 w0.089: v1(115.38,125.07) 115.03,125.42 115.03,127.35 114.6,127.78 110.03,127.78 109.52,128.29 108.63,128.29 107.95,128.98 105.28,128.98 105.07,129.18 101.65,129.18 101.39,128.93 100.63,128.93 98.85,127.15 96.9,127.15 96.64,126.9 95.17,126.9 94.74,126.46 92.93,126.46 92.6,126.79 84.55,126.79 77.26,119.5 75.97,119.5 75.71,119.25 v1(75.71,119.03)
  BOTTOM w0.102: v1(115.38,125.07) 115.51,125.07 U6539.DM19
PCH_SPI0_CLK: length 41.5
  TOP w0.114: R68336.1 121.58,110.74 121.46,110.87 121.31,110.87 v1(120.9,111.27)
  IN4 w0.089: v1(107.2,126.38) 107.49,126.38 107.74,126.13 107.74,123.21 108.05,122.91 108.05,122.02 108.34,121.73 108.46,121.73 108.65,121.92 108.78,121.92 109.03,121.67 109.03,121.54 108.84,121.35 108.84,121.23 109.09,120.98 109.22,120.98 109.47,121.23 109.6,121.23 109.85,120.98 109.85,120.85 109.59,120.6 109.59,119.99 112.59,116.99 113.71,116.99 113.84,117.12 114.73,117.12 114.85,116.99 114.85,116.35 114.73,116.23 114.09,116.23 113.96,116.1 113.96,115.72 114.09,115.59 115.49,115.59 115.62,115.72 115.62,117.07 115.74,117.19 116.35,117.19 116.5,117.04 116.5,115.85 118.54,113.81 118.54,113.43 119.55,112.42 119.81,112.42 120.06,112.67 120.26,112.67 120.45,112.48 120.45,112.3 120.21,112.06 120.21,111.88 120.44,111.66 120.57,111.66 120.82,111.91 121.03,111.91 121.15,111.78 121.15,111.53 v1(120.9,111.27)
  BOTTOM w0.102: v1(107.2,126.38) 107.31,126.38 U6539.DJ37
  BOTTOM w0.114: v1(120.9,111.27) 120.9,110.46 120.57,110.13 v2(120.06,110.13) 118.82,110.13 117.52,108.84 117.52,107.16 117.93,106.75 118.06,106.75 118.21,106.6 118.21,106.34 118.06,106.19 R68571.1
PCH_SPI0_CLK_R: length 3.9
  BOTTOM w0.114: R68572.2 119.43,105.31 119.17,105.56 R68571.2 R68583.1 v2(119.17,104.8) 119.68,104.8 119.84,104.64 R68584.2
PCH_SPI0_CS0#: length 40.5
  IN4 w0.089: v1(108.11,127.02) 107.87,127.26 107.87,127.53 108,127.66 108.5,127.66 108.66,127.5 108.66,125.57 108.87,125.36 109.24,125.36 109.39,125.21 109.39,123.27 109.77,122.88 109.77,122.55 111.37,120.95 111.37,120.03 111.49,119.91 111.96,119.91 112.94,118.93 112.94,118.22 113.02,118.13 113.24,118.13 113.33,118.22 113.33,118.89 113.46,119.02 113.62,119.02 113.71,118.93 113.71,118.22 113.8,118.13 114,118.13 114.09,118.22 114.09,118.93 114.18,119.02 114.41,119.02 114.5,118.93 114.5,118.22 114.59,118.13 114.77,118.13 114.86,118.22 114.86,118.55 114.95,118.64 115.12,118.64 115.21,118.55 115.21,118.22 115.3,118.13 117.37,118.13 118,117.5 118.54,117.5 120.31,115.72 120.31,115.08 120.72,114.68 120.72,113.89 v1(123.34,111.27)
  BOTTOM w0.102: v1(108.11,127.02) 107.99,127.02 U6539.DG37
  BOTTOM w0.114: R68581.1 128.8,109.65 128.06,110.39 123.74,110.39 123.34,110.79 v1(123.34,111.27)
PCH_SPI0_CS0#_R: length 2
  BOTTOM w0.114: R68581.2 R68582.1 132.28,110.1 132.81,109.57 R68589.1
PCH_SPI0_IO2: length 53.3
  TOP w0.114: v1(120.02,111.27) 120.31,111.27 120.52,111.07 120.52,110.88 120.73,110.66 R68381.1
  IN4 w0.089: v1(120.02,111.27) 120.01,111.27 117.94,113.34 117.94,113.73 116.54,115.12 113.77,115.12 108.76,120.14 108.76,120.57 107.56,121.76 107.56,125.39 v1(107.2,125.75)
  BOTTOM w0.102: U6539.DJ39 107.03,125.75 v1(107.2,125.75)
  BOTTOM w0.114: v1(120.02,111.27) 119.64,110.89 118.51,110.89 116.76,109.14 116.76,106.78 117.14,106.4 117.14,103.76 118.28,102.61 v2(118.28,101.9) 119.86,100.32 119.86,99.08 120.62,98.32 122.37,98.32 123.24,99.18 123.24,99.84 126.41,103.02 129.18,103.02 130.61,104.45 R68577.1
PCH_SPI0_IO2_R: length 1
  BOTTOM w0.114: R68578.1 131.9,105.16 131.64,104.9 R68577.2
PCH_SPI0_IO3: length 40.6
  TOP w0.114: R68384.1 R68378.1 123.11,110.77 122.73,111.15 v1(122.73,111.27)
  IN4 w0.089: v1(108.11,126.34) 108.39,126.34 108.48,126.25 108.48,125.45 108.65,125.27 108.65,123.32 108.76,123.21 109.19,123.21 109.48,122.93 109.48,122.52 111.17,120.82 111.17,119.43 111.43,119.17 111.55,119.17 111.86,119.48 111.99,119.48 112.11,119.35 112.11,119.23 111.8,118.92 111.8,118.79 111.93,118.67 112.06,118.67 112.36,118.97 112.49,118.97 112.61,118.85 112.61,118.72 112.31,118.42 112.31,118.29 112.69,117.9 117.1,117.9 117.76,117.24 118.47,117.24 118.66,117.05 118.66,116.82 118.58,116.74 117.9,116.74 117.8,116.63 117.8,116.47 117.91,116.35 118.19,116.35 118.28,116.27 118.28,116.03 118.19,115.95 117.94,115.95 117.83,115.84 117.83,115.59 117.95,115.47 118.45,115.47 118.54,115.38 118.54,114.96 118.66,114.83 118.79,114.83 118.92,114.96 118.92,115.6 119.01,115.69 119.21,115.69 119.3,115.6 119.3,114.92 119.39,114.83 119.55,114.83 119.68,114.96 119.68,115.63 119.77,115.72 119.97,115.72 120.06,115.63 120.06,114.7 120.47,114.3 120.47,113.53 v1(122.73,111.27)
  BOTTOM w0.102: U6539.DG35 108.22,126.34 v1(108.11,126.34)
  BOTTOM w0.114: R68579.1 118.16,108.76 v2(118.82,109.42) 119.02,109.62 120.82,109.62 121.78,110.58 122.41,110.58 122.73,110.89 v1(122.73,111.27)
PCH_SPI0_IO3_R: length 0.6
  BOTTOM w0.114: R68579.2 R68580.1
PCH_SPI0_SI: length 37.6
  TOP w0.114: R68370.1 121.74,111.65 v1(122.12,111.27)
  IN4 w0.089: v1(122.12,111.27) 122.12,111.5 120.24,113.38 120.24,113.64 120.06,113.81 119.22,113.81 117.01,116.02 117.01,117.37 116.71,117.67 112.59,117.67 110.38,119.88 110.38,121.28 109.27,122.4 108.91,122.4 108.57,122.74 108.57,123.15 108.47,123.24 108.47,125.2 108.11,125.56 v1(108.11,125.72)
  BOTTOM w0.102: v1(108.11,125.72) 108.25,125.72 U6539.DJ35
  BOTTOM w0.114: v1(122.12,111.27) 122.12,111.63 121.97,111.78 120.72,111.78 120.46,111.52 120.46,110.91 120.19,110.64 118.61,110.64 117.01,109.04 117.01,106.88 117.39,106.5 117.39,104.47 117.8,104.06 R68573.1
PCH_SPI0_SI_R: length 3.4
  BOTTOM w0.114: R68573.2 118.54,103.78 v2(119.04,103.27) R68585.1 R68586.2 R68574.2
PCH_SPI0_SO: length 37
  IN4 w0.089: v1(109.93,125.71) 109.57,125.35 109.57,123.42 110.28,122.7 110.28,122.37 111.58,121.08 111.58,120.42 111.83,120.16 112.44,120.16 112.57,120.04 112.57,119.66 112.95,119.28 114.85,119.28 115.77,118.36 117.47,118.36 118.03,117.8 118.61,117.8 120.57,115.85 120.57,115.21 120.98,114.8 120.98,114.04 123.13,111.88 123.34,111.88 v1(123.95,111.27)
  BOTTOM w0.102: v1(109.93,125.71) 109.8,125.71 U6539.DJ33
  BOTTOM w0.114: R68575.1 134.14,107.77 133.78,108.12 133.78,108.48 133.57,108.68 v2(133.57,109.19) 133.57,109.24 132.38,110.44 130.96,110.44 130.53,110 129.2,110 128.19,111.02 124.2,111.02 v1(123.95,111.27)
PCH_SPI0_SO_R: length 5.5
  BOTTOM w0.114: R68575.2 134.01,107.32 133.49,106.8 R68576.2 133.49,106.02 133.55,105.96 R68588.2 132.58,104.59 132.58,103.63 132.46,103.5 R68587.1
PCH_SPI1_CLK_R: length 49.5
  TOP w0.114: v2(161.89,108.35) 161.89,108.78 162.66,109.55 U37.105
  IN3 w0.102: v1(121.71,101.62) 122.22,102.13 129.08,102.13 130.68,103.73 137.03,103.73 137.21,103.91 147.47,103.91 148.28,104.72 149.07,104.72 149.63,105.28 151.13,105.28 152.45,106.6 159.35,106.6 159.68,106.93 160.47,106.93 v2(161.89,108.35)
  BOTTOM w0.114: R68584.1 120.29,104.04 120.41,103.91 120.57,103.91 121.71,102.77 v1(121.71,101.62)
PCH_SPI1_SI_R: length 53.9
  TOP w0.114: R25303.1 165.54,113.21 165.41,113.08 165.41,112.89 165.27,112.75 164.97,112.75 164.51,112.29 164.13,112.29 163.86,112.02 U37.102 163.86,108.37 v2(163.88,108.35)
  IN3 w0.102: v1(120.31,100.96) 120.8,100.96 120.95,101.11 131.11,101.11 133.14,103.15 137.13,103.15 137.41,103.43 147.7,103.43 148.49,104.22 149.29,104.22 149.86,104.8 151.33,104.8 152.65,106.12 159.61,106.12 159.94,106.45 161.97,106.45 v2(163.88,108.35)
  BOTTOM w0.114: v1(120.31,100.96) 119.81,101.47 R68586.1
PCH_SPI1_SO_R: length 49.3
  TOP w0.114: R25316.1 164.79,113.21 164.16,112.57 164.03,112.57 163.46,112 U37.103 163.46,108.6 v2(163.22,108.35)
  IN3 w0.102: v2(134.08,106.65) 134.08,105.69 134.18,105.58 135.53,105.58 135.68,105.43 135.68,104.75 135.86,104.57 137.49,104.57 137.97,105.05 137.97,107.08 138.09,107.21 138.48,107.21 138.6,107.08 138.6,104.54 138.73,104.42 139.11,104.42 139.24,104.54 139.24,106.96 139.36,107.08 139.75,107.08 139.87,106.96 139.87,105.04 140.12,104.8 144.57,104.8 144.98,105.2 148.15,105.2 148.79,105.84 151,105.84 152.24,107.08 158.92,107.08 159.3,107.46 160.32,107.46 161.72,108.86 162.71,108.86 v2(163.22,108.35)
  BOTTOM w0.114: v2(134.08,106.65) 134.08,106.19 134,106.11 R68588.1
PCH_SPI_CS0#_R: length 48.4
  TOP w0.114: U37.101 164.26,108.63 v2(164.54,108.35)
  IN3 w0.102: v1(133.27,108.35) 134.54,108.35 134.83,108.07 134.83,106.04 134.93,105.94 135.84,105.94 135.94,106.04 135.94,108.49 136.06,108.61 136.44,108.61 136.57,108.48 136.57,105.31 136.7,105.18 137.33,105.18 137.59,105.43 137.59,107.43 138,107.85 139.62,107.85 142.06,105.41 144.29,105.41 144.7,105.81 148.05,105.81 148.56,106.32 151.15,106.32 152.27,107.44 158.77,107.44 159.18,107.85 160.19,107.85 161.59,109.24 163.67,109.24 164.54,108.38 v2(164.54,108.35)
  BOTTOM w0.114: R68589.2 132.81,108.56 133.01,108.35 v1(133.27,108.35)
PCH_TBT_PERST#: length 35.8
  IN2 w0.102: v1(104.52,124.38) 104.47,124.38 104.06,123.97 104.06,122.32 102.38,120.65 102.38,118.61 101.14,117.37 101.14,112.67 101.9,111.91 104.57,111.91 v1(105.46,112.8)
  BOTTOM w0.102: U6539.DN43 104.64,124.38 v1(104.52,124.38)
  BOTTOM w0.114: R68685.2 98.09,107.82 98.06,107.84 97.58,107.84 97.38,108.04 U6554.2 97.38,109.62 97.45,109.7 99.03,109.7 v2(99.37,109.36) 101.6,107.13 103.6,107.13 103.93,107.46 103.93,108.1 104.44,108.61 104.44,109.24 104.77,109.57 104.77,110.59 105.17,110.99 R68408.2 R68411.1 105.18,112.52 v1(105.46,112.8)
PCH_TCK: length 7.1
  BOTTOM w0.102: TP13247.1 120.42,171.32 120.42,170.58 120.52,170.48 120.52,170 120.47,169.95 120.47,168.24 120.85,167.87 U6539.A7
  BOTTOM w0.114: TP13247.1 120.82,171.73 R68276.1
PCH_TDI: length 8.7
  BOTTOM w0.102: R68269.1 118.38,171.57 118.21,171.4 118.21,170.05 118.79,169.47 118.79,168.17 118.28,167.66 118.28,167 118.3,166.99 118.3,166.96 119.07,166.19 119.07,165.17 U6539.B12
  BOTTOM w0.114: R68266.1 R68269.1
PCH_TDO: length 9.1
  BOTTOM w0.102: U6539.E12 118.62,163.59 117.8,164.41 117.8,165.63 117.27,166.16 117.27,168.04 116.68,168.63 116.68,169.06 v2(116.89,169.26) 116.99,169.37 R68268.1 116.99,170.96 117.27,171.24 R68263.1
PCH_TMS: length 7.1
  BOTTOM w0.102: R68267.1 120.21,169.8 120.26,169.74 120.26,168.09 120.49,167.87 120.49,166.52 119.98,166.01 U6539.A9
  BOTTOM w0.114: R68261.1 120.06,171.98 120.18,171.86 120.18,170.23 R68267.1
PCH_TRST#: length 5
  TOP w0.102: v1(122.18,162.06) 122.25,162.06 122.62,162.43 122.62,162.43 122.7,162.51 123.41,162.51 123.74,162.84 123.97,162.84
  TOP w0.114: 123.97,162.84 124.89,162.84 125.24,162.48 R68271.1 R68275.1
  BOTTOM w0.102: v1(122.18,162.06) 122.21,162.08 122.21,162.19 U6539.H4
PCIE4_RCOMPN: length 13.2
  TOP w0.089: 123.11,155.29 123.09,155.29 123.06,155.27 121.91,155.27 121.64,155.54 121.64,155.92 121,156.56 121,156.76 120.59,157.17 119.23,157.17 v1(118.92,157.48)
  TOP w0.114: R68426.1 129.98,155.59 129.76,155.37 129.42,155.37 129.26,155.22 126.16,155.22 126.08,155.29 123.11,155.29
  BOTTOM w0.102: v1(118.92,157.48) 118.92,157.67 U6539.V12
PCIE4_RCOMPP: length 13.2
  TOP w0.089: 123.11,155.06 123.09,155.06 123.06,155.09 121.84,155.09 121.46,155.47 121.46,155.85 120.82,156.49 120.82,156.69 120.52,156.99 119.28,156.99 v1(118.85,156.57)
  TOP w0.114: R68426.2 129.51,155.14 129.36,154.99 126.06,154.99 125.99,155.06 123.11,155.06
  BOTTOM w0.102: U6539.Y12 118.85,156.82 v1(118.85,156.57)
PCIE_CLKREQ_#5: length 14.4
  TOP w0.114: R68439.2 115.59,116.86 115.64,116.81 v4(115.64,116.3) 115.97,115.97 v1(116.05,115.97)
  IN2 w0.089: 113.32,123.47 113.32,123.48 113.2,123.59 113.2,126.02 v1(113.57,126.39)
  IN2 w0.102: v1(116.05,115.97) 116.45,116.38 116.45,118.97 115.51,119.91 115.51,121.08 114.4,122.2 113.84,122.2 113.32,122.71 113.32,123.47
  BOTTOM w0.102: U6539.DG25 113.41,126.39 v1(113.57,126.39)
PCIE_CLKREQ_#6: length 14.4
  TOP w0.114: v1(116.05,116.61) 116,116.66 116,116.86 115.87,116.99 115.87,117.75 115.74,117.88 R68442.2
  IN2 w0.089: 112.95,123.47 112.95,123.58 113.02,123.65 113.02,123.66 113.03,123.67 113.03,126.5 v1(113.55,127.02)
  IN2 w0.102: 112.95,123.47 112.95,122.58 113.71,121.82 114.22,121.82 115.18,120.85 115.18,119.58 116.05,118.72 v1(116.05,116.61)
  BOTTOM w0.102: v1(113.55,127.02) 113.7,127.02 U6539.DF23
PCIE_CLKREQ_LAN#: length 183.6
  TOP w0.114: R25446.1 v2(23.41,158.01) 23.57,157.86 24.18,157.86 v2(24.19,157.87) 24.53,158.21 25.27,158.21 25.84,158.79 Q6531.1
  IN4 w0.089: v1(99,95.86) 98.98,95.89 98.98,95.91 97.72,97.18 92.5,97.18 91.36,98.32 79.67,98.32 76.5,95.15 74.85,95.15 72.44,92.73 52.37,92.73 51.48,93.62 51.48,94.48 49.35,96.62 46.07,96.62 45.46,97.23 41.47,97.23 40.51,98.19 38.65,98.19 36.05,100.8 36.05,101.25 35.22,102.08 35.22,108.1 34.34,108.99 34.34,113.46 33.4,114.4 33.4,117.67 32.05,119.02 32.05,122.07 30.53,123.59 30.53,126.51 29.87,127.17 29.87,133.65 29.51,134.01 29.51,144.04 31.34,145.87 31.34,150.24 32.3,151.21 32.3,155.8 v2(30.02,158.09)
  BOTTOM w0.102: 113.53,114.27 113.56,114.29 113.56,115.31 113.96,115.72 113.96,116.1 113.08,116.99 113.08,119.15 113.46,119.53 113.46,119.91 113.15,120.21 113.15,121.38 113.16,121.39 113.16,122.26 U6539.DT24
  BOTTOM w0.114: v2(23.41,158.01) 23.79,158.01 24.43,158.65 29.46,158.65 v2(30.02,158.09) ; v1(99,95.86) 99,100.25 99.26,100.5 99.26,104.01 99.89,104.64 100.48,104.64 101.14,105.31 104.11,105.31 105.52,106.71 107.88,106.71 108.81,107.64 111.22,107.64 111.55,107.97 111.55,109.62 112.41,110.48 R68437.2 113.08,111.02 113.66,111.6 113.66,112.21 112.95,112.93 112.95,113.81 113.2,114.07 113.33,114.07 113.53,114.27
PCIE_CLKREQ_SSD#: length 130.7
  IN3 w0.102: v1(109.83,108.89) 107.75,106.8 106.47,106.8 105.2,105.53 102.26,105.53 100.38,103.65 99.36,103.65 98.6,102.89 96.18,102.89 95.55,102.26 89.83,102.26 89.58,102 89.58,101.5 89.3,101.22 82.11,101.22 81.88,100.99 80.82,100.99 80.72,100.89 78.1,100.89 77.36,100.15 73.05,100.15 72.52,99.63 71.86,99.63 71.04,98.8 71.04,98.57 69.34,96.87 60.7,96.87 59.86,96.03 45.89,96.03 45.38,96.54 34.23,96.54 33.9,96.87 28.82,96.87 25.32,93.37 25.32,87.65 26.46,86.51 26.46,84.22 25.45,83.21 25.45,78.64 24.94,78.13 24.94,76.98 23.67,75.71 22.98,75.71 v2(22.22,74.95)
  BOTTOM w0.102: U6539.DT30 111.23,122.27 111.23,119.72 110.99,119.48 110.99,116.27 111.07,116.19 111.07,115.92 111.55,115.43 111.55,114.07 111.68,113.94 111.68,113.34 111.55,113.21 R68436.2
  BOTTOM w0.114: v1(109.83,108.89) 109.81,108.91 109.81,109.27 v2(110.14,109.6) 110.51,109.98 110.51,111.22 110.61,111.32 110.61,112.24 111.3,112.93 R68436.2 ; CN16.52 21.6,74.03 22.22,74.65 v2(22.22,74.95)
PCIE_CLKREQ_VGA#: length 82.2
  IN3 w0.102: v1(110.79,120.67) 109.52,121.94 109.52,127.91 109.77,128.17 109.77,128.47 110.33,129.03 110.33,154.63 110.74,155.04 110.74,157.2 111.17,157.63 111.17,159.15 111.58,159.56 111.58,164.26 112.44,165.12 112.44,169.06 112.26,169.24 112.26,172.44 108.61,176.09 v1(108.61,176.65)
  BOTTOM w0.102: R68441.2 111.17,115.53 110.87,115.83 110.87,116.11 110.79,116.18 110.79,119.45 110.41,119.83 110.41,120.29 v1(110.79,120.67) 110.89,120.78 U6539.DW30
  BOTTOM w0.114: v1(108.61,176.65) 108.61,179.96 109.24,180.59 v2(110.21,180.59) 111.35,180.59 111.88,181.12 111.88,182.19 112.49,182.8 112.49,186.53 112.31,186.71 Q9.3 113.14,187.41 113.8,188.07 R25487.1
PCIE_CLKREQ_WLAN#: length 99.2
  TOP w0.114: Q63.1 185.09,109.62 185.26,109.45 v1(185.59,109.45)
  IN4 w0.089: v1(110.12,110.51) 110.66,110.51 111.04,110.13 111.81,110.13 114.22,107.72 117.14,107.72 118.28,106.58 122.47,106.58 122.7,106.8 124.91,106.8 126.26,105.46 126.26,104.57 128.94,101.88 140.13,101.88 140.31,102.06 142.43,102.06 142.74,101.75 146.98,101.75 147.37,101.37 155.75,101.37 156.26,100.86 179.98,100.86 183.81,104.7 183.81,107.06 185.59,108.84 v1(185.59,109.45)
  BOTTOM w0.102: R68440.2 110.69,113.21 110.92,113.43 110.92,113.81 110.79,113.94 110.79,115.62 110.66,115.75 110.66,116.02 110.59,116.1 110.59,119.35 110.21,119.73 110.21,120.72 110.66,121.18 110.66,121.39 110.7,121.49 110.89,121.68 U6539.DV30
  BOTTOM w0.114: R68440.2 110.49,112.44 110.36,112.32 110.36,111.61 110.05,111.31 v2(110.05,111.12) 110.12,111.05 v1(110.12,110.51)
PCIE_RCOMPN: length 5
  BOTTOM w0.102: R68421.1 121.81,118.42 121.69,118.54 121.69,118.7 121.46,118.93 121.46,119.56 120.82,120.2 120.82,120.55 120.62,120.75 120.62,121.07 120.5,121.63 120.37,121.76 120.37,122.31 U6539.DT9
PCIE_RCOMPP: length 5
  BOTTOM w0.102: R68421.2 121.36,118.42 121.48,118.54 121.48,118.61 121.33,118.77 120.95,118.77 120.83,118.89 120.83,119.03 120.95,119.15 121.11,119.15 121.25,119.3 121.25,119.48 120.62,120.11 120.62,120.46 120.42,120.66 120.42,121.05 120.33,121.46 120.25,121.58 120.07,121.76 U6539.DV9
PCIE_REQ_LAN#_R: length 6.6
  TOP w0.114: U6521.48 22.69,162.03 22.91,161.82 22.91,161.31 23.19,161.03 R25445.1 23.19,159.9 R25446.2 23.79,160.04 25.45,160.04 25.7,160.3 Q6531.3
PCIE_RXN3_WLAN: length 81.8
  IN4 w0.089: v1(126,132.48) 125.93,132.48 125.7,132.26 125.7,132.08 125.88,131.9 130.73,131.9 132.05,130.58 132.05,128.75 134.41,126.39 134.41,122.58 136.57,120.42 136.57,118.39 139.29,115.67 139.29,113.02 140.28,112.04 141.22,112.04 141.29,111.96 151.25,111.96 152.48,110.73 165.75,110.73 166.88,111.86 168.02,111.86 168.25,112.09 169.52,112.09 170.1,112.67 171.14,112.67 172.06,113.59 173.89,113.59 174.99,114.69 174.99,115.02 175.61,115.64 175.61,115.86 175.26,116.21 v2(175.07,116.21)
  BOTTOM w0.089: v1(126,132.48) 125.37,131.85 123.92,131.85 U6539.CT1
  BOTTOM w0.114: CN17.43 183.46,113.15 183.33,113.29 182.93,113.29 182.69,113.05 181.17,113.05 180.67,113.56 179.91,113.56 178.34,115.13 175.89,115.13 175.35,115.67 175.35,115.93 v2(175.07,116.21)
PCIE_RXN5_SSD: length 161.6
  IN1 w0.089: v1(130.73,135.23) 130.63,135.12 130.63,134.94 130.73,134.85 134.46,134.85 135.48,133.83 135.48,131.44 136.01,130.91 136.01,124.81 135.05,123.85 135.05,121.61 129.92,116.47 129.92,115.11 125.52,110.72 119.37,110.72 118.79,110.13 112.57,110.13 112.34,109.9 104.69,109.9 104.24,109.45 101.62,109.45 100.01,107.83 94.01,107.83 93.67,107.49 92.41,107.49 92.03,107.11 88.51,107.11 88.08,106.68 82.57,106.68 82.06,106.17 79.44,106.17 77.28,104.01 76.6,104.01 72.43,99.84 72.05,99.84 71.03,98.82 71.03,97.42 68.17,94.56 48.91,94.56 48.43,94.08 30.02,94.08 28.3,92.37 28.3,89.24 30.02,87.52 30.02,85.24 30.35,84.91 31.11,84.91 31.29,85.09 31.29,85.24 v2(31.65,85.59)
  BOTTOM w0.089: U6539.CN1 124.05,133.32 127.97,133.32 128.02,133.27 128.06,133.27
  BOTTOM w0.114: R2652.1 34.14,82.8 33.93,83.01 33.93,84.25 32.8,85.38 31.86,85.38 v2(31.65,85.59) ; 128.06,133.27 129.73,133.27 130.53,134.06 130.53,135.02 v1(130.73,135.23)
PCIE_RXN5_SSD_C: length 2.6
  BOTTOM w0.114: CN16.5 33.35,81.27 33.22,81.41 33.22,81.51 33.39,81.68 33.66,81.68 33.92,81.94 33.92,82.16 34.1,82.35 R2652.2
PCIE_RXN6_SSD: length 160.5
  IN1 w0.089: v1(128.57,135.02) 128.57,135.02 128.97,134.62 129.45,134.62 129.99,134.08 133.83,134.08 134.72,133.2 134.72,130.91 135.25,130.38 135.25,125.32 134.11,124.17 134.11,121.73 129.15,116.77 129.15,115.41 125.57,111.83 119.42,111.83 118.49,110.89 112.31,110.89 112.14,111.06 106.69,111.06 106.29,110.66 104.39,110.66 103.93,110.21 101.32,110.21 100.05,108.94 92.58,108.94 91.51,107.87 88.19,107.87 87.75,107.44 81.55,107.44 81.05,106.93 79.14,106.93 76.98,104.77 74.82,104.77 71.65,101.6 71.32,101.6 70.28,100.56 70.28,97.94 67.66,95.32 48.61,95.32 48.18,94.89 45.21,94.89 44.7,95.4 39.92,95.4 39.39,94.87 29.74,94.87 27.55,92.68 27.55,88.85 29.08,87.32 29.08,84.91 30.01,83.98 30.44,83.98 30.77,83.65 v2(30.77,83.49)
  BOTTOM w0.089: 128.06,134.16 128.04,134.16 128.01,134.13 126.16,134.13 125.88,133.85 123.04,133.85 U6539.CL3
  BOTTOM w0.114: v2(30.77,83.49) 30.77,83.56 30.51,83.82 30.26,83.82 30.13,83.7 30.13,83.22 30.58,82.77 R2654.1 ; v1(128.57,135.02) 128.57,135 128.98,134.59 128.98,134.41 128.72,134.16 128.06,134.16
PCIE_RXN6_SSD_C: length 2.1
  BOTTOM w0.114: R2654.2 30.66,82.32 30.32,81.99 30.32,81.38 30.35,81.35 CN16.17
PCIE_RXN7_SSD: length 156.9
  IN1 w0.089: v1(127.76,135.12) 127.76,134.44 128.01,134.18 129.33,134.18 129.84,133.68 133.6,133.68 134.31,132.97 134.31,125.3 133.65,124.64 133.65,121.84 128.49,116.68 127.88,116.68 127.17,115.97 127.17,115.21 124.71,112.75 123.36,112.75 122.84,112.22 119.26,112.22 118.34,111.3 114.78,111.3 114.61,111.47 106.54,111.47 106.15,111.08 103.61,111.08 103.19,110.66 101.21,110.66 99.88,109.33 92.33,109.33 91.28,108.28 88.03,108.28 87.6,107.85 81.38,107.85 80.87,107.34 78.99,107.34 76.83,105.18 74.67,105.18 71.49,102 71.17,102 69.87,100.71 69.87,98.17 67.43,95.73 48.43,95.73 48,95.3 45.41,95.3 44.9,95.81 39.69,95.81 39.21,95.32 29.64,95.32 27.15,92.83 27.15,88.61 28.37,87.4 28.37,83.97 28.08,83.68 27.88,83.68 v2(27.62,83.42)
  BOTTOM w0.089: U6539.CK2 123.43,134.32 123.67,134.08 125.72,134.08 126.1,134.46 127.38,134.46 127.61,134.7 127.61,134.98 v1(127.76,135.12)
  BOTTOM w0.114: v2(27.62,83.42) 27.38,83.42 27.23,83.27 27.23,83.01 27.46,82.77 R2656.1
PCIE_RXN7_SSD_C: length 2.2
  BOTTOM w0.114: CN16.29 27.35,81.14 27.2,81.29 27.2,82.08 27.44,82.32 R2656.2
PCIE_RXN8_SSD: length 157.9
  IN1 w0.089: v1(126.11,135.12) 126,135.12 125.83,134.95 125.83,134.59 126.8,133.61 129.09,133.61 129.61,133.09 132.78,133.09 133.07,132.81 133.07,132.18 133.73,131.52 133.73,125.83 132.99,125.1 132.99,122 128.36,117.37 127.17,117.37 125.32,115.52 125.32,114.25 124.48,113.41 122.5,113.41 121.89,112.8 117.52,112.8 117.14,112.42 110.79,112.42 110.43,112.06 106.31,112.06 105.91,111.66 101.39,111.66 99.64,109.9 92.02,109.9 90.98,108.86 87.8,108.86 87.37,108.43 80.26,108.43 79.8,107.97 78.81,107.97 78.66,107.82 77.92,107.82 76.29,106.19 74.86,106.19 71.3,102.63 70.9,102.63 67.66,99.39 67.66,98.5 65.48,96.31 48.15,96.31 47.82,95.98 45.54,95.98 45.13,96.39 39.26,96.39 38.83,95.96 29.47,95.96 26.56,93.05 26.56,87.65 26.72,87.5 26.72,84.22 25.65,83.16 24.05,83.16 23.82,83.39 23.82,83.7 v1(23.67,83.84)
  BOTTOM w0.089: U6539.CK4 122.8,134.32 122.98,134.5 123.15,134.56 123.18,134.57 125.45,134.57 126,135.12
  BOTTOM w0.102: v1(126.11,135.12) 126,135.12
  BOTTOM w0.114: v1(23.67,83.84) 23.77,83.74 23.77,83.19 23.67,83.08 R646.1
PCIE_RXN8_SSD_C: length 2.2
  BOTTOM w0.114: CN16.43 23.85,81.36 23.95,81.46 23.95,82.16 23.77,82.35 R646.2
PCIE_RXN9_LAN: length 174.4
  TOP w0.114: v2(18.84,160.04) 18.66,159.86 18.48,159.86 18.32,160.01 18.32,160.49 18.54,160.71 C96306.2
  IN1 w0.089: v2(18.84,160.04) 18.84,159.92 18.68,159.75 18.45,159.75 18.29,159.92 18.29,162.41 18.84,162.96 27.35,162.96 29,164.61 30.78,164.61 32.13,165.96 34.41,165.96 35.78,167.33 35.78,169.87 41.52,175.61 41.88,175.61 43.76,177.49 51.63,177.49 53.64,175.49 64.87,175.49 69.18,171.17 81.53,171.17 82.29,171.93 87.69,171.93 87.84,172.08 92.28,172.08 92.43,171.93 93.5,171.93 93.61,171.81 99.7,171.81 103.07,175.18 105,175.18 105.43,174.75 112.39,174.75 112.92,174.22 113.76,174.22 114.91,173.07 116.58,173.07 116.71,172.95 116.71,172.29 116.94,172.06 116.94,169.9 117.77,169.06 117.77,167.03 118.49,166.32 118.49,165.68 119.17,165 121.67,165 125.28,161.39 128.37,161.39 128.75,161.01 128.75,158.82 125.19,155.27 125.19,151.36 125.91,150.64 128.32,150.64 128.77,150.19 128.77,144.22 131.06,141.93 131.06,140.07 130.84,139.85 v1(130.73,139.85)
  BOTTOM w0.089: U6539.CG4 122.82,135.46 123.08,135.46 123.17,135.41 124.14,135.41 124.63,135.91 126.16,135.91 126.41,136.17 127.97,136.17 127.98,136.18 128.01,136.18 128.05,136.22 128.06,136.22
  BOTTOM w0.114: 128.06,136.22 128.62,136.22 129.84,137.44 129.84,138.19 131.01,139.36 131.01,139.57 v1(130.73,139.85)
PCIE_RXN_LAN_L: length 2.4
  TOP w0.114: C96306.1 18.54,161.16 18.32,161.37 18.32,161.6 18.44,161.72 18.69,161.72 18.99,162.02 18.99,162.23 19.09,162.32 U6521.39
PCIE_RXP3_WLAN: length 81.8
  IN4 w0.089: v2(175.83,116.21) 175.79,116.16 175.79,115.57 175.17,114.94 175.17,114.61 173.96,113.41 172.13,113.41 171.22,112.49 170.17,112.49 169.59,111.91 168.32,111.91 168.09,111.68 166.95,111.68 165.82,110.55 152.41,110.55 151.18,111.78 141.22,111.78 141.14,111.86 140.2,111.86 139.11,112.95 139.11,115.59 136.39,118.31 136.39,120.34 134.23,122.5 134.23,126.31 131.87,128.68 131.87,130.5 130.66,131.72 125.81,131.72 125.53,132.01 125.53,132.33 125.52,132.34 125.52,132.36 v1(125.39,132.48)
  BOTTOM w0.089: U6539.CT2 123.52,132.1 124.12,132.1 124.2,132.03 125.3,132.03 125.39,132.12 v1(125.39,132.48)
  BOTTOM w0.114: v2(175.83,116.21) 175.58,115.95 175.58,115.77 175.98,115.36 178.43,115.36 180,113.79 180.76,113.79 181.27,113.28 182.6,113.28 182.83,113.51 183.4,113.51 183.54,113.65 CN17.41
PCIE_RXP5_SSD: length 161.7
  IN1 w0.089: v2(31.66,84.93) 31.39,84.93 31.18,84.73 30.27,84.73 29.84,85.17 29.84,87.45 28.13,89.16 28.13,92.44 29.94,94.26 48.36,94.26 48.84,94.74 68.1,94.74 70.85,97.49 70.85,98.89 71.98,100.02 72.36,100.02 76.53,104.19 77.21,104.19 79.37,106.35 81.99,106.35 82.49,106.85 88.01,106.85 88.44,107.29 91.95,107.29 92.33,107.67 93.59,107.67 93.94,108.01 99.93,108.01 101.54,109.62 104.16,109.62 104.62,110.08 112.26,110.08 112.49,110.31 118.71,110.31 119.3,110.89 125.45,110.89 129.74,115.19 129.74,116.55 134.87,121.68 134.87,123.92 135.83,124.89 135.83,130.83 135.3,131.37 135.3,133.76 134.39,134.67 130.65,134.67 v1(130.09,135.23)
  BOTTOM w0.089: 128.06,133.5 123.97,133.5 123.92,133.45 123.52,133.45 U6539.CN2
  BOTTOM w0.114: 128.06,133.5 129.64,133.5 130.3,134.16 130.3,135.02 v1(130.09,135.23) ; R2653.1 33.48,82.8 33.7,83.01 33.7,84.15 32.7,85.15 31.87,85.15 v2(31.66,84.93)
PCIE_RXP5_SSD_C: length 2.7
  BOTTOM w0.114: CN16.7 32.85,81.21 32.99,81.35 32.99,81.6 33.29,81.91 33.56,81.91 33.69,82.04 33.69,82.22 33.56,82.35 R2653.2
PCIE_RXP6_SSD: length 160.5
  IN1 w0.089: v2(129.2,135.02) 129.43,134.8 129.52,134.8 130.06,134.26 133.9,134.26 134.89,133.27 134.89,130.98 135.43,130.45 135.43,125.24 134.28,124.1 134.28,121.65 129.33,116.7 129.33,115.34 125.64,111.65 119.49,111.65 118.56,110.72 112.24,110.72 112.07,110.89 106.77,110.89 106.37,110.49 104.46,110.49 104.01,110.03 101.39,110.03 100.12,108.76 92.65,108.76 91.59,107.69 88.26,107.69 87.83,107.26 81.63,107.26 81.12,106.75 79.22,106.75 77.06,104.59 74.9,104.59 71.72,101.42 71.39,101.42 70.45,100.48 70.45,97.86 67.74,95.15 48.69,95.15 48.26,94.71 45.13,94.71 44.63,95.22 40,95.22 39.46,94.69 29.82,94.69 27.73,92.6 27.73,88.92 29.26,87.4 29.26,84.99 30.09,84.15 v1(30.79,84.15)
  BOTTOM w0.089: 128.06,133.93 128.04,133.93 128.01,133.96 126.23,133.96 125.95,133.68 123.29,133.68 123.03,133.42 122.8,133.42 122.47,133.75 U6539.CL4
  BOTTOM w0.114: v2(129.2,135.02) 129.2,134.32 128.82,133.93 128.06,133.93 ; v1(30.79,84.15) 30.69,84.05 30.16,84.05 29.9,83.79 R2655.1
PCIE_RXP6_SSD_C: length 2.1
  BOTTOM w0.114: CN16.19 29.85,81.26 30.09,81.5 30.09,82.13 R2655.2
PCIE_RXP7_SSD: length 156.8
  IN1 w0.089: v2(27.61,84.18) 27.61,83.99 27.73,83.86 28.01,83.86 28.19,84.04 28.19,87.32 26.97,88.54 26.97,92.9 29.57,95.5 39.14,95.5 39.62,95.98 44.98,95.98 45.49,95.48 47.92,95.48 48.36,95.91 67.36,95.91 69.69,98.24 69.69,100.78 71.09,102.18 71.42,102.18 74.59,105.36 76.76,105.36 78.92,107.51 80.8,107.51 81.3,108.02 87.53,108.02 87.96,108.45 91.21,108.45 92.26,109.51 99.8,109.51 101.14,110.84 103.12,110.84 103.54,111.26 106.08,111.26 106.47,111.65 114.68,111.65 114.85,111.48 118.26,111.48 119.18,112.4 122.76,112.4 123.29,112.93 124.64,112.93 127,115.28 127,116.05 127.81,116.86 128.42,116.86 133.47,121.92 133.47,124.71 134.13,125.37 134.13,132.89 133.53,133.5 129.76,133.5 129.26,134.01 127.93,134.01 127.58,134.36 127.58,134.77 127.45,134.9 127.35,134.9 v1(127.12,135.12)
  BOTTOM w0.089: v1(127.12,135.12) 127.26,135.12 127.43,134.96 127.43,134.77 127.31,134.64 126.03,134.64 125.65,134.26 123.97,134.26 U6539.CK1
  BOTTOM w0.114: R2657.1 26.78,82.77 27,83 27,83.37 27.15,83.51 27.15,83.63 27.61,84.09 v2(27.61,84.18)
PCIE_RXP7_SSD_C: length 2.1
  BOTTOM w0.114: R2657.2 26.8,82.32 26.97,82.16 26.97,81.22 26.85,81.1 CN16.31
PCIE_RXP8_SSD: length 157.8
  IN1 w0.089: v2(24.3,83.84) 24.18,83.84 23.99,83.65 23.99,83.46 24.12,83.33 25.58,83.33 26.54,84.3 26.54,87.43 26.39,87.58 26.39,93.13 29.4,96.14 38.76,96.14 39.19,96.57 45.2,96.57 45.61,96.16 47.75,96.16 48.08,96.49 65.4,96.49 67.48,98.57 67.48,99.46 70.83,102.81 71.22,102.81 74.78,106.37 76.22,106.37 77.85,108 78.59,108 78.74,108.15 79.73,108.15 80.19,108.61 87.3,108.61 87.73,109.04 90.9,109.04 91.94,110.08 99.56,110.08 101.32,111.83 105.84,111.83 106.24,112.23 110.35,112.23 110.72,112.59 117.07,112.59 117.45,112.98 121.82,112.98 122.43,113.59 124.41,113.59 125.14,114.32 125.14,115.59 127.1,117.55 128.29,117.55 132.82,122.07 132.82,125.17 133.55,125.9 133.55,131.44 132.89,132.1 132.89,132.74 132.71,132.91 129.54,132.91 129.02,133.44 126.73,133.44 125.65,134.52 125.65,134.95 v1(125.47,135.12)
  BOTTOM w0.089: v1(125.47,135.12) 125.47,134.9 125.32,134.75 123.15,134.75 123.14,134.75 123.1,134.73 123.09,134.73 122.81,134.63 122.27,134.63 U6539.CK5
  BOTTOM w0.114: R647.1 24.43,82.97 24.32,83.08 24.13,83.08 24,83.21 24,83.54 v2(24.3,83.84)
PCIE_RXP8_SSD_C: length 2.2
  BOTTOM w0.114: CN16.41 24.35,81.26 24.18,81.42 24.18,82.2 24.33,82.35 R647.2
PCIE_RXP9_LAN: length 174.5
  TOP w0.114: v2(17.83,160.04) 18.09,160.31 18.09,160.49 17.88,160.71 C96307.2
  IN1 w0.089: v1(131.36,139.84) 131.24,139.97 131.24,142.01 128.95,144.29 128.95,150.26 128.39,150.82 125.98,150.82 125.37,151.43 125.37,155.19 128.93,158.75 128.93,161.08 128.44,161.57 125.35,161.57 121.75,165.17 119.25,165.17 118.66,165.75 118.66,166.39 117.95,167.1 117.95,169.14 117.11,169.97 117.11,172.13 116.89,172.36 116.89,173.02 116.65,173.25 114.98,173.25 113.84,174.39 113,174.39 112.46,174.93 105.51,174.93 105.07,175.36 102.99,175.36 99.63,171.99 93.68,171.99 93.57,172.11 92.5,172.11 92.36,172.25 87.76,172.25 87.62,172.11 82.22,172.11 81.46,171.35 69.26,171.35 64.94,175.66 53.71,175.66 51.71,177.67 43.69,177.67 41.81,175.79 41.45,175.79 35.61,169.95 35.61,167.41 34.34,166.14 32.05,166.14 30.71,164.79 28.93,164.79 27.28,163.14 18.77,163.14 18.11,162.48 18.11,160.33 v2(17.83,160.04)
  BOTTOM w0.089: U6539.CG5 122.17,135.67 122.46,135.37 122.66,135.37 122.74,135.29 123.03,135.29 123.13,135.24 124.21,135.24 124.71,135.73 126.23,135.73 126.49,135.99 128.06,135.99
  BOTTOM w0.114: 128.06,135.99 128.72,135.99 130.07,137.34 130.07,138.1 131.24,139.26 131.24,139.72 v1(131.36,139.84)
PCIE_RXP_LAN_L: length 2.4
  TOP w0.114: U6521.38 18.69,162.35 18.77,162.28 18.77,162.11 18.6,161.95 18.34,161.95 18.08,161.69 18.08,161.36 17.88,161.16 C96307.1
PCIE_TXN3_WLAN: length 80.8
  IN4 w0.089: v1(121.47,131.86) 121.58,131.75 121.58,131.75 122.38,130.96 130.86,130.96 131.41,130.4 131.41,128.24 133.75,125.9 133.75,122.22 135.99,119.99 135.99,118.08 138.6,115.47 138.6,112.9 140.05,111.45 140.58,111.45 140.68,111.35 150.84,111.35 152.04,110.16 166.06,110.16 166.72,110.82 167.87,110.82 168.55,111.5 169.82,111.5 170.36,112.04 171.32,112.04 172.29,113 175.13,113 176.91,114.78 176.91,116.14 176.74,116.3 v2(176.58,116.3)
  BOTTOM w0.102: U6539.CU7 121.47,131.63 v1(121.47,131.86)
  BOTTOM w0.114: v2(176.58,116.3) 177.1,115.78 178.62,115.78 180.08,114.33 180.83,114.33 181.05,114.11 181.36,114.11 181.56,113.91 C203.2
PCIE_TXN3_WLAN_C: length 3
  BOTTOM w0.114: CN17.37 183.57,114.65 183.42,114.8 183.06,114.8 182.75,114.49 182.75,114.36 182.49,114.1 182.2,114.1 182.01,113.91 C203.1
PCIE_TXN5_SSD: length 163.4
  IN1 w0.089: v1(23.39,88.39) 23.6,88.17 23.78,88.17 24.05,88.44 24.05,94.02 28.65,98.62 32.48,98.62 32.8,98.94 37.98,98.94 38.45,99.42 39.71,99.42 40.13,99.01 47.72,99.01 47.95,99.23 63.09,99.23 64.4,100.54 65.29,100.54 68.5,103.76 68.5,104.39 74.57,110.46 76.96,110.46 77.21,110.72 77.92,110.72 78.59,111.38 79.14,111.38 79.58,111.81 82.95,111.81 85.48,114.33 90.48,114.33 91.46,115.31 93.83,115.31 96.42,117.9 99.56,117.9 101.19,116.28 108.79,116.28 109.83,117.32 114.14,117.32 114.78,116.68 114.78,115.87 115.05,115.59 117.68,115.59 117.98,115.89 117.98,116.17 118.46,116.66 120.29,116.66 120.75,117.12 121.26,117.12 121.46,117.32 122.3,117.32 122.91,117.93 122.91,118.82 124.46,120.37 124.91,120.37 127.25,122.7 127.25,124.92 127.1,125.07 127.1,126.18 128.05,127.14 128.18,127.14 128.39,127.35 128.39,127.73 128.75,128.09 129.28,128.09 131.21,130.02 131.21,130.35 130.99,130.58 128.62,130.58 128.53,130.67 123.15,130.67 121.9,131.91 121.9,133.18 122.04,133.32 122.04,134.5 121.84,134.88 121.84,135.27 122.04,135.48 122.04,135.71 121.85,135.9 121.32,135.9 121.2,135.78 121.2,135.66 121.34,135.52 v1(121.49,135.52)
  BOTTOM w0.102: v1(121.49,135.52) 121.37,135.52 121.24,135.4 U6539.CJ7
  BOTTOM w0.114: v1(23.39,88.39) 25.73,88.39 27.88,86.23 28.39,86.23 29.76,84.86 31.08,84.86 31.47,84.47 31.87,84.47 32.12,84.22 32.55,84.22 32.81,83.96 C788.1
PCIE_TXN5_SSD_C: length 3.5
  BOTTOM w0.114: CN16.11 31.85,81.36 31.77,81.44 31.77,81.91 32.55,82.69 32.55,83.15 32.76,83.36 C788.2
PCIE_TXN6_SSD: length 162.7
  IN1 w0.089: v1(23.39,86.51) 23.59,86.31 23.74,86.31 23.9,86.46 23.9,87.47 24.63,88.21 24.63,93.8 28.82,97.99 35.02,97.99 35.41,98.37 47.98,98.37 48.26,98.65 63.32,98.65 64.62,99.96 65.51,99.96 69.13,103.58 69.13,103.98 71.91,106.75 72.73,106.75 75.85,109.88 77.32,109.88 77.57,110.13 78.15,110.13 78.79,110.77 83.23,110.77 84.89,112.43 84.89,112.94 85.72,113.76 90.79,113.76 91.74,114.7 94.03,114.7 96.62,117.29 99.26,117.29 100.96,115.59 106.6,115.59 106.85,115.34 109.77,115.34 110.03,115.59 113.84,115.59 114.42,115.01 117.9,115.01 118.5,115.6 120.17,115.6 120.97,116.4 121.38,116.4 121.71,116.74 122.85,116.74 124.01,117.89 124.01,118.32 126.11,120.42 126.11,120.75 127.88,122.53 127.88,125.17 127.68,125.37 127.68,125.95 128.11,126.39 128.82,126.39 129.51,127.07 131.42,127.07 131.8,127.45 131.8,130.58 131.21,131.16 128.85,131.16 128.77,131.24 124.1,131.24 123.19,132.15 123.19,136.21 122.59,136.81 121.42,136.81 121.27,136.66 121.27,136.57 121.4,136.44 v1(121.57,136.44)
  BOTTOM w0.102: v1(121.57,136.44) 121.57,136.31 U6539.CG7
  BOTTOM w0.114: v1(23.39,86.51) 23.57,86.33 23.73,86.33 24.79,87.4 25.78,87.4 27.6,85.57 28.04,85.57 28.6,85.01 28.6,84.17 28.96,83.81 C790.1
PCIE_TXN6_SSD_C: length 3.2
  BOTTOM w0.114: CN16.23 28.85,81.45 28.72,81.58 28.72,82.16 28.88,82.32 28.88,83.16 29.08,83.36 C790.2
PCIE_TXN7_SSD: length 160.2
  IN1 w0.089: v1(25.83,84.73) 25.67,84.58 25.67,84.58 25.62,84.53 25.62,84.25 25.39,84.02 24.89,84.02 24.48,84.43 24.48,87.25 25.22,87.98 25.22,93.57 29,97.35 35.35,97.35 35.79,97.79 48.46,97.79 48.59,97.66 63.4,97.66 64.8,99.06 65.43,99.06 70.4,104.04 70.82,104.04 76.09,109.31 77.58,109.31 77.82,109.55 79.22,109.55 79.86,110.18 90.33,110.18 91.37,111.22 99.08,111.22 101.24,113.38 106.55,113.38 107.87,114.7 110.03,114.7 110.34,115.01 113.4,115.01 114.42,113.99 116.68,113.99 117.06,114.37 118.08,114.37 118.74,115.03 121.25,115.03 121.46,115.23 121.46,115.67 121.89,116.1 123.62,116.1 124.9,117.38 124.9,118.27 125.91,119.28 127.18,119.28 128.62,120.72 128.62,125.29 129.08,125.75 130.09,125.75 130.6,126.26 131.49,126.26 132.38,127.15 132.38,130.81 131.44,131.75 129.07,131.75 128.94,131.87 124.28,131.87 123.76,132.39 123.76,137.04 122.86,137.94 122.22,137.94 122,137.73 120.66,137.73 120.57,137.64 120.57,137.48 120.7,137.35 v1(120.84,137.35)
  BOTTOM w0.102: v1(120.84,137.35) 120.86,137.34 120.86,137.16 U6539.CD8
  BOTTOM w0.114: C792.1 25.91,83.94 25.67,84.18 25.67,84.57 25.69,84.58 25.69,84.59 v1(25.83,84.73)
PCIE_TXN7_SSD_C: length 3.3
  BOTTOM w0.114: CN16.35 25.85,81.41 25.7,81.56 25.7,83.31 25.88,83.49 C792.2
PCIE_TXN8_SSD: length 159.6
  IN1 w0.089: v1(121.49,138.27) 121.46,138.31 121.46,138.49 121.55,138.58 123.11,138.58 124.33,137.36 124.33,134.82 126.29,132.86 128.78,132.86 129.31,132.33 131.77,132.33 132.96,131.14 132.96,126.46 132.03,125.53 132.03,122.1 128.52,118.59 126.62,118.59 126.14,118.11 126.14,117.79 124.3,115.95 124.3,115.48 123.7,114.88 121.94,114.88 121.13,114.07 118.79,114.07 118.41,113.69 117.27,113.69 116.81,113.23 114.3,113.23 113.79,113.74 110.84,113.74 109.91,112.8 106,112.8 105.61,112.42 101.09,112.42 99.32,110.65 91.61,110.65 90.57,109.61 87.49,109.61 87.07,109.19 84.17,109.19 83.76,109.6 80.16,109.6 79.3,108.73 78.51,108.73 78.36,108.58 78,108.58 77.84,108.73 76.33,108.73 71.02,103.43 70.61,103.43 65.53,98.34 65.53,98.01 64.59,97.08 47.85,97.08 47.57,96.8 45.94,96.8 45.59,97.15 37.23,97.15 36.83,96.75 29.2,96.75 25.8,93.35 25.8,87.75 25.19,87.14 25.19,86.38 25.45,86.13 v1(25.45,85.99)
  BOTTOM w0.102: U6539.CB7 121.42,137.81 121.54,137.94 121.54,138.22 v1(121.49,138.27)
  BOTTOM w0.114: C794.1 22.65,84.22 22.52,84.35 22.25,84.35 22.12,84.48 22.12,84.99 22.25,85.11 23.78,85.11 24.94,86.28 25.24,86.28 25.45,86.08 v1(25.45,85.99)
PCIE_TXN8_SSD_C: length 3.5
  BOTTOM w0.114: CN16.47 22.85,81.31 22.71,81.44 22.71,81.75 22.37,82.09 22.37,83.26 22.6,83.49 C794.2
PCIE_TXN9_LAN: length 155.9
  TOP w0.114: U6521.42 20.29,162.38 20.21,162.3 20.21,161.72 20.35,161.58 20.35,160.97 20.03,160.65 19.9,160.65 v2(19.66,160.41)
  IN1 w0.089: v2(19.66,160.41) 19.38,160.68 19.1,160.68 18.79,160.98 18.79,162.15 19.17,162.53 21.69,162.53 22.52,161.69 26.84,161.69 29.26,164.11 31.04,164.11 32.43,165.5 34.72,165.5 36.61,167.39 36.61,169.78 43.93,177.1 51.21,177.1 53.36,174.95 64.51,174.95 68.8,170.66 82.17,170.66 83.03,171.52 88.11,171.52 88.27,171.68 91.91,171.68 92.07,171.52 93.34,171.52 93.44,171.42 100.07,171.42 101.9,173.25 102.79,173.25 103.81,174.27 104.87,174.27 104.95,174.34 112.13,174.34 112.69,173.78 113.58,173.78 115.69,171.68 115.69,170.5 116.07,170.12 116.07,169.39 117.32,168.14 117.32,165.83 118.97,164.18 118.97,162.91 119.23,162.64 123.17,162.64 124.27,161.54 124.27,151.13 125.15,150.25 127.11,150.25 127.88,149.48 127.88,143.97 128.6,143.25 128.6,141.73 v1(128.82,141.5)
  BOTTOM w0.114: v1(128.82,141.5) 128.71,141.5 128.58,141.37 128.58,141.11 128.73,140.96 C96792.2
PCIE_TXN9_LAN_C: length 10
  IN3 w0.114: v1(120.84,139.18) 121.23,138.79 121.93,138.79 122.09,138.96 128.21,138.96 128.5,139.25 128.5,139.78 v1(128.57,139.85)
  BOTTOM w0.114: v1(120.84,139.18) 120.84,138.98 U6539.BY8 ; C96792.1 128.57,140.26 v1(128.57,139.85)
PCIE_TXP3_WLAN: length 80.8
  IN4 w0.089: v1(120.82,131.86) 121.22,131.47 121.62,131.47 122.3,130.78 130.78,130.78 131.24,130.33 131.24,128.17 133.57,125.83 133.57,122.15 135.81,119.91 135.81,118.01 138.43,115.39 138.43,112.83 139.98,111.27 140.51,111.27 140.61,111.17 150.77,111.17 151.96,109.98 166.13,109.98 166.79,110.64 167.94,110.64 168.63,111.32 169.9,111.32 170.43,111.86 171.39,111.86 172.36,112.82 175.2,112.82 177.08,114.7 177.08,116.1 v2(177.28,116.3)
  BOTTOM w0.102: v1(120.82,131.86) 120.82,131.64 U6539.CU8
  BOTTOM w0.114: C202.2 181.56,114.48 181.42,114.34 181.14,114.34 180.93,114.56 180.17,114.56 178.72,116.01 177.57,116.01 v2(177.28,116.3)
PCIE_TXP3_WLAN_C: length 3
  BOTTOM w0.114: CN17.35 183.61,115.15 183.5,115.03 182.97,115.03 182.52,114.58 182.52,114.45 182.39,114.33 182.14,114.33 182.01,114.46 C202.1
PCIE_TXP5_SSD: length 163.4
  IN1 w0.089: v1(120.87,135.52) 121.03,135.68 121.03,135.86 121.24,136.08 121.93,136.08 122.22,135.79 122.22,135.4 122.02,135.2 122.02,134.92 122.22,134.55 122.22,133.25 122.08,133.11 122.08,131.99 123.22,130.84 128.61,130.84 128.69,130.76 131.06,130.76 131.39,130.43 131.39,129.95 129.35,127.91 128.82,127.91 128.57,127.66 128.57,127.28 128.25,126.96 128.13,126.96 127.27,126.11 127.27,125.14 127.43,124.99 127.43,122.63 124.99,120.19 124.53,120.19 123.08,118.74 123.08,117.85 122.37,117.14 121.53,117.14 121.33,116.94 120.82,116.94 120.36,116.48 118.54,116.48 118.16,116.1 118.16,115.82 117.75,115.41 114.98,115.41 114.6,115.8 114.6,116.61 114.07,117.14 109.9,117.14 108.86,116.1 101.11,116.1 99.49,117.73 96.49,117.73 93.9,115.13 91.54,115.13 90.55,114.15 85.55,114.15 83.03,111.63 79.65,111.63 79.22,111.2 78.66,111.2 78,110.54 77.29,110.54 77.03,110.28 74.65,110.28 68.68,104.31 68.68,103.68 65.36,100.37 64.47,100.37 63.17,99.06 48.03,99.06 47.8,98.83 40.05,98.83 39.64,99.24 38.53,99.24 38.05,98.76 32.88,98.76 32.56,98.45 28.72,98.45 24.23,93.95 24.23,88.36 23.86,87.99 23.63,87.99 v1(23.39,87.75)
  BOTTOM w0.102: U6539.CJ8 120.87,135.34 120.87,135.52 v1(120.87,135.52)
  BOTTOM w0.114: C789.1 32.05,83.97 31.78,84.24 31.37,84.24 30.98,84.63 29.67,84.63 28.3,86 27.79,86 25.63,88.16 23.79,88.16 v1(23.39,87.75)
PCIE_TXP5_SSD_C: length 3.5
  BOTTOM w0.114: C789.2 32.1,83.36 32.32,83.14 32.32,82.78 31.54,82.01 31.54,81.55 31.35,81.36 CN16.13
PCIE_TXP6_SSD: length 162.8
  IN1 w0.089: v1(23.39,85.87) 23.64,86.13 23.82,86.13 24.07,86.38 24.07,87.4 24.81,88.14 24.81,93.73 28.9,97.81 35.1,97.81 35.48,98.19 48.05,98.19 48.33,98.47 63.39,98.47 64.7,99.78 65.59,99.78 69.31,103.5 69.31,103.9 71.98,106.58 72.8,106.58 75.92,109.7 77.39,109.7 77.64,109.95 78.23,109.95 78.86,110.59 83.31,110.59 85.07,112.35 85.07,112.86 85.79,113.58 90.87,113.58 91.81,114.53 94.1,114.53 96.69,117.12 99.18,117.12 100.88,115.41 106.53,115.41 106.78,115.16 109.85,115.16 110.1,115.41 113.76,115.41 114.35,114.83 117.98,114.83 118.57,115.42 120.24,115.42 121.05,116.23 121.45,116.23 121.79,116.56 122.93,116.56 124.19,117.82 124.19,118.24 126.28,120.34 126.28,120.67 128.06,122.45 128.06,125.24 127.86,125.45 127.86,125.88 128.19,126.21 128.9,126.21 129.59,126.9 131.49,126.9 131.97,127.38 131.97,130.65 131.28,131.34 128.92,131.34 128.85,131.42 124.18,131.42 123.37,132.22 123.37,136.29 122.66,136.99 121.35,136.99 121.09,136.74 121.09,136.61 v1(120.92,136.44)
  BOTTOM w0.102: U6539.CG8 120.92,136.31 v1(120.92,136.44)
  BOTTOM w0.114: v1(23.39,85.87) 23.62,86.1 23.82,86.1 24.89,87.17 25.68,87.17 27.51,85.34 27.94,85.34 28.37,84.92 C791.1
PCIE_TXP6_SSD_C: length 3.3
  BOTTOM w0.114: CN16.25 28.35,81.41 28.49,81.55 28.49,82.26 28.65,82.41 28.65,83.16 28.44,83.36 C791.2
PCIE_TXP7_SSD: length 160.2
  IN1 w0.089: v2(25.19,84.73) 25.45,84.48 25.45,84.32 25.32,84.2 24.96,84.2 24.66,84.5 24.66,87.17 25.4,87.91 25.4,93.5 29.07,97.18 35.43,97.18 35.86,97.61 48.38,97.61 48.51,97.48 63.47,97.48 64.87,98.88 65.5,98.88 70.48,103.86 70.9,103.86 76.17,109.13 77.65,109.13 77.89,109.37 79.29,109.37 79.93,110 90.4,110 91.44,111.05 99.16,111.05 101.32,113.2 106.62,113.2 107.94,114.53 110.1,114.53 110.41,114.83 113.33,114.83 114.35,113.81 116.76,113.81 117.14,114.2 118.16,114.2 118.81,114.85 121.32,114.85 121.64,115.16 121.64,115.59 121.96,115.92 123.69,115.92 125.08,117.31 125.08,118.19 125.98,119.1 127.25,119.1 128.8,120.65 128.8,125.22 129.15,125.57 130.17,125.57 130.68,126.08 131.56,126.08 132.56,127.08 132.56,130.88 131.51,131.92 129.14,131.92 129.01,132.05 124.35,132.05 123.94,132.46 123.94,137.11 122.93,138.12 122.14,138.12 121.93,137.9 120.58,137.9 120.39,137.71 120.39,137.53 v1(120.22,137.35)
  BOTTOM w0.102: v1(120.22,137.35) 120.22,137.35 120.22,137.17 U6539.CD9
  BOTTOM w0.114: C793.1 25.24,83.94 25.45,84.14 25.45,84.48 v2(25.19,84.73)
PCIE_TXP7_SSD_C: length 3.3
  BOTTOM w0.114: CN16.37 25.35,81.36 25.47,81.48 25.47,83.31 25.29,83.49 C793.2
PCIE_TXP8_SSD: length 159.7
  IN1 w0.089: v1(120.87,138.27) 121.2,138.6 121.31,138.6 121.33,138.62 121.33,138.62 121.47,138.76 123.19,138.76 124.51,137.43 124.51,134.89 126.36,133.04 128.85,133.04 129.39,132.51 131.85,132.51 133.14,131.21 133.14,126.39 132.21,125.45 132.21,122.02 128.59,118.41 126.69,118.41 126.31,118.04 126.31,117.72 124.47,115.88 124.47,115.41 123.77,114.7 122.01,114.7 121.2,113.89 118.87,113.89 118.49,113.51 117.34,113.51 116.88,113.05 114.22,113.05 113.71,113.56 110.91,113.56 109.98,112.63 106.07,112.63 105.68,112.24 101.16,112.24 99.4,110.47 91.68,110.47 90.64,109.43 87.56,109.43 87.14,109.01 84.1,109.01 83.69,109.42 80.23,109.42 79.37,108.56 78.58,108.56 78.43,108.4 77.92,108.4 77.77,108.56 76.41,108.56 71.1,103.25 70.68,103.25 65.7,98.27 65.7,97.94 64.66,96.9 47.92,96.9 47.65,96.62 45.87,96.62 45.51,96.97 37.31,96.97 36.9,96.57 29.27,96.57 25.98,93.28 25.98,87.68 25.37,87.07 25.37,86.79 v1(25.57,86.59)
  BOTTOM w0.102: U6539.CB8 120.87,138.09 v1(120.87,138.27)
  BOTTOM w0.114: C795.1 21.89,85.08 22.15,85.34 23.68,85.34 24.85,86.51 25.5,86.51 v1(25.57,86.59)
