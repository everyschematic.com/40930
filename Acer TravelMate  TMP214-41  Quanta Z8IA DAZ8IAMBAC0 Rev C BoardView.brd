# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TCP0_AUX_DP_R: length 5.1
  TOP w0.079: 23.06,67.93 23.05,67.92 23.04,67.92 arc(23,67.91) 22.97,67.89 22.87,67.79 arc(22.76,67.71) 22.62,67.68 21.69,67.68 arc(21.42,67.63) 21.2,67.48 20.97,67.25 arc(20.86,67.17) 20.73,67.13 arc(20.64,67.1) 20.56,67.04 20.23,66.71 arc(20.2,66.67) 20.19,66.62 20.19,66.42 arc(20.15,66.21) 20.03,66.03 U6549.L8
  TOP w0.114: 23.06,67.93 23.21,68.07 arc(23.27,68.16) 23.29,68.26 R68606.2
TCP0_FLASH_CLK: length 30.2
  TOP w0.079: v5(20.3,62.28) U6549.C7
  TOP w0.114: U6551.6 30.27,71.27 TP13351.1 29.64,70.63 28.49,70.63 27.73,71.4 27.73,73.94 28.19,74.39 28.19,75.18 27.47,75.9 27.11,75.9 26.94,75.74 v2(26.94,75.46)
  IN1 w0.089: v2(26.94,75.46) 26.94,75.18 26.08,74.32 26.08,70.2 24.86,68.98 23.62,68.98 22.09,67.46 21.78,67.46 20.25,65.94 18.84,65.94 18.66,65.76 18.66,63.45 18.84,63.27 19.31,63.27 v5(20.3,62.28)
TCP0_FLASH_CS#: length 41.7
  TOP w0.079: U6549.B6 21.09,61.59 21.09,61.02 21.56,60.55 v1(21.56,60.19)
  TOP w0.114: v1(27.35,79.02) 27.35,79.4 30.27,82.32 31.31,82.32 32.18,81.45 32.18,80.67 32.53,80.32 R68639.1 TP13350.1 U6551.1
  IN1 w0.089: v1(27.35,79.02) 25.1,76.77 25.1,70.67 24.56,70.13 23.34,70.13 21.69,68.48 21.49,68.48 20.96,67.94 20.62,67.94 20.34,68.22 18.79,68.22 18.16,67.59 17.95,67.59 16.94,66.57 16.94,62.53 18.39,61.08 21.15,61.08 21.56,60.68 v1(21.56,60.19)
TCP0_FLASH_DI: length 32.7
  TOP w0.079: v5(20.98,62.25) 20.98,62.25 U6549.C6
  TOP w0.114: U6551.5 29,71.27 TP13348.1 28.24,71.78 28.24,73.68 28.7,74.14 28.7,75.38 28.37,75.71 v1(28.37,76.48)
  IN1 w0.089: v5(20.98,62.25) 20.48,61.74 18.61,61.74 18.18,62.18 18.18,66.04 18.59,66.44 20.09,66.44 21.62,67.97 21.84,67.97 23.36,69.49 24.68,69.49 25.61,70.42 25.61,75.75 26.33,76.48 v1(28.37,76.48)
TCP0_FLASH_DO: length 41.6
  TOP w0.079: v5(22.73,60.48) 22.65,60.48 22.02,61.11 22.02,61.59 U6549.B4
  TOP w0.114: U6551.2 TP13349.1 31.16,80.03 R68637.1 31.57,80.32 31.8,80.54 31.8,81.43 31.16,82.06 30.4,82.06 28.49,80.16 28.49,78.64 v1(27.86,78)
  IN1 w0.089: v5(22.73,60.48) 22.52,60.48 21.51,61.49 18.33,61.49 17.19,62.63 17.19,66.44 18.08,67.33 18.28,67.33 18.92,67.97 20.21,67.97 20.47,67.71 21.03,67.71 21.54,68.22 21.76,68.22 23.29,69.75 24.56,69.75 25.4,70.58 25.4,76.12 26.77,77.49 27.35,77.49 v1(27.86,78)
TCP0_FLASH_HOLD#: length 2.5
  TOP w0.114: U6551.7 31.54,71.65 31.41,71.52 TP13346.1 31.44,71.11 R68636.1
TCP0_FLASH_MSTR_SLV: length 10.3
  TOP w0.079: U6549.A5 21.33,61.03 22.02,60.35 22.02,60.09 22.52,59.59 22.78,59.59 22.98,59.39 R68877.2
  TOP w0.114: R68875.1 28.87,59.46 v2(28.52,59.1) 27.92,58.5 23.74,58.5 23.52,58.72 R68617.1 R68877.2
TCP0_FLASH_SHARE_EN: length 10.3
  TOP w0.079: U6549.A4 21.79,61.11 22.39,60.51 22.39,60.28 22.63,60.04
  TOP w0.114: R68876.2 29,61.74 28.97,61.72 R68614.1 28.24,61.72 28.01,61.49 28.01,61.01 27.73,60.73 27.73,60.19 v2(27.25,59.71) 27.07,59.53 26,59.53 25.62,59.15 25.24,59.15 24.35,60.04 22.63,60.04
TCP0_FLASH_WP#: length 2.1
  TOP w0.114: U6551.3 TP13347.1 R68638.1
TCP0_GPIO_5: length 4.2
  TOP w0.079: U6549.B9 19.26,61.58 19.26,61.12 18.9,60.77 18.9,60.52
  TOP w0.114: 18.9,60.52 18.9,60.25 18.66,60.02 v4(18.13,60.02) 17.78,59.66 17.27,59.66 17.04,59.43 R68597.1
TCP0_GPIO_6: length 3
  TOP w0.079: 19.38,60.52 19.38,60.74 19.95,61.32 U6549.A8
  TOP w0.114: R68603.1 R68602.2 19.56,59.51 19.43,59.64 v4(19.43,60.25) 19.38,60.3 19.38,60.52
TCP0_GPIO_12: length 2.8
  TOP w0.079: 21.1,60.76 20.87,60.98 U6549.A6
  TOP w0.114: R68620.1 R68616.1 21,59.58 21.1,59.68 v4(21.1,60.22) 21.1,60.76
TCP0_JTAG_TCK: length 13.6
  TOP w0.079: U6549.B5 21.54,61.6 21.54,61.1 22.19,60.45 22.19,60.17 22.52,59.84 23.16,59.84 23.29,59.71
  TOP w0.114: TP13342.1 30.75,61.52 30.12,61.52 29.28,60.68 R68623.1 29,60.22 28.97,60.25 R68631.1 28.62,59.84 27.5,58.72 25.35,58.72 24.35,59.71 23.29,59.71
TCP0_JTAG_TDI: length 8.1
  TOP w0.079: 25.06,60.09 24.68,60.09 24.52,60.26 23.63,60.26 23.03,60.86 22.57,60.86 22.25,61.18 U6549.A3
  TOP w0.114: TP13340.1 27.35,61.36 27.17,61.19 27.02,61.19 26.87,61.03 R68621.1 26.87,60.5 26.46,60.09 25.06,60.09
TCP0_JTAG_TDO: length 2.8
  TOP w0.079: v5(21.62,62.91) U6549.C5
  BOTTOM w0.114: R68624.1 22.24,61.44 TP13343.1 21.79,61.9 21.79,62.73 v5(21.62,62.91)
TCP0_JTAG_TMS: length 3.9
  TOP w0.079: U6549.C3 v5(22.26,62.26)
  BOTTOM w0.114: R68622.1 23.79,60.35 TP13341.1 23.16,60.98 22.91,60.98 22.52,61.36 22.52,62 v5(22.26,62.26)
TCP0_RESET#: length 18.6
  TOP w0.079: 16.3,67.49 16.78,67.49 17.11,67.15 18.2,67.15 18.81,66.54 18.81,66.19 U6549.L11
  TOP w0.114: 16.3,67.49 16.02,67.49 15.54,67.97 15.54,70.13 v2(15.67,70.25) 15.89,70.48 R68625.1 16.71,70.48 16.76,70.43 17.11,70.43 17.34,70.66 17.34,71.34 R68630.1 R68628.1 17.04,72.89 17.19,73.05 18.21,73.05 18.59,73.43 18.59,74.51 18.97,74.89 Q6612.1 20.36,74.89 20.7,74.54 R68884.1 21.28,74.54 21.43,74.39 21.43,73.45 21.25,73.27 R68626.1
TCP0_TEST_PWRGD: length 6.4
  TOP w0.079: 25.06,60.32 24.84,60.32 24.68,60.47 23.67,60.47 23.09,61.06 22.63,61.06 22.47,61.21 22.47,61.59 U6549.B3
  TOP w0.114: R68595.1 26.74,61.52 26.46,61.24 26.46,60.47 26.31,60.32 25.06,60.32
TCP0_THERMDA: length 3.3
  TOP w0.079: U6549.M11 18.16,66.82 16.68,66.82 16.61,66.9 16.54,66.9
  TOP w0.114: 16.54,66.9 TP13344.1
TCP0_TX_N0: length 185.5
  TOP w0.114: C96800.1 25.27,65.85 arc(25.34,65.8) 25.42,65.79 25.49,65.79 arc(25.66,65.82) 25.8,65.92 v1(25.98,66.09)
  IN3 w0.089: 123.24,150.52 123.11,150.52 123.08,150.55 122.63,150.55 122.61,150.53 122.13,150.53 arc(122.06,150.52) 122,150.48 arc(121.97,150.43) 121.95,150.36 arc(121.95,150.32) 121.98,150.28 122.02,150.23 arc(122.1,150.18) v1(122.19,150.16)
  IN3 w0.114: 123.24,150.52 123.45,150.52 123.93,150.18 124.36,150.1 124.51,149.88 124.81,149.83 125.03,149.99 125.33,149.93 125.49,149.71 125.79,149.66 126.01,149.81 126.56,149.72 126.7,149.62 126.88,149.37 126.83,149.1 127.01,148.85 127.27,148.8 127.45,148.55 127.4,148.29 127.57,148.04 127.84,147.99 128.14,147.56 128.44,147.36 129.14,147.23 129.52,147.3 129.77,147.48 130.04,147.43 130.29,147.6 130.33,147.87 130.6,148.05 130.6,148.05 131.41,148.62 131.8,148.69 132.24,148.61 132.4,148.39 132.7,148.34 132.92,148.49 133.46,148.4 134.86,147.42 135.64,146.31 135.85,145.11 135.66,144.03 134.44,142.29 134.06,140.11 134.2,139.32 134.04,138.42 134.17,137.69 134.07,137.15 134.19,136.44 134.06,135.68 134.13,135.27 134.04,134.77 134.17,134.03 134.07,133.45 134.16,132.94 134.1,132.6 134.18,132.16 133.91,130.64 133.92,130.6 134.02,129.99 134.08,129.94 134.42,129.59 134.88,129.51 135.16,129.23 135.29,128.48 135.22,128.05 135.28,127.7 135.11,126.74 135.12,126.7 135.29,125.73 135.18,125.12 134.65,124.36 134.44,123.17 134.63,122.1 134.22,119.77 133.47,118.69 132.6,118.09 131.23,116.12 131,114.86 130.06,113.52 128.59,112.49 127.79,111.33 124.31,108.9 123.57,108.77 122.77,108.91 122.32,108.83 122.06,108.88 121.69,108.81 121.34,108.57 120.75,107.72 120.25,107.37 120,107.02 115.33,103.75 113.35,103.4 112.6,102.87 111.4,102.66 110.57,102.08 110.32,101.72 107.79,99.95 107.15,99.84 106.41,99.97 104.01,99.55 102.8,98.7 102.58,98.38 102.52,98.05 102.24,97.66 101.22,96.95 96.2,96.06 95.52,96.18 95.08,96.1 94.33,96.24 93.32,96.06 92.3,96.24 91.65,96.13 91.03,96.24 90.35,96.12 88.93,96.37 88.89,96.36 88.4,96.28 87.67,96.4 86.91,96.27 85.45,96.53 84.02,96.28 82.5,96.54 81.32,96.34 80.36,96.51 79.49,96.35 77.4,94.89 76.82,94.06 76.37,93.75 73.96,93.32 71.94,91.9 67.69,91.16 67.06,91.27 66.46,91.16 65.81,91.28 65.17,91.16 64.55,91.27 63.9,91.16 63.25,91.27 62.66,91.16 62.03,91.28 61.35,91.16 60.74,91.26 60.7,91.27 60.1,91.16 59.84,91.21 59.49,91.27 58.87,91.16 58.22,91.27 57.59,91.16 56.99,91.27 56.37,91.16 55.76,91.27 55.12,91.16 54.46,91.27 53.82,91.16 53.2,91.27 52.62,91.17 52.05,91.27 51.42,91.16 50.79,91.27 50.19,91.16 49.56,91.27 48.91,91.16 48.27,91.27 47.65,91.16 47.04,91.27 46.44,91.16 45.84,91.27 45.23,91.16 44.6,91.27 43.97,91.16 43.36,91.27 42.78,91.16 42.17,91.27 41.54,91.16 40.94,91.27 40.33,91.16 39.73,91.27 39.2,91.17 38.66,91.27 37.91,91.14 36.96,90.47 34.8,87.38 34.49,85.62 34.56,85.21 33.9,81.46 33.58,81.01 33.27,79.24 31.32,76.45 29.93,68.6 28.9,67.12 28.48,66.83 27.11,66.59 arc(26.95,66.54) 26.8,66.45 arc(26.6,66.31) 26.41,66.16 arc(26.26,66.11) 26.1,66.09 v1(25.98,66.09)
  BOTTOM w0.102: U6539.AT5 121.89,149.88 arc(121.9,149.93) 121.93,149.97 122.08,150.12 arc(122.12,150.15) 122.17,150.16 arc(122.18,150.16) v1(122.19,150.16)
TCP0_TX_N0_C: length 2.5
  TOP w0.079: U6549.J2 22.77,65.09 22.8,65.12 arc(22.82,65.13) 22.84,65.15 arc(22.85,65.16) 22.86,65.17 arc(22.99,65.24) 23.13,65.27 23.62,65.27 arc(23.64,65.27) 23.66,65.28 arc(23.7,65.3) 23.71,65.35 23.71,65.48 arc(23.8,65.7) 24.02,65.79 24.09,65.79 arc(24.12,65.79) 24.14,65.81 24.16,65.82 24.18,65.82
  TOP w0.114: 24.18,65.82 24.38,65.82 arc(24.46,65.86) 24.5,65.94 C96800.2
TCP0_TX_N1: length 190.4
  TOP w0.114: C96807.1 25.3,60.84 arc(25.37,60.85) v1(25.43,60.89)
  IN3 w0.089: 122.5,152.57 122.48,152.57 122.45,152.54 121.46,152.54 arc(121.27,152.47) 121.16,152.31 arc(121.11,152.18) 121.03,152.07 v1(120.95,151.99)
  IN3 w0.114: 122.5,152.57 122.67,152.57 123.08,152.5 124.57,151.45 127.83,150.88 127.83,150.87 128.23,150.8 128.54,150.86 133.08,150.06 135.62,148.28 136.72,146.71 136.99,145.17 136.72,143.59 135.51,141.86 135.2,140.09 135.33,139.32 135.18,138.46 135.31,137.73 135.21,137.15 135.34,136.38 135.21,135.59 135.26,135.27 135.18,134.77 135.31,134.03 135.23,133.59 135.32,133.09 135.23,132.6 135.31,132.16 135.27,131.9 135.46,130.81 136.2,129.76 136.42,128.49 136.34,128.05 136.41,127.7 136.25,126.81 136.43,125.79 136.22,124.64 135.7,123.89 135.57,123.17 135.76,122.12 135.49,120.6 135.65,119.68 135.54,119.03 134.98,118.23 134.46,117.87 134.06,117.3 133.46,116.88 132.19,115.06 131.99,113.96 131.04,112.6 129.16,111.28 128.41,110.21 125.02,107.84 122.91,107.47 115.37,102.19 111.78,101.55 111.36,101.26 111.1,100.88 107.26,98.2 104.16,97.65 101.93,96.09 101.48,95.45 101,95.11 98.79,94.72 97.52,94.95 96.82,94.82 95.54,95.05 95.1,94.97 94.33,95.11 91.34,94.58 89.67,94.88 87.57,94.5 85.89,94.8 83.99,94.47 83,94.64 82.2,94.5 81.12,94.69 79.62,94.43 76.35,92.13 76.24,91.98 75.95,91.77 73.58,91.36 73.01,90.96 67.69,90.02 67.06,90.13 66.46,90.03 65.81,90.14 65.17,90.03 64.55,90.14 63.9,90.02 63.25,90.14 62.66,90.03 62.03,90.14 61.35,90.02 60.7,90.14 60.1,90.03 59.49,90.14 58.87,90.03 58.22,90.14 57.59,90.03 56.99,90.14 56.37,90.03 55.76,90.14 55.12,90.02 54.46,90.14 53.82,90.02 53.2,90.13 52.62,90.03 52.05,90.13 51.42,90.02 50.79,90.13 50.19,90.03 49.56,90.14 48.91,90.02 48.27,90.14 47.65,90.03 47.04,90.13 46.44,90.03 45.84,90.13 45.23,90.02 44.6,90.14 43.97,90.03 43.36,90.13 42.78,90.03 42.17,90.14 41.54,90.03 40.94,90.13 40.33,90.03 39.73,90.13 39.18,90.04 38.79,90.1 38.27,90.01 37.73,89.64 36.06,87.25 34.93,80.82 34.68,80.46 34.29,78.26 32.29,75.4 31.03,68.23 29.64,66.25 28.95,65.77 27.4,65.5 27.15,65.32 26.97,65.07 26.78,63.98 26.92,63.19 26.8,62.51 26.88,62.02 arc(26.89,61.94) 26.9,61.86 26.89,61.6 arc(26.86,61.46) 26.78,61.34 26.69,61.25 arc(26.56,61.16) 26.41,61.13 25.95,61.13 arc(25.69,61.08) 25.47,60.93 v1(25.43,60.89)
  BOTTOM w0.102: v1(120.95,151.99) 121.18,151.76 arc(121.23,151.69) 121.24,151.62 U6539.AM7
TCP0_TX_N1_C: length 2.4
  TOP w0.079: 24.01,61.42 24,61.44 24,61.46 arc(23.99,61.49) 23.98,61.51 23.63,61.86 arc(23.43,61.99) 23.19,62.05 arc(22.95,62.1) 22.74,62.24 U6549.C2
  TOP w0.114: 24.01,61.42 24.42,61.01 arc(24.48,60.93) C96807.2
TCP0_TX_P0: length 185.5
  TOP w0.114: v1(25.95,65.48) arc(25.86,65.54) 25.76,65.56 25.31,65.56 arc(25.11,65.52) C96799.1
  IN3 w0.089: 123.24,150.76 123.1,150.76 123.06,150.73 122.56,150.73 122.54,150.71 122.13,150.71 arc(121.99,150.68) 121.88,150.61 arc(121.81,150.51) 121.77,150.39 arc(121.77,150.35) 121.77,150.32 121.77,150.31 arc(121.76,150.27) 121.75,150.25 121.7,150.2 arc(121.66,150.17) 121.62,150.16 v1(121.57,150.16)
  IN3 w0.114: v1(25.95,65.48) 25.96,65.48 26.4,65.84 arc(26.66,66.06) 26.94,66.26 arc(27.04,66.32) 27.16,66.35 28.58,66.6 29.07,66.95 30.16,68.51 31.55,76.36 33.5,79.15 33.81,80.92 34.13,81.36 34.8,85.21 34.73,85.62 35.02,87.29 37.13,90.29 38.01,90.91 38.66,91.02 39.2,90.93 39.73,91.02 40.33,90.92 40.94,91.02 41.54,90.92 42.17,91.03 42.78,90.92 43.36,91.02 43.97,90.92 44.6,91.03 45.23,90.91 45.84,91.02 46.44,90.92 47.04,91.02 47.65,90.92 48.27,91.02 48.91,90.91 49.56,91.03 50.19,90.92 50.79,91.02 51.42,90.91 52.05,91.02 52.62,90.92 53.2,91.02 53.82,90.91 54.46,91.03 55.12,90.91 55.76,91.02 56.37,90.92 56.99,91.02 57.59,90.92 58.22,91.03 58.87,90.92 59.49,91.03 60.1,90.92 60.7,91.02 61.35,90.91 62.03,91.03 62.66,90.92 63.25,91.02 63.9,90.91 64.55,91.03 65.17,90.92 65.81,91.03 66.46,90.92 67.06,91.02 67.69,90.91 72.03,91.67 74.06,93.09 76.47,93.52 76.99,93.88 77.57,94.72 79.58,96.12 80.36,96.26 81.32,96.09 82.5,96.3 84.02,96.03 85.45,96.28 86.91,96.03 87.67,96.16 88.4,96.03 88.93,96.12 90.35,95.87 90.39,95.88 91.03,95.99 91.65,95.88 92.3,96 93.32,95.82 94.33,95.99 95.08,95.86 95.52,95.94 96.2,95.82 101.32,96.72 102.42,97.49 102.75,97.96 102.81,98.29 102.97,98.52 104.11,99.32 106.41,99.72 107.15,99.59 107.89,99.72 110.5,101.55 110.75,101.91 111.5,102.43 112.69,102.64 113.44,103.17 115.42,103.52 120.17,106.85 120.42,107.2 120.92,107.55 121.52,108.4 121.78,108.58 122.06,108.63 122.32,108.59 122.77,108.66 123.57,108.52 124.4,108.67 127.96,111.16 128.77,112.31 130.24,113.34 131.23,114.77 131.46,116.03 132.78,117.91 133.64,118.52 134.45,119.67 134.88,122.1 134.69,123.17 134.88,124.26 135.41,125.02 135.54,125.73 135.36,126.74 135.53,127.7 135.46,128.05 135.54,128.48 135.38,129.35 135,129.73 134.54,129.82 134.25,130.11 134.15,130.64 134.42,132.16 134.34,132.6 134.4,132.94 134.31,133.45 134.42,134.03 134.29,134.77 134.38,135.27 134.3,135.68 134.44,136.44 134.32,137.15 134.41,137.69 134.28,138.42 134.44,139.32 134.3,140.11 134.67,142.2 135.89,143.94 136.1,145.11 135.87,146.4 135.04,147.59 133.56,148.63 131.8,148.93 131.31,148.85 130.46,148.25 129.43,147.53 129.14,147.48 128.53,147.59 128.31,147.74 126.88,149.79 126.65,149.95 124.03,150.41 123.53,150.76 123.24,150.76
  BOTTOM w0.102: v1(121.57,150.16) 121.3,149.9 arc(121.26,149.83) 121.24,149.75 U6539.AT7
TCP0_TX_P0_C: length 2.5
  TOP w0.079: U6549.J1 23.06,65.03 arc(22.94,64.92) 23.06,64.81 23.27,64.81 arc(23.31,64.81) 23.35,64.84 23.53,65.02 arc(23.61,65.08) 23.71,65.13 arc(23.83,65.21) 23.87,65.35 23.87,65.48 arc(23.92,65.59) 24.02,65.63 24.09,65.63 arc(24.12,65.62) 24.14,65.61 24.16,65.59 24.18,65.59
  TOP w0.114: C96799.2 24.5,65.48 arc(24.46,65.56) 24.38,65.59 24.18,65.59
TCP0_TX_P1: length 190.4
  TOP w0.114: C96806.1 25.26,61.6 arc(25.35,61.58) v1(25.43,61.53)
  IN3 w0.089: 122.5,152.33 122.48,152.33 122.45,152.36 121.46,152.36 arc(121.38,152.33) 121.33,152.26 arc(121.34,152.16) 121.38,152.08 arc(121.48,152.02) v1(121.58,151.99)
  IN3 w0.114: 122.5,152.33 122.64,152.33 122.98,152.27 123.46,151.94 123.5,151.67 123.75,151.5 124.02,151.54 124.48,151.22 125.16,151.1 125.31,150.88 125.61,150.83 125.83,150.98 126.13,150.93 126.29,150.71 126.59,150.66 126.81,150.81 127.11,150.76 127.26,150.54 127.56,150.48 127.78,150.64 128.23,150.56 128.54,150.61 128.85,150.56 129.01,150.34 129.31,150.28 129.53,150.44 129.83,150.39 129.98,150.17 130.28,150.11 130.5,150.27 132.98,149.83 135.45,148.1 136.5,146.61 136.75,145.17 136.49,143.68 135.28,141.96 134.95,140.09 135.09,139.32 134.93,138.46 135.06,137.73 134.96,137.15 135.1,136.38 134.96,135.59 135.02,135.27 134.93,134.77 135.06,134.03 134.98,133.59 135.07,133.09 134.99,132.6 135.07,132.16 135.02,131.9 135.23,130.72 135.97,129.66 136.17,128.49 136.1,128.05 136.16,127.7 136,126.81 136.18,125.79 136,124.73 135.47,123.99 135.33,123.17 135.34,123.13 135.51,122.12 135.25,120.6 135.41,119.68 135.31,119.13 134.81,118.41 134.28,118.04 133.88,117.47 133.28,117.05 131.96,115.16 131.76,114.05 130.87,112.77 128.99,111.46 128.24,110.39 124.93,108.07 122.82,107.7 115.28,102.42 111.69,101.78 111.19,101.43 110.92,101.05 107.17,98.43 104.06,97.88 101.76,96.27 101.31,95.62 100.9,95.34 98.79,94.97 97.52,95.19 96.82,95.07 95.54,95.3 95.1,95.22 94.33,95.35 91.34,94.83 89.67,95.12 87.57,94.75 85.89,95.05 83.99,94.71 83,94.89 82.2,94.74 81.12,94.93 79.53,94.65 76.17,92.31 76.07,92.15 75.85,92 73.48,91.59 72.91,91.19 67.69,90.27 67.06,90.38 66.46,90.27 65.81,90.39 65.17,90.27 64.55,90.38 63.9,90.27 63.25,90.38 62.66,90.28 62.03,90.39 61.35,90.27 60.7,90.38 60.1,90.28 59.49,90.38 58.87,90.27 58.22,90.39 57.59,90.27 56.99,90.38 56.37,90.27 55.76,90.38 55.12,90.27 54.46,90.38 53.82,90.27 53.2,90.38 52.62,90.28 52.05,90.38 51.42,90.27 50.79,90.38 50.19,90.27 49.56,90.38 48.91,90.27 48.27,90.38 47.65,90.27 47.04,90.38 46.44,90.27 45.84,90.38 45.23,90.27 44.6,90.38 43.97,90.27 43.36,90.38 42.78,90.27 42.17,90.38 41.54,90.27 40.94,90.38 40.33,90.27 39.73,90.38 39.18,90.28 38.79,90.35 38.18,90.24 37.56,89.81 35.84,87.35 34.7,80.92 34.45,80.56 34.06,78.35 32.06,75.49 30.8,68.33 29.47,66.43 28.86,66 27.31,65.73 26.98,65.5 26.74,65.16 26.53,63.98 26.67,63.19 26.55,62.51 26.65,61.98 arc(26.65,61.92) 26.65,61.87 26.65,61.61 arc(26.64,61.55) 26.61,61.51 26.52,61.42 arc(26.47,61.39) 26.41,61.37 25.8,61.37 arc(25.6,61.41) 25.43,61.53 v1(25.43,61.53)
  BOTTOM w0.102: v1(121.58,151.99) 121.58,151.87 arc(121.6,151.77) 121.66,151.69 121.75,151.6 arc(121.82,151.55) U6539.AM5
TCP0_TX_P1_C: length 2.4
  TOP w0.079: U6549.C1 23.13,62.27 arc(23.02,62.34) 23.05,62.46 23.05,62.46 arc(23.11,62.5) 23.18,62.52 23.3,62.52 arc(23.37,62.5) 23.42,62.47 arc(23.48,62.38) 23.5,62.28 arc(23.5,62.28) 23.5,62.28 arc(23.51,62.22) 23.54,62.17 24.09,61.62 arc(24.11,61.61) 24.14,61.6 24.16,61.6 24.18,61.59
  TOP w0.114: C96806.2 24.5,61.56 arc(24.42,61.45) 24.29,61.47 24.18,61.59
TCP0_TXRX_N0: length 174.5
  TOP w0.114: v1(25.47,64.08) 25.33,63.94 arc(25.27,63.9) 25.19,63.88 C96803.1
  IN3 w0.114: v1(125.15,147.56) arc(125.23,147.43) 125.26,147.29 125.26,147.22 arc(125.37,146.96) 125.62,146.86 126.44,146.86 126.9,146.78 127.66,146.25 129.2,144.04 130.05,143.45 130.42,142.92 132.33,141.58 arc(132.38,141.54) 132.41,141.5 132.74,141.03 132.88,140.25 132.76,139.6 133,138.26 132.82,137.28 133.01,136.25 132.87,135.51 133.1,134.2 132.92,133.13 132.96,132.88 132.77,131.82 133.19,129.48 133.5,129.04 133.74,127.66 133.51,126.34 133.81,124.62 133.56,123.19 133.75,122.11 133.4,120.11 132.86,119.34 131.87,118.65 130.17,116.23 130.17,116.22 129.94,114.96 129.31,114.05 127.84,113.02 127.02,111.85 124.34,109.98 123.52,109.83 122.8,109.96 122.08,109.83 121.78,109.88 121.31,109.8 120.72,109.39 119.98,108.32 116.27,105.73 113.27,105.2 112.83,104.89 112.6,104.56 112.5,104.01 112.41,103.88 112.14,103.69 110.86,103.46 110.08,102.92 109.89,102.64 108.99,102.01 107.46,101.74 106.81,101.85 106.38,101.78 105.94,101.86 105.28,101.74 104.64,101.29 104.49,101.08 101.55,99.02 100.68,98.86 99.86,98.29 99.56,97.86 98.92,97.42 96.39,96.97 95.7,97.09 95.09,96.99 94.29,97.13 93.46,96.98 92.39,97.17 92.18,97.32 91.7,97.4 90.92,97.26 87.74,97.82 84.07,97.18 82.56,97.44 81.33,97.22 80.36,97.39 79.13,97.18 76.51,95.34 76.01,95.25 75.7,95.31 75.19,95.22 73.67,94.15 73.37,94.1 71.36,92.69 67.69,92.05 67.06,92.16 66.46,92.05 65.81,92.16 65.17,92.05 64.55,92.16 63.9,92.04 63.25,92.16 62.66,92.05 62.03,92.16 61.35,92.04 60.74,92.15 60.7,92.16 60.1,92.05 59.84,92.1 59.49,92.16 58.87,92.05 58.22,92.16 57.59,92.05 56.99,92.16 56.37,92.05 55.76,92.16 55.12,92.04 54.46,92.16 53.82,92.05 53.2,92.16 52.62,92.05 52.05,92.16 51.42,92.04 50.79,92.16 50.19,92.05 49.56,92.16 48.91,92.05 48.27,92.16 47.65,92.05 47.04,92.16 46.44,92.05 45.84,92.16 45.23,92.05 44.6,92.16 43.97,92.05 43.36,92.16 42.78,92.05 42.17,92.16 41.54,92.05 40.94,92.16 40.33,92.05 39.73,92.16 39.18,92.06 38.51,92.17 37.54,92 36.41,91.21 33.94,87.69 33.58,85.68 33.67,85.17 33.08,81.81 32.51,81 32.24,79.44 30.5,76.95 29.55,71.58 28.64,70.29 27.57,69.54 26.73,68.95 25.22,66.79 25.08,66 25.08,64.67 arc(25.1,64.54) 25.18,64.43 25.38,64.22 25.44,64.17 arc(25.46,64.13) v1(25.47,64.08)
  BOTTOM w0.102: U6539.BB2 123.44,147.3 arc(123.57,147.39) 123.72,147.42 123.87,147.42 arc(124.03,147.39) 124.17,147.3 124.34,147.13 arc(124.38,147.1) 124.43,147.09 124.67,147.09 arc(124.8,147.11) 124.91,147.19 125.06,147.34 arc(125.13,147.44) v1(125.15,147.56)
TCP0_TXRX_N0_C: length 2.1
  TOP w0.079: U6549.G2 22.76,64.06 arc(22.94,63.94) 23.15,63.9 23.28,63.9 arc(23.38,63.92) 23.46,63.97 arc(23.49,63.99) 23.53,64 23.64,64 arc(23.75,64.02) 23.84,64.08 23.88,64.12 arc(23.94,64.16) 24.01,64.18 24.09,64.18 arc(24.12,64.17) 24.14,64.15 24.16,64.14 24.18,64.14
  TOP w0.114: C96803.2 24.5,64.02 arc(24.46,64.11) 24.38,64.14 24.18,64.14
TCP0_TXRX_N1: length 184.1
  TOP w0.114: C96811.1 25.24,63.12 arc(25.35,63.1) v1(25.45,63.04)
  IN3 w0.114: v1(25.45,63.04) 25.43,63.03 arc(25.29,62.93) 25.13,62.9 25.06,62.9 24.8,62.95 24.63,63.07 24.49,63.26 24.45,63.51 24.45,63.53 24.47,63.54 24.47,63.62 24.5,63.78 24.38,64.46 24.44,64.84 24.34,65.43 24.46,66.11 24.29,67.09 24.4,67.71 25.06,68.66 26.3,69.53 26.5,69.56 27.96,70.59 28.75,71.72 29.71,77.11 31.45,79.6 31.73,81.16 32.35,82.06 32.94,85.37 32.83,86.01 33.11,87.63 36.03,91.8 37.21,92.62 38.41,92.83 39.18,92.7 39.73,92.8 40.33,92.69 40.94,92.8 41.54,92.69 42.17,92.8 42.78,92.7 43.36,92.8 43.97,92.69 44.6,92.8 45.23,92.69 45.84,92.8 46.44,92.69 47.04,92.8 47.65,92.69 48.27,92.8 48.91,92.69 49.56,92.8 50.19,92.69 50.79,92.8 51.42,92.69 52.05,92.8 52.62,92.7 53.2,92.8 53.82,92.69 54.46,92.81 55.12,92.69 55.76,92.8 56.37,92.69 56.99,92.8 57.59,92.7 58.22,92.81 58.87,92.69 59.49,92.8 60.1,92.7 60.7,92.8 61.35,92.69 62.03,92.81 62.66,92.7 63.25,92.8 63.9,92.69 64.55,92.8 65.17,92.69 65.81,92.81 66.46,92.7 67.06,92.8 67.69,92.69 71.09,93.29 73.23,94.79 73.4,94.82 75.63,96.37 77.23,96.66 78.79,97.75 80.48,98.05 81.25,97.91 83.25,98.26 83.7,98.19 84.27,98.29 85.51,98.07 87.76,98.47 90.76,97.94 91.57,98.08 92.54,97.91 92.72,97.79 93.47,97.61 94.32,97.76 95.02,97.64 95.63,97.75 96.42,97.61 98.65,98 99.11,98.32 99.49,98.87 101.1,99.99 101.56,100.07 104.75,102.31 105.88,102.51 106.39,102.42 106.96,102.52 107.61,102.41 108.61,102.59 109.1,102.93 109.43,103.39 109.52,103.92 109.83,104.36 110.43,104.78 111.84,105.03 114.14,106.64 117.07,107.16 117.56,107.51 118.16,108.35 118.22,108.74 119.11,110.01 119.18,110.05 119.87,110.54 120.54,110.66 121.41,110.5 121.8,110.57 122.2,110.5 122.78,110.61 123.38,110.5 124.21,110.65 126.57,112.3 127.38,113.47 128.83,114.48 129.33,115.2 129.56,116.48 131.4,119.1 132.29,119.73 132.82,120.49 133.11,122.13 132.93,123.19 133.16,124.49 132.72,126.96 132.82,127.51 132.44,129.62 132.48,129.84 132.19,131.47 131.91,131.87 131.8,132.51 131.92,133.22 132.33,133.81 132.42,134.31 132.24,135.34 132.02,135.65 131.64,135.92 131.36,135.97 131.19,135.94 131.06,135.96 130.82,136.13 130.61,136.44 130.46,137.27 130.63,138.2 130.83,138.48 131.87,139.21 132.11,139.55 132.17,139.87 132.07,140.51 131.61,141.17 130.01,142.29 129.62,142.85 128.09,143.92 126.77,144.15 125.99,143.91 125.75,144.03 125.46,143.95 125.33,143.71 125.04,143.62 124.86,143.58 124.56,143.64 124.25,143.86 124.05,144.13 123.88,145.11 124.04,145.33 123.98,145.63 123.76,145.78 123.71,146.08 123.86,146.3 123.81,146.6 123.59,146.76 123.52,147.13 123.55,147.26 123.99,147.89 124.21,148 125.07,148 arc(125.26,148.06) 125.4,148.21 arc(125.41,148.23) 125.42,148.25 125.47,148.41 arc(125.48,148.43) 125.5,148.45 v1(125.79,148.74)
  BOTTOM w0.102: v1(125.79,148.74) 125.79,148.69 arc(125.71,148.51) 125.54,148.44 arc(125.4,148.38) 125.34,148.25 arc(125.25,148.03) 125.04,147.94 124.3,147.94 arc(124.09,147.9) U6539.AY1
TCP0_TXRX_N1_C: length 2.2
  TOP w0.079: 24.3,62.93 24.29,62.92 arc(24.24,62.89) 24.19,62.91 24.15,62.94 arc(24.1,62.96) 24.05,62.98 arc(23.91,63.03) 23.79,63.11 23.68,63.22 arc(23.45,63.38) 23.17,63.43 arc(23.01,63.41) 22.86,63.33 arc(22.85,63.32) 22.84,63.31 arc(22.82,63.29) 22.8,63.28 U6549.E2
  TOP w0.114: C96811.2 24.5,63.05 arc(24.46,62.96) 24.38,62.93 24.3,62.93
TCP0_TXRX_P0: length 174.5
  TOP w0.114: C96798.1 25.39,64.65 arc(25.45,64.66) v1(25.5,64.69)
  IN3 w0.114: v1(25.5,64.69) 25.49,64.7 arc(25.36,64.89) 25.32,65.11 25.32,65.98 25.45,66.7 26.9,68.77 27.59,69.26 28.82,70.12 29.78,71.49 30.72,76.86 32.47,79.34 32.74,80.91 33.31,81.72 33.92,85.17 33.83,85.68 34.17,87.59 36.58,91.04 37.63,91.77 38.51,91.93 39.18,91.81 39.73,91.91 40.33,91.8 40.94,91.91 41.54,91.8 42.17,91.91 42.78,91.81 43.36,91.91 43.97,91.8 44.6,91.91 45.23,91.8 45.84,91.91 46.44,91.81 47.04,91.91 47.65,91.8 48.27,91.91 48.91,91.8 49.56,91.92 50.19,91.8 50.79,91.91 51.42,91.8 52.05,91.91 52.62,91.81 53.2,91.91 53.82,91.8 54.46,91.92 55.12,91.8 55.76,91.91 56.37,91.81 56.99,91.91 57.59,91.81 58.22,91.92 58.87,91.81 59.49,91.92 60.1,91.81 60.7,91.91 61.35,91.8 62.03,91.92 62.66,91.81 63.25,91.91 63.9,91.8 64.55,91.91 65.17,91.81 65.81,91.92 66.46,91.81 67.06,91.91 67.69,91.8 71.45,92.46 73.46,93.87 73.76,93.92 75.29,94.99 75.7,95.06 76.01,95.01 76.6,95.11 79.23,96.95 80.36,97.15 81.33,96.98 82.56,97.2 84.07,96.93 87.74,97.58 90.92,97.02 91.7,97.16 92.08,97.09 92.3,96.94 93.46,96.73 94.29,96.88 95.09,96.74 95.7,96.85 96.39,96.73 99.02,97.19 99.73,97.69 100.03,98.12 100.77,98.64 101.65,98.79 104.67,100.9 104.82,101.12 105.38,101.51 105.94,101.61 106.38,101.53 106.81,101.61 107.46,101.49 109.08,101.78 110.06,102.46 110.25,102.74 110.96,103.24 112.23,103.46 112.58,103.7 112.73,103.92 112.82,104.46 113,104.72 113.36,104.97 116.37,105.5 120.15,108.15 120.89,109.21 121.41,109.57 121.78,109.64 122.08,109.59 122.8,109.71 123.52,109.59 124.43,109.75 127.19,111.68 128.01,112.85 129.48,113.88 130.17,114.87 130.4,116.13 132.04,118.47 132.87,119.05 133.03,119.17 133.63,120.02 134,122.11 133.81,123.19 134.06,124.62 133.75,126.34 133.99,127.66 133.73,129.13 133.42,129.57 133.02,131.82 133.21,132.88 133.16,133.13 133.35,134.2 133.12,135.51 133.25,136.25 133.07,137.28 133.24,138.26 133.01,139.6 133.12,140.25 132.97,141.13 132.61,141.64 arc(132.55,141.72) 132.47,141.78 130.59,143.09 130.22,143.62 129.38,144.21 127.83,146.43 127,147.01 126.47,147.1 125.62,147.1 arc(125.54,147.13) 125.5,147.22 125.5,147.27 arc(125.59,147.47) v1(125.79,147.56)
  BOTTOM w0.102: U6539.BB1 123.82,147.13 arc(123.76,147.12) 123.71,147.08 arc(123.67,147.03) 123.65,146.98 arc(123.65,146.95) 123.66,146.93 arc(123.72,146.84) 123.81,146.78 arc(123.83,146.77) 123.85,146.77 arc(124.01,146.8) 124.16,146.86 arc(124.2,146.88) 124.25,146.88 124.67,146.88 arc(124.88,146.93) 125.06,147.05 125.13,147.12 arc(125.18,147.15) 125.23,147.16 125.44,147.16 arc(125.56,147.19) 125.67,147.26 125.76,147.35 arc(125.78,147.38) 125.79,147.42 v1(125.79,147.56)
TCP0_TXRX_P0_C: length 2.1
  TOP w0.079: 24.18,64.37 24.16,64.37 24.14,64.36 arc(24.12,64.34) 24.09,64.33 24.01,64.33 arc(23.88,64.31) 23.77,64.23 23.73,64.19 arc(23.69,64.17) 23.64,64.16 23.56,64.16 arc(23.52,64.16) 23.49,64.19 23.42,64.26 arc(23.31,64.32) 23.19,64.35 23.15,64.35 arc(23.05,64.31) 23.01,64.21 arc(23.04,64.14) 23.1,64.11 U6549.G1
  TOP w0.114: C96798.2 24.5,64.49 arc(24.46,64.41) 24.38,64.37 24.18,64.37
TCP0_TXRX_P1: length 184.1
  TOP w0.114: C96810.1 25.3,62.36 arc(25.38,62.38) v1(25.45,62.42)
  IN3 w0.114: v1(125.15,148.74) 125.19,148.7 125.19,148.39 arc(125.19,148.37) 125.19,148.35 125.17,148.32 125.18,148.32 arc(125.14,148.26) 125.07,148.24 124.15,148.24 123.83,148.08 123.32,147.36 123.28,147.13 123.82,144.04 124.07,143.68 124.46,143.41 124.86,143.34 125.1,143.38 126.06,143.68 126.79,143.9 128,143.69 129.45,142.67 129.83,142.12 131.43,141 131.64,140.71 131.84,140.42 131.92,139.87 131.88,139.65 131.7,139.39 130.65,138.66 130.4,138.29 130.22,137.27 130.38,136.34 130.65,135.95 130.96,135.73 131.05,135.72 131.19,135.69 131.36,135.72 131.54,135.69 131.85,135.48 132.01,135.25 132.18,134.31 132.11,133.9 131.69,133.31 131.55,132.51 131.68,131.78 131.96,131.37 132.23,129.84 132.2,129.62 132.57,127.51 132.47,126.96 132.91,124.49 132.68,123.19 132.87,122.13 132.59,120.58 132.12,119.91 131.22,119.28 129.33,116.57 129.11,115.29 128.66,114.65 127.21,113.64 126.39,112.47 124.11,110.88 123.38,110.75 122.78,110.85 122.2,110.75 121.8,110.82 121.41,110.75 120.54,110.9 119.78,110.77 119.04,110.25 118.94,110.18 118,108.83 117.93,108.45 117.39,107.68 116.97,107.39 114.05,106.87 111.74,105.26 110.34,105.01 109.65,104.53 109.29,104.02 109.2,103.48 108.93,103.1 108.52,102.81 107.61,102.65 106.96,102.77 106.39,102.67 105.88,102.75 104.66,102.54 101.46,100.3 101,100.22 99.32,99.04 98.93,98.49 98.56,98.23 96.42,97.85 95.63,97.99 95.02,97.89 94.32,98.01 93.48,97.86 92.82,98.01 92.64,98.14 91.57,98.33 90.76,98.18 87.76,98.71 85.51,98.31 84.27,98.53 83.7,98.43 83.25,98.51 81.25,98.16 80.48,98.29 78.69,97.98 77.13,96.88 75.54,96.6 73.31,95.05 73.13,95.01 70.99,93.52 67.69,92.93 67.06,93.05 66.46,92.94 65.81,93.05 65.17,92.94 64.55,93.05 63.9,92.93 63.25,93.05 62.66,92.94 62.03,93.05 61.35,92.93 60.7,93.05 60.1,92.94 59.49,93.05 58.87,92.94 58.22,93.05 57.59,92.94 56.99,93.05 56.37,92.94 55.76,93.05 55.12,92.93 54.46,93.05 53.82,92.94 53.2,93.05 52.62,92.94 52.05,93.04 51.42,92.93 50.79,93.04 50.19,92.94 49.56,93.05 48.91,92.94 48.27,93.05 47.65,92.94 47.04,93.05 46.44,92.94 45.84,93.04 45.23,92.94 44.6,93.05 43.97,92.94 43.36,93.05 42.78,92.94 42.17,93.05 41.54,92.94 40.94,93.05 40.33,92.94 39.73,93.05 39.18,92.95 38.41,93.08 37.11,92.85 35.86,91.97 32.88,87.72 32.58,86.01 32.69,85.37 32.12,82.15 31.5,81.26 31.22,79.69 29.48,77.21 28.53,71.81 27.79,70.76 26.41,69.79 26.2,69.76 24.89,68.84 24.17,67.81 24.04,67.09 24.21,66.11 24.09,65.43 24.2,64.84 24.13,64.46 24.25,63.78 24.23,63.64 24.21,63.51 24.27,63.17 24.46,62.89 24.7,62.72 25.04,62.66 25.17,62.66 arc(25.2,62.65) 25.24,62.63 v1(25.45,62.42)
  BOTTOM w0.102: v1(125.15,148.74) 125.14,148.73 125.14,148.25 arc(125.11,148.17) 125.04,148.14 124.1,148.14 arc(123.88,148.1) 123.69,147.98 123.62,147.9 arc(123.48,147.81) 123.33,147.78 U6539.AY2
TCP0_TXRX_P1_C: length 2.2
  TOP w0.079: 24.22,62.7 24.06,62.81 24.04,62.82 arc(24.03,62.82) 24.02,62.82 24,62.83 arc(23.84,62.88) 23.7,62.98 arc(23.55,63.05) 23.4,63.01 arc(23.34,62.98) 23.27,62.97 23.09,62.97 arc(23.04,62.99) 23.02,63.04 arc(23.06,63.15) U6549.E1
  TOP w0.114: 24.22,62.7 24.38,62.7 arc(24.46,62.66) 24.5,62.58 C96810.2
TCP01_FLASH_BUSY#: length 3
  TOP w0.079: 19.13,60.52 19.13,60.77 19.49,61.12 U6549.A9
  TOP w0.114: R68607.1 18.03,59.4 18.28,59.66 18.69,59.66 19.13,60.11 19.13,60.52
TCP_RETIMER_PERST#: length 137.8
  TOP w0.079: U6549.B8 20.19,61.57 20.19,61.06 19.86,60.73 v1(19.86,60.6)
  TOP w0.114: v1(99.94,106.52) 99.94,103.48 99.16,102.69 99.16,100.66 100.25,99.56 100.25,97.69 100.38,97.56 100.38,96.54 100.25,96.42 v2(97.71,96.42) 97.21,95.92 97.21,95.6 v1(97.18,95.56)
  IN2 w0.102: v1(97.18,95.56) 96.91,95.56 96.44,96.03 92.88,96.03 92.37,95.53 86.79,95.53 86.02,96.29 82.85,96.29 82.21,96.92 79.55,96.92 77.44,94.81 75.15,94.81 74.47,94.13 73.58,94.13 71.37,91.92 35.81,91.92 32.56,88.67 32.56,79.4 31.16,78 31.16,65.81 30.27,64.92 30.27,62.89 29.81,62.43 29.81,58.24 27.38,55.8 23.16,55.8 23.13,55.83 v1(21.89,55.83)
  IN4 w0.089: v1(21.89,55.83) 21.51,56.21 21.51,57.25 20.62,58.14 20.62,59.46 20.24,59.84 20.24,60.22 v1(19.86,60.6)
  BOTTOM w0.114: 98.03,107.4 97.87,107.56 R68684.1 R68683.1 ; 98.03,107.4 U6554.4 ; 98.03,107.4 98.09,107.46 98.47,107.46 98.57,107.37 R68685.1 99.33,107.37 99.94,106.75 v1(99.94,106.52)
TCRCOMP_DN: length 4.3
  BOTTOM w0.254: R68242.2 127.14,151.25 126.94,151.46 126.59,151.46 126.2,151.06 126.02,151.06 125.7,151.38 125.37,151.38 125.01,151.03 124.53,151.03 124.26,151.3 124.08,151.3 123.92,151.13 U6539.AN1
TCRCOMP_DP: length 4.4
  BOTTOM w0.203: U6539.AN2 123.61,150.69 124.48,150.69 124.52,150.64 124.89,150.64
  BOTTOM w0.254: 124.89,150.64 127.05,150.64 127.2,150.8 R68242.1
TCT1: length 16.7
  TOP w0.508: C645.1 39.48,179.86 v2(38.5,180.84) 38.28,180.84 C96313.1 36.72,180.87 v2(35.5,180.87) 35.5,180.86 v2(33.85,180.86) v2(32.5,180.86) 29.5,180.86 v2(29.5,180.86)
  BOTTOM w0.508: U25.10 v2(29.5,180.86) ; U25.1 v2(38.5,180.84) ; U25.7 v2(32.5,180.86) ; U25.4 v2(35.5,180.87)
TEMP_MBAT#: length 160.4
  TOP w0.114: v1(197.2,109.37) 196.9,109.06 196.9,107.46 198.17,106.19 198.17,104.16 197.4,103.4 197.4,97.3 196.21,96.11 193.37,96.11 v2(193.01,96.47) 192.84,96.63 191.14,96.63 190.62,96.11 175.79,96.11 174.14,97.76 174.14,99.42 173.96,99.6 v2(173.96,99.62) 173.96,99.67 173.26,100.36 169.38,100.36 169.35,100.34 U37.73
  IN1 w0.089: v2(173.96,99.62) 173.95,99.62 173.54,100.02 168.65,100.02 168.45,100.23 163.19,100.23 162.96,100.45 156.28,100.45 155.21,101.52 147.47,101.52 146.36,102.63 144.5,102.63 144.43,102.7 139.81,102.7 139.48,102.37 132.65,102.37 132.15,102.87 128.34,102.87 128.19,103.02 117.57,103.02 117.03,102.47 109.63,102.47 108.55,103.55 105.96,103.55 v1(105.48,104.04)
  IN3 w0.102: v1(197.2,109.37) 196.82,108.99 196.39,108.99 195.69,109.69 195.05,109.69 191.94,112.8 189.02,112.8 188.51,113.31 186.61,113.31 184.54,115.37 179.66,115.37 178.35,114.07 177.59,114.07 176.19,115.47 174.67,115.47 174.16,115.97 174.16,116.48 173.27,117.37 170.99,117.37 169.08,115.47 165.02,115.47 164.51,114.96 163.47,114.96 162.99,115.44 v1(162.96,115.44)
  BOTTOM w0.114: PR18.1 162.8,115.55 162.89,115.47 162.94,115.47 v1(162.96,115.44) ; PR14.2 105.57,104.13 v1(105.48,104.04)
  BOTTOM w0.152: PR8.1 162.17,116.02 162.22,115.97 PR18.1
TESTMODE: length 15.2
  BOTTOM w0.114: R311.1 v2(121.84,207.79) 122.73,206.91 122.73,205.76 123.36,205.13 123.74,205.13 124,205.38 124,206.4 124.52,206.92 125.66,206.92 127.06,205.52 127.06,205.24 128.16,204.14 128.16,201.92 128.06,201.83 127.28,201.83 U8.AD9
THERM+: length 1.6
  TOP w0.102: v1(128.96,186.05) 129.36,185.66
  TOP w0.114: 129.36,185.66 129.37,185.66 TP68.1
  BOTTOM w0.102: U8.F12 129.38,186.47 v1(128.96,186.05)
THERM-: length 8.7
  TOP w0.102: 129.31,182.65 129.31,183.03 129.81,183.53 v1(129.81,184.42)
  TOP w0.114: TP69.1 131.31,178.56 129.67,180.2 129.67,180.3 129.03,180.95 129.03,181.63 129.31,181.91 129.31,182.65
  BOTTOM w0.102: U8.E12 129.81,185.22 v1(129.81,184.42)
THERMAL_SHDN#: length 175
  IN1 w0.089: v2(202.74,122.58) 202.2,122.04 199.21,122.04 198.55,122.7 198.55,123.72 197.78,124.48 196.64,124.48 196.51,124.61 192.2,124.61 191.89,124.3 191.89,123.34 190.7,122.15 184.42,122.15 184.25,122.32 181.53,122.32 181.15,122.7 177.97,122.7 177.64,123.03 170.47,123.03 169.31,124.19 169.31,125.32 165.78,128.85 163.89,128.85 163.56,129.18 159.94,129.18 158.92,130.2 158.92,131.59 156.32,134.2 155.81,134.2 152.27,137.74 144.5,137.74 142.64,139.59 142.64,145.31 140.79,147.16 140.79,165.03 139.44,166.38 137.63,166.38 133.99,170.01 125.59,170.01 124.28,171.32 124.28,173.73 123.73,174.28 123.73,176.62 121.74,178.61 121.43,178.61 120.98,179.07 120.98,179.37 119.86,180.49 118.77,180.49 117.65,181.61 114.24,181.61 113.84,181.2 112.01,181.2 111.69,180.88 107.29,180.88 107.18,180.77 105.56,180.77 104.92,181.4 102.99,181.4 101.95,182.44 101.6,182.44 100.88,183.16 100.88,183.59 99.97,184.5 98.14,184.5 97.84,184.81 97.2,184.81 96.97,184.58 v1(96.46,184.58)
  IN4 w0.089: v1(96.46,184.58) 95.3,183.41 95.3,181.63 96.31,180.62 96.31,179.55 93.99,177.23 93.99,176.77 93.59,176.37 v1(93.19,176.37)
  BOTTOM w0.114: v1(96.46,184.58) 95.78,184.58 v2(95.36,185) 94.19,185 93.63,185.56 U2.4 ; v2(202.74,122.58) 202.61,122.7 R67422.1 ; R69027.1 90.12,177.47 90.38,177.74 Q6640.1 91.19,177.74 92.55,176.37 v1(93.19,176.37)
TOUCHPANEL_PWR: length 206.6
  TOP w0.114: Q6592.2 79.23,186.9 79.42,186.71 v2(79.42,186.08) 79.42,185.77 v2(79.04,185.39) ; v1(189.15,110.89) 188.01,110.89 187.45,111.45 187.45,112.34 186.86,112.93 185.75,112.93 184.35,114.32 184.35,117.9 184.65,118.21 184.65,121.26 185.21,121.82 187.5,121.82 v1(187.62,121.69) ; v2(169.51,102.36) 168.98,102.89 168.57,102.89 168.33,103.14 U37.80
  IN1 w0.089: v1(187.62,121.69) 187.37,121.94 184.32,121.94 184.2,122.07 181.33,122.07 180.89,122.5 177.9,122.5 177.57,122.83 170.4,122.83 169.11,124.13 169.11,125.24 165.7,128.65 163.77,128.65 163.49,128.93 159.81,128.93 158.67,130.07 158.67,131.47 156.26,133.88 155.72,133.88 152.06,137.54 144.42,137.54 142.44,139.52 142.44,145.23 140.58,147.09 140.58,164.92 139.31,166.19 137.51,166.19 133.88,169.82 125.47,169.82 124.07,171.22 124.07,173.55 123.54,174.09 123.54,176.4 121.72,178.22 121.19,178.22 120.58,178.83 120.58,179.36 119.71,180.24 118.74,180.24 117.57,181.4 114.32,181.4 113.91,181 112.19,181 111.88,180.69 107.39,180.69 107.27,180.57 105.43,180.57 104.8,181.2 102.92,181.2 101.87,182.24 101.52,182.24 100.63,183.13 100.63,183.54 99.87,184.3 98.34,184.3 98.04,183.99 96.24,183.99 95.96,184.27 91.97,184.27 91.61,183.92 91.61,183.28 90.47,182.14 90.47,181.51 89.96,181 87.55,181 82.34,186.2 79.85,186.2 v2(79.04,185.39)
  IN4 w0.089: v1(189.15,110.89) 186.86,110.89 186.23,110.26 185.21,110.26 184.45,109.5 184.45,108.99 182.93,107.46 182.93,104.85 179.75,101.67 174.24,101.67 172.89,103.02 172.38,103.02 171.34,101.98 169.9,101.98 v2(169.51,102.36)
TP_3: length 10.6
  BOTTOM w0.102: 99.23,119.78 100.38,120.93 100.38,121 U6539.DW52
  BOTTOM w0.114: 99.23,119.78 96.57,119.78 96.18,119.4 96.18,118.77 95.8,118.39 95.45,118.39 93.11,116.05 TP13283.1
TP_4: length 9.9
  BOTTOM w0.102: U6539.DV53 100.18,121.12 99.13,120.06
  BOTTOM w0.114: TP13284.1 93.54,116.86 95.31,118.63 95.66,118.63 95.93,118.89 95.93,119.71 96.29,120.06 99.13,120.06
TP_DP1: length 15.6
  TOP w0.089: 109.01,122.07 109.01,122.2 109.49,122.68 109.49,123.21 109.39,123.32 109.39,124.99 109.52,125.12 109.52,127.28 109.9,127.66 110.54,127.66 110.89,128.01 110.89,129.83 v1(111.34,130.27)
  TOP w0.114: 109.01,122.07 109.01,116.81 108.94,116.74 TP13262.1
  BOTTOM w0.2: v1(111.34,130.27) U6539.CY30
TP_INTH#_L: length 9.9
  BOTTOM w0.114: CN33.7 127.1,100.41 128.06,101.37 132.63,101.37 133.84,102.57 R573.1 R25473.1
TP_L34: length 4.8
  TOP w0.089: v1(118.13,128.22) 118.14,128.22 118.66,128.74 121.13,128.74 121.71,128.17 TP13285.1
  BOTTOM w0.102: U6539.DD13 118.34,128.21 118.14,128.21 v1(118.13,128.22)
TP_M34: length 7.2
  BOTTOM w0.102: U6539.DF53 99.34,127.33 98.09,126.08 98.09,125.78 97.35,125.04 95.8,125.04 94.66,123.9 TP13257.1
TP_SMB_CLK: length 3.9
  TOP w0.114: v2(127.4,97.94) 127.35,98 C699.1 127.35,99.16 127.29,99.22 R558.1
  BOTTOM w0.114: CN33.6 128.1,98.87 127.4,98.17 v2(127.4,97.94)
TP_SMB_DATA: length 5.2
  TOP w0.114: R560.1 129.98,99.09 129.64,98.75 C698.1 129.23,98.42 129.1,98.29 v2(129.1,97.94) 129.1,97.61 v2(128.57,97.08)
  BOTTOM w0.114: v2(129.1,97.94) 129.1,97.94 CN33.5
TPCLK: length 122.2
  TOP w0.114: L23.1 134.8,97.19 134.82,97.21 R566.1 135.3,96.54 135.55,96.29 v2(137.33,96.29) 137.84,95.78 138.77,95.78 139.88,94.67 v1(139.88,94.59) ; U37.89 166.73,106.74 166.46,107.01 166.07,107.01 165.65,106.6 v1(165.65,106.45)
  IN1 w0.089: v2(198.93,104.92) 198.42,105.43 198.42,106.83 197.84,107.41 183.02,107.41 180.76,109.67 175.08,109.67 172.23,106.82 166.56,106.82 166.43,106.95 166,106.95 165.65,106.6 v1(165.65,106.45)
  BOTTOM w0.114: v1(139.88,94.59) 140.34,95.05 142.38,95.05 143.04,94.39 198.3,94.39 199.94,96.03 202.23,96.03 202.99,96.8 202.99,98.78 202.44,99.34 201.9,99.34 201.34,99.89 201.34,101.5 200.96,101.88 199.9,101.88 198.93,102.85 v2(198.93,104.92)
TPCLK-1: length 6.8
  TOP w0.114: v2(131.36,97.94) 131.19,97.94 130.98,97.74 130.98,97.51 131.19,97.3 v2(131.59,97.3) 132.38,97.3 132.85,96.83 C696.1 133.19,96.53 133.32,96.41 L23.2
  BOTTOM w0.114: CN33.2 132.1,98.8 131.36,98.07 v2(131.36,97.94)
TPD_EN: length 138.8
  TOP w0.114: v2(197.4,104.42) 197.89,104.9 197.89,106.09 196.21,107.77 196.21,108.96 196.01,109.17 196.01,110.61 196.41,111.02 196.41,113.84 196.77,114.2 196.77,116.61 197.45,117.29 197.45,123.09 v1(197.33,123.21) ; R895.2 170.1,113.18 170.18,113.1 171.93,113.1 172.49,113.66 177.99,113.66 178.73,114.4 178.73,115.34 179.37,115.97 179.37,118.51 v2(178.16,119.72) 177.85,120.04 177.85,121.31 178.61,122.07 v2(179.7,122.07) ; v1(138.53,94.59) 137.89,94.59 136.79,95.69 128.32,95.69 127.58,96.42 R574.1 126.8,96.42 126.63,96.26 R572.2
  IN3 w0.102: v1(197.33,123.21) 197.28,123.21 196.51,122.45 186.23,122.45 185.85,122.07 181.53,122.07 181.27,122.32 179.93,122.32 179.7,122.09 v2(179.7,122.07)
  BOTTOM w0.114: v2(197.4,104.42) 197.76,104.06 197.76,101.34 196.96,100.54 196.96,98.88 195.46,97.39 194.57,97.39 192.1,94.92 154.29,94.92 153.51,95.7 151.47,95.7 150.7,94.92 146.7,94.92 145.97,95.65 139.59,95.65 v1(138.53,94.59)
TPD_INT#: length 47.1
  IN1 w0.089: v1(111.46,104.15) 111.86,103.76 114.7,103.76 115.16,104.21 116.95,104.21 117.06,104.33 121.75,104.33 123.36,105.94 128.42,105.94 130.07,104.29 133.09,104.29 v1(133.22,104.16)
  BOTTOM w0.102: 113.84,114.27 113.84,115.08 114.22,115.47 114.22,115.97 114.4,116.15 114.4,117.14 113.79,117.75 113.79,118.84 114.47,119.53 114.47,120.04 114.22,120.29 113.71,120.29 113.56,120.44 113.56,120.9 113.84,121.18 113.84,121.82 113.96,121.94 114.35,121.94 114.56,122.16 114.56,122.34 U6539.DT21
  BOTTOM w0.114: v1(133.22,104.16) 133.22,103.63 133.06,103.47 R573.2 ; 113.84,114.27 113.84,114.07 113.71,113.94 R68737.1 113.46,113.66 113.3,113.51 113.3,113.08 113.96,112.42 113.96,111.53 111.88,109.45 111.88,108.66 112.14,108.4 112.14,106.88 111.7,106.45 111.7,104.47 111.46,104.23 v1(111.46,104.15)
TPD_INT#_EC: length 19
  TOP w0.114: R25308.2 R25323.1 147.37,111.14 147.37,111.15 147.11,110.89 141.75,110.89 139.85,108.99 v2(139.49,108.99) 139.36,108.99 137.33,106.96 136.95,106.96 136.06,106.07 136.06,105.05 135.33,104.31 v1(135.33,104.16)
  BOTTOM w0.114: R25473.2 135.56,103.65 135.33,103.88 v1(135.33,104.16)
TPDAT-1: length 4.4
  TOP w0.114: L24.2 130.71,97.07 C697.1 130.17,97.53 130.42,97.79 v2(130.42,97.94)
  BOTTOM w0.114: CN33.3 131.1,98.95 130.42,98.27 v2(130.42,97.94)
TPDATA: length 123.9
  TOP w0.114: U37.90 166.74,107.14 166.6,107.28 165.67,107.28 165.02,106.63 v1(165.02,106.45) ; v1(139.22,94.59) 139.21,94.59 138.53,95.27 v2(138.25,95.27) 137.59,95.27 136.9,95.96 132.6,95.96 L24.1 131.57,95.96 131.06,95.96 130.82,96.19 R567.1
  IN1 w0.089: v2(198.92,105.69) 198.92,106.84 198.14,107.62 183.08,107.62 180.82,109.88 175,109.88 172.14,107.01 166.64,107.01 166.51,107.14 165.53,107.14 165.02,106.63 v1(165.02,106.45)
  BOTTOM w0.114: v1(139.22,94.59) 139.22,94.59 139.95,95.32 142.5,95.32 143.16,94.66 150.81,94.66 151.59,95.43 153.4,95.43 154.17,94.66 198.06,94.66 200.58,97.18 200.58,97.81 199.94,98.45 199.94,100.35 198.42,101.88 198.42,105.19 v2(198.92,105.69)
TPM_LRESET#: length 4.2
  TOP w0.114: U33.17 85.14,99.82 85.01,99.94 85.01,100.24 86.85,102.08 87.22,102.08 87.29,102 R601.2
TPM_PIRQ#: length 51
  TOP w0.114: R580.1 83.87,100.15 83.99,100.28 83.99,100.99 84.22,101.21 R593.1 v2(85.31,101.21) 85.6,101.21 86.77,102.38 87.68,102.38 v1(87.93,102.64)
  IN2 w0.102: v1(112.09,104.16) 111.55,103.63 109.75,103.63 109.09,102.97 101.82,102.97 101.42,103.37 94.13,103.37 93.9,103.15 88.44,103.15 v1(87.93,102.64)
  BOTTOM w0.102: 114.96,115.24 114.85,115.34 114.85,117.37 114.19,118.03 114.19,118.49 114.98,119.28 114.98,119.53 115.15,119.7 115.15,121 115.1,121.05 115.1,121.9 U6539.DU19
  BOTTOM w0.114: 114.96,115.24 114.96,114.3 114.83,114.17 114.83,112.52 114.7,112.39 114.7,111.25 112.68,109.23 112.68,108.54 112.42,108.28 112.42,106.75 112.09,106.42 v1(112.09,104.16)
TPM_SPI0_CLK: length 46.3
  TOP w0.114: v1(84.7,98.89) 84.78,98.82 U33.19
  IN1 w0.089: v1(121.69,99.46) 121.48,99.67 120.19,99.67 119.86,99.34 117.9,99.34 117.34,98.78 102.97,98.78 102.59,99.16 100.22,99.16 99.77,98.7 96.21,98.7 96.05,98.87 84.73,98.87 v1(84.7,98.89)
  BOTTOM w0.114: v1(121.69,99.46) 121.69,100.94 121.2,101.42 121.2,102.49 120.54,103.15 120.19,103.15 119.04,104.29 118.29,104.29 118.06,104.52 R68583.2
TPM_SPI0_SI: length 40.8
  TOP w0.114: U33.21 84.7,97.82 v1(84.68,97.79)
  IN1 w0.089: v1(120.39,99.18) 120.39,99.16 120.06,98.83 118.08,98.83 117.52,98.27 102.71,98.27 102.31,98.68 100.43,98.68 99.73,97.98 84.87,97.98 v1(84.68,97.79)
  BOTTOM w0.114: R68585.2 119.04,101.57 120.14,100.48 120.14,99.44 v1(120.39,99.18)
TPM_SPI0_SO: length 55.8
  TOP w0.114: U33.24 85.59,96.09 v1(85.9,95.78) 85.14,95.02 83.26,95.02 82.93,95.35 82.93,96.59 82.72,96.8 R583.1
  IN1 w0.089: v1(124.32,98.76) 124.12,98.57 118.16,98.57 117.62,98.04 111.05,98.04 110.92,97.91 100.4,97.91 100.25,97.75 89.78,97.75 87.8,95.78 v1(85.9,95.78)
  BOTTOM w0.114: v1(124.32,98.76) 125.14,99.59 125.14,99.97 127.05,101.88 131.49,101.88 132,102.38 R68587.2
TS_EN: length 290.9
  TOP w0.114: v2(206.93,102.89) 207.44,102.38 207.94,102.38 212.14,106.58 212.9,106.58 213.28,106.19 214.29,106.19 214.55,106.45 214.55,106.83 215.06,107.34 215.06,111.53 213.88,112.72 213.88,120.58 213.41,121.05 v2(213.41,121.31) 213.41,121.94 v2(213.15,122.2) ; R956.1 170.96,103.82 170.96,103.83 170.96,105.51 v1(170.76,105.71)
  IN1 w0.089: v2(206.93,102.89) 205.53,102.89 204.9,103.53 201.34,103.53 200.83,103.02 199.94,103.02 199.82,103.15 192.83,103.15 190.29,105.69 189.02,105.69 188.51,105.18 187.37,105.18 186.74,105.81 185.72,105.81 182.81,102.9 175.81,102.9 173,105.71 v1(170.76,105.71)
  IN3 w0.102: v1(69.85,187.98) 70.1,188.24 75.1,188.24 75.76,187.58 78.38,187.58 79.55,188.74 85.39,188.74 86.91,187.22 92.25,187.22 92.37,187.09 92.37,186.2 92.63,185.95 92.63,184.4 93.92,183.11 98.55,183.11 99.36,183.92 102.79,183.92 103.04,184.17 105.84,184.17 106.07,183.94 110.64,183.94 111.17,183.41 112.19,183.41 112.77,182.83 112.77,179.12 115.21,176.68 115.21,175.71 115.94,174.98 116.91,174.98 118.77,173.12 121.69,173.12 123.74,171.07 123.74,170.71 125.22,169.24 127.3,169.24 127.68,168.86 127.68,167.28 130.22,164.74 131.31,164.74 133.27,162.79 133.27,156.87 132.63,156.23 132.63,155.72 133.14,155.22 138.6,155.22 138.91,154.91 138.91,147.34 139.11,147.14 139.11,129.44 140.13,128.42 140.13,124.74 140.51,124.36 140.51,123.34 139.24,122.07 139.24,121.64 138.91,121.31 138.91,120.42 138.48,119.99 138.48,119.28 138.86,118.89 138.86,113.31 140.38,111.78 147.52,111.78 148.03,112.28 148.03,112.95 148.32,113.24 148.6,113.24 150.22,114.86 153.23,114.86 155.37,116.99 156.64,116.99 157.4,117.75 160.07,117.75 161.46,119.15 162.73,119.15 162.99,119.4 164.51,119.4 165.27,120.16 166.13,120.16 167.27,121.31 169.39,121.31 170.23,122.15 176.31,122.15 178.61,119.84 184.36,119.84 184.8,119.4 188.77,119.4 189.5,120.13 191.2,120.13 191.46,120.4 204.87,120.4 205.46,120.98 211.3,120.98 211.88,121.56 212.52,121.56 v2(213.15,122.2)
  BOTTOM w0.114: v1(69.85,187.98) 70.02,187.98 70.35,188.31 R436.2
TS_EN_C: length 3.7
  TOP w0.114: U37.81 168.31,103.54 168.57,103.27 169.26,103.27 v2(169.36,103.17) 169.59,102.95 C1210.1 R956.2
TS_EN_R: length 4.8
  BOTTOM w0.114: R436.1 69.57,189.18 69.74,189.35 69.74,189.61 69.9,189.76 v2(69.9,189.81) 69.51,190.19 69.51,190.8 69.74,191.03 69.74,191.39 70.15,191.79 CN29.28
TS_INT#: length 1.9
  BOTTOM w0.114: TP13179.1 62.28,191.54 61.65,192.16 CN29.11
TS_ON: length 9.2
  TOP w0.089: 110.41,122.07 110.79,122.45 110.79,123.16 111.2,123.57 111.2,124.76 v1(110.84,125.12)
  TOP w0.114: 110.41,122.07 109.95,121.61 109.95,119.22 111.04,118.13 TP13368.1
  BOTTOM w0.102: v1(110.84,125.12) 111.02,125.12 U6539.DK29
TSEN_1: length 1.4
  TOP w0.114: PR7017.2 158.7,142.21 v2(158.82,142.08)
  TOP w0.178: PR7021.1 PR7017.2
TSEN_2: length 0.5
  TOP w0.178: PR7028.2 PR7035.1
TX0_HDMI+: length 3.9
  TOP w0.089: U6537.17 22.1,126.35 22.01,126.44 20.67,126.44 20.51,126.27 19.36,126.27 19.23,126.14 R68232.1
TX0_HDMI-: length 3.9
  TOP w0.089: U6537.16 22.1,126.75 22.01,126.67 20.58,126.67 20.41,126.5 19.36,126.5 19.23,126.63 R68233.1
TX1_HDMI+: length 4.7
  TOP w0.089: U6537.20 22.1,125.15 22.01,125.24 21.63,125.24 19.62,123.22 19.36,123.22 19.23,123.1 R68230.1
TX1_HDMI-: length 4.7
  TOP w0.089: U6537.19 22.1,125.55 22.01,125.47 21.54,125.47 19.52,123.45 19.36,123.45 19.23,123.58 R68231.1
TX2_HDMI+: length 5.6
  TOP w0.089: R68228.1 19.23,121.07 19.36,121.19 19.72,121.19 19.98,121.45 19.98,122.38 21.64,124.04 22.01,124.04 22.1,123.95 U6537.23
TX2_HDMI-: length 5.6
  TOP w0.089: R68229.1 19.23,121.55 19.36,121.42 19.63,121.42 19.76,121.55 19.76,122.48 21.55,124.27 22.01,124.27 22.1,124.35 U6537.22
TXC_HDMI+: length 4.5
  TOP w0.089: U6537.14 22.1,127.55 22.01,127.64 21.59,127.64 19.9,129.32 19.15,129.32 LH1.1
TXC_HDMI-: length 4.5
  TOP w0.089: U6537.13 22.1,127.95 22.01,127.87 21.68,127.87 20,129.55 19.15,129.55 LH1.4
TYPE C_ADP_IN: length 183.2
  TOP w0.114: v2(148.25,108.91) 148.86,108.31 R68871.1
  IN1 w0.089: v1(16.17,58.32) 16.17,57.55 17.83,55.9 17.83,54.12 22.14,49.81 23.92,49.81 26.46,52.35 26.46,55.27 27.35,56.16 27.35,63.12 32.18,67.95 32.18,78.49 34.97,81.28 34.97,87.14 36.29,88.46 36.29,89.08 37.81,90.6 71.06,90.6 74.21,93.75 74.21,94.94 78.15,98.88 78.15,101.32 80.21,103.37 88.92,103.37 89.49,103.94 92.91,103.94 94.03,105.05 100.12,105.05 101.96,106.89 109.08,106.89 109.32,107.13 115.36,107.13 115.82,107.59 119.93,107.59 120.82,108.48 128.95,108.48 129.76,109.29 134.74,109.29 135.3,108.73 136.06,108.73 136.95,107.85 140.66,107.85 141.68,108.86 144.83,108.86 145.18,108.51 147.85,108.51 v2(148.25,108.91)
  BOTTOM w0.114: R68760.1 16.17,59.07 v1(16.17,58.32)
TYPEC1_OUT_1-5A: length 216.4
  TOP w0.114: v1(19.35,47.01) 12.11,47.01 10.21,48.92 10.21,51.33 8.35,53.18 v2(8.35,58.44) ; v2(159.05,96.69) 159.46,96.28 U37.48
  IN2 w0.102: v1(19.35,47.01) 19.22,46.89 19.22,44.09 19.6,43.71 29.76,43.71 31.41,45.36 31.41,65.17 31.8,65.55 31.8,77.73 33.33,79.26 33.33,88.72 36.07,91.46 71.65,91.46 73.81,93.62 76.99,93.62 79.78,96.42 81.71,96.42 83.05,95.07 92.81,95.07 93.26,95.53 96.19,95.53 96.9,94.81 116.33,94.81 117.29,95.78 118.92,95.78 119.68,96.54 119.93,96.54 120.47,97.08 123.72,97.08 124.25,96.54 136.95,96.54 137.41,96.08 143.76,96.08 144.44,95.4 146.83,95.4 147.34,95.91 148.76,95.91 149.27,95.4 151.05,95.4 151.18,95.53 157.88,95.53 v2(159.05,96.69)
  BOTTOM w0.114: R68903.1 8.76,58.85 v2(8.35,58.44) 8.35,58.01 8.62,57.74 Q6617.2
TYPEC1_USB0: length 26.6
  TOP w0.254: C96857.2 C96859.2 9.77,65.38 v1(9.7,65.3) ; C96856.2 C96858.2 9.68,68.14 v1(9.65,68.17)
  TOP w0.508: v2(29.51,112.29) 29.19,112.61 PD8003.2 29.76,113.2 30.41,112.56 PD8007.2
  IN3 w0.508: v1(21.05,44.88) 20.72,44.88 20.37,45.23 17.19,45.23 15.54,46.89 11.98,46.89 v2(9.32,49.55)
  BOTTOM w0.254: v1(9.7,65.3) 9.57,65.3 9.33,65.54 CN10.A4 8.29,65.54 8.07,65.33 v5(7.92,65.33) 7.89,65.3 CN10.B9 ; v1(21.05,44.88) 21.18,44.76 R68696.1 ; v1(9.65,68.17) 9.52,68.04 CN10.A9 7.97,68.04 v5(7.92,67.99) 7.82,67.99 7.62,67.79 CN10.B4
  BOTTOM w0.508: v2(9.32,49.55) 9.32,49.43 9.86,48.88 R69057.1 ; 9.19,52.8 9.22,52.83 9.19,52.85
  vias: v2(10.08,58.7) v2(10.08,58.04) v2(10.08,57.35) v2(10.84,58.7) v2(10.84,58.04) v2(19.86,105.18) v2(20.29,105.69) v2(20.52,105) v2(20.95,105.53) v2(21.51,109.17) v2(21.89,106.69) v2(22.11,110.2) v2(22.08,109.54) v2(33.17,106.8) v2(33.17,106.14) v2(33.19,105.48) v2(33.83,106.73) v2(33.75,104.57) v2(33.85,106.07) v2(33.85,105.41) v2(34.49,106.73) v2(34.51,106.07) v2(34.51,105.41)
