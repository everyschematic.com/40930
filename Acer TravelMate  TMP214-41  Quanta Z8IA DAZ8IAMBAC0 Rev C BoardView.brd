# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TYPEC1_USB0_PD: length 3.5
  TOP w0.254: PR9281.2 36.5,115.24 36.65,115.24 37.26,114.63 37.26,113.18 37.64,112.8
  vias: v2(41.93,107.62)
TYPEC_FAULT: length 227.5
  TOP w0.114: v1(14.14,44.47) 9.82,48.79 5.89,48.79 4.24,50.44 v1(3.27,50.44) ; v1(171.66,109.89) 171.39,109.62 171.39,107.85 R68868.2
  IN1 w0.089: v1(23.67,50.19) 26.08,52.6 26.08,56.66 27.1,57.68 27.1,60.22 27.02,60.3 27.02,65.35 27.33,65.66 29.02,65.66 31.92,68.56 31.92,78.59 34.77,81.44 34.77,87.32 36.09,88.64 36.09,89.23 37.66,90.8 70.76,90.8 74.01,94.05 74.01,95.02 77.95,98.96 77.95,101.39 80.13,103.58 88.11,103.58 89.4,104.87 91.16,104.87 91.61,104.42 92.86,104.42 94,105.56 96.82,105.56 97.23,105.97 98.19,105.97 98.32,105.84 100.63,105.84 101.87,107.08 108.99,107.08 109.24,107.34 115.23,107.34 115.69,107.79 119.76,107.79 120.63,108.67 128.78,108.67 129.63,109.52 134.92,109.52 135.44,109 136.18,109 137.08,108.1 140.63,108.1 141.85,109.32 148.64,109.32 148.81,109.14 148.81,108.94 149.27,108.48 151.53,108.48 152.12,107.9 155.16,107.9 155.32,107.74 164.64,107.74 165.02,107.36 167.91,107.36 168.65,108.1 169.84,108.1 171.64,109.89 v1(171.66,109.89)
  IN2 w0.102: v1(23.67,50.19) 20.37,50.19 19.22,49.04 19.22,47.9 16.86,45.54 14.7,45.54 14.14,44.98 v1(14.14,44.47)
  BOTTOM w0.114: v1(3.27,50.44) 4.08,50.44 4.21,50.57 R69010.2 C96911.2 4.49,51.58 4.88,51.2 U6553.10 ; R69011.1 23.04,50.06 23.17,50.19 v1(23.67,50.19)
UART1_RXD: length 1.9
  TOP w0.089: v1(115.38,123.72) 115.38,122.81 TP13400.1
  BOTTOM w0.102: U6539.DT19 115.48,123.62 v1(115.38,123.72)
UART1_TXD: length 3.7
  BOTTOM w0.102: U6539.DV19 115.48,121.55 115.36,121.43 115.36,119.53 115.23,119.4 115.23,118.89 TP13399.1
UART2_RXD: length 6.9
  TOP w0.089: 114.19,122.07 114.19,122.09 113.69,122.6 113.69,122.97 113.93,123.21 113.93,126.6 114.35,127.02 v1(114.47,127.02)
  TOP w0.114: 114.19,122.07 TP13252.1
  BOTTOM w0.102: U6539.DG23 114.35,127.02 v1(114.47,127.02)
UART2_TXD: length 6.9
  TOP w0.089: v1(114.47,125.72) 114.47,125.71 114.11,125.34 114.11,123.48 114.57,123.01 114.57,122.07
  TOP w0.114: 114.57,122.07 115.18,121.46 115.18,120.49 115.01,120.32 TP13251.1
  BOTTOM w0.102: U6539.DJ21 114.62,125.72 v1(114.47,125.72)
ULT_EDP_HPD: length 121.1
  TOP w0.114: C6616.2 66.97,187.45 v2(67.03,187.5) 67.26,187.73 R25467.1 ; R68243.2 122.62,122.97 v1(122.23,122.97)
  IN3 w0.102: v1(122.23,122.97) 121.09,122.97 120.01,121.89 116.81,121.89 115.87,122.83 115.87,127.73 115.11,128.5 115.11,131.47 114.98,131.59 114.98,151.03 114.88,151.13 114.88,158.8 115.23,159.15 115.74,159.15 116.15,159.56 116.15,167.28 115.57,167.87 115.57,169.68 115.11,170.14 115.11,173.37 111.27,177.2 111.27,178.1 109.98,179.4 109.98,180.54 110.13,180.69 110.13,181.51 109.32,182.32 105.53,182.32 104.95,182.9 103.39,182.9 102.63,182.14 100.5,182.14 99.94,181.58 95.47,181.58 95.07,181.99 93.54,181.99 91.23,184.3 91.23,185.19 90.91,185.51 89.71,185.51 89.39,185.82 86.28,185.82 84.93,187.17 75.53,187.17 74.95,187.75 70.81,187.75 70.02,186.97 67.56,186.97 v2(67.03,187.5)
  BOTTOM w0.102: v1(122.23,122.97) U6539.DR5
ULT_EDP_HPD_R: length 9.3
  TOP w0.114: v1(68.78,193.93) 68.78,193.8 69.64,192.94 v2(69.9,192.94) 69.92,192.94 70.05,192.81 70.05,191.6 69.39,190.94 69.39,190.17 69.64,189.91 69.64,188.94 69.12,188.41 68.17,188.41 68.02,188.26 R25467.2
  BOTTOM w0.114: CN29.25 68.65,193.8 v1(68.78,193.93)
USB2_COMP: length 4.3
  BOTTOM w0.254: U6539.DE1 123.95,127.57 124.46,127.06 125.74,127.06 125.9,126.9 R68424.1
USB30_RX1+: length 146.8
  TOP w0.114: v2(22.52,90.6) 22.35,90.43 22.01,90.43 21.86,90.58 C518.2 20.9,90.82 R422.2
  IN1 w0.089: v1(128.32,130.2) 128.1,129.98 128.1,129.7 127.83,129.44 124.51,129.44 123.52,128.44 123.52,123.47 122.12,122.07 121.66,122.07 120.73,121.14 120.73,119.97 119.93,119.17 119.93,118.89 119.5,118.46 107.56,118.46 106.98,117.88 101.21,117.88 100.05,119.05 95.96,119.05 93.39,116.48 90.85,116.48 90.1,115.73 85.22,115.73 82.44,112.94 78.42,112.94 77.39,111.91 73.83,111.91 68.5,106.58 68.5,106.09 66.34,103.93 66.34,103.2 64.81,101.67 63.92,101.67 62.76,100.5 57.94,100.5 57.73,100.71 52.78,100.71 52.45,100.38 47.55,100.38 47.11,100.81 44.29,100.81 44.04,101.06 39.62,101.06 39.24,100.68 37.84,100.68 37.25,100.1 34.58,100.1 33.06,101.62 30.43,101.62 29.54,102.51 25.9,102.51 25.05,101.66 22.76,101.66 20.67,99.57 20.67,91.79 22.01,90.45 22.37,90.45 v2(22.52,90.6)
  BOTTOM w0.089: 126.03,131.2 126.01,131.2 125.98,131.17 123.63,131.17 123.44,130.98 123.44,130.89 U6539.CV2
  BOTTOM w0.114: v1(128.32,130.2) 128.12,130.4 128.12,130.65 127.57,131.2 126.03,131.2
USB30_RX1+_C: length 11
  TOP w0.114: R422.1 20.12,90.71 19.88,90.47 19.7,90.47 19.06,91.12 U6530.2 U6530.9 17.59,91.12 17.19,90.72 17.19,90.27 v2(16.99,90.07)
  IN3 w0.114: CN2.6 14.1,86.43 14.22,86.31 14.71,86.31 15.38,86.99 16.1,86.99 16.45,87.34 16.45,88.79 16.27,88.97 16.27,89.52 16.56,89.81 16.73,89.81 v2(16.99,90.07)
USB30_RX1-: length 146.8
  TOP w0.114: R421.2 20.89,89.82 C513.2 21.86,90.04 22.02,90.2 22.26,90.2 v2(22.52,89.94)
  IN1 w0.089: v2(22.52,89.94) 22.52,90.05 22.31,90.27 21.94,90.27 20.49,91.72 20.49,99.64 22.69,101.84 24.98,101.84 25.83,102.69 29.61,102.69 30.5,101.8 33.13,101.8 34.66,100.28 37.18,100.28 37.76,100.86 39.16,100.86 39.55,101.24 44.11,101.24 44.37,100.99 47.19,100.99 47.62,100.56 52.37,100.56 52.7,100.89 57.81,100.89 58.01,100.68 62.68,100.68 63.85,101.85 64.74,101.85 66.16,103.27 66.16,104.01 68.32,106.17 68.32,106.65 73.76,112.09 77.32,112.09 78.35,113.12 82.36,113.12 85.14,115.9 90.02,115.9 90.78,116.66 93.32,116.66 95.88,119.22 100.12,119.22 101.29,118.06 106.9,118.06 107.49,118.64 119.43,118.64 119.75,118.97 119.75,119.25 120.55,120.04 120.55,121.21 121.59,122.25 122.04,122.25 123.34,123.54 123.34,128.52 124.43,129.61 127.76,129.61 127.92,129.78 127.92,129.96 v1(127.68,130.2)
  BOTTOM w0.089: 126.03,130.97 126.01,130.97 125.98,130.99 123.7,130.99 123.62,130.91 123.62,130.79 123.69,130.72 U6539.CV1
  BOTTOM w0.114: 126.03,130.97 127.48,130.97 127.89,130.56 127.89,130.4 v1(127.68,130.2)
USB30_RX1-_C: length 11
  TOP w0.114: v2(16.99,89.4) 17.45,89.86 17.45,90.54 17.53,90.62 U6530.10 U6530.1 19.24,90.62 19.61,90.24 19.78,90.24 20.1,89.92 R421.1
  IN3 w0.114: CN2.5 14.1,85.57 14.6,86.07 14.81,86.07 15.48,86.74 16.2,86.74 16.7,87.24 16.7,88.89 16.51,89.07 16.51,89.42 16.66,89.57 16.83,89.57 v2(16.99,89.4)
USB30_RX2+: length 141.9
  TOP w0.114: R428.2 23.33,105.83 23.48,105.68 23.92,105.68 24.05,105.8 24.05,106.12 C526.2 24.81,105.91 25.69,105.91 26.56,105.04 26.56,103.88 27.42,103.02 28.11,103.02 28.52,102.61 28.52,102.33 v1(28.72,102.13)
  IN3 w0.114: v1(129.58,130.2) 129.79,129.99 129.84,129.99 129.98,129.86 129.98,129.19 129.6,128.81 129.6,127.25 128.71,126.36 128.71,125.55 128.46,125.29 128.46,121.55 128.84,121.17 128.84,119.12 125.93,116.21 125.71,116.21 124.44,114.94 121.36,114.94 120.45,114.04 118.67,114.04 117.51,112.87 114.84,112.87 111.88,109.92 109.46,109.92 107.35,107.81 106.05,107.81 104.77,106.52 101.67,106.52 100.17,105.02 99.24,105.02 98.12,103.9 95.67,103.9 95.35,103.58 78.84,103.58 77.96,102.7 77.49,102.7 76.91,102.12 71.95,102.12 69.92,100.09 68.13,100.09 66.92,98.88 59.57,98.88 58.32,97.62 53.97,97.62 53.29,98.29 38.4,98.29 38.26,98.43 29.48,98.43 28.56,99.36 28.56,101.96 v1(28.72,102.13)
  BOTTOM w0.089: 128.06,131.64 128.04,131.64 128.01,131.67 125.98,131.67 125.71,131.41 123.07,131.41 U6539.CU3
  BOTTOM w0.114: v1(129.58,130.2) 129.79,130.41 129.79,130.69 128.83,131.64 128.06,131.64
USB30_RX2+_C: length 11.3
  TOP w0.114: R428.1 21.96,105.81 21.76,105.81 21.48,106.09 21.48,106.43 21.05,106.86 20.4,106.86 20.3,106.76 U6531.2 U6531.9 18.39,106.76 18.18,106.55 18.02,106.55 v2(17.76,106.81)
  BOTTOM w0.114: CN3.6 14.1,104.51 14.23,104.38 14.62,104.38 15.44,105.19 15.88,105.19 17.14,106.45 17.4,106.45 v2(17.76,106.81)
USB30_RX2-: length 142
  TOP w0.114: R427.2 23.57,105.45 24.08,105.45 C523.2 24.81,105.69 25.6,105.69 26.33,104.95 26.33,103.78 27.33,102.79 28.01,102.79 28.29,102.51 28.29,102.33 v1(28.09,102.13)
  IN3 w0.114: v1(28.09,102.13) 28.11,102.13 28.32,101.93 28.32,99.26 29.38,98.19 38.16,98.19 38.3,98.05 53.19,98.05 53.87,97.38 58.42,97.38 59.67,98.64 67.02,98.64 68.23,99.84 70.02,99.84 72.05,101.88 77.01,101.88 77.59,102.46 78.06,102.46 78.94,103.34 95.45,103.34 95.77,103.66 98.22,103.66 99.34,104.78 100.27,104.78 101.77,106.28 104.87,106.28 106.15,107.57 107.45,107.57 109.56,109.67 111.98,109.67 114.94,112.63 117.61,112.63 118.77,113.8 120.55,113.8 121.46,114.7 124.54,114.7 125.81,115.97 126.03,115.97 129.08,119.02 129.08,121.27 128.7,121.65 128.7,125.19 128.95,125.45 128.95,126.26 129.84,127.15 129.84,128.71 130.22,129.09 v1(130.22,130.2)
  BOTTOM w0.089: 128.06,131.87 128.04,131.87 128.01,131.85 125.9,131.85 125.64,131.59 122.87,131.59 U6539.CT4
  BOTTOM w0.114: v1(130.22,130.2) 130.02,130.4 130.02,130.78 128.93,131.87 128.06,131.87
USB30_RX2-_C: length 11.3
  TOP w0.114: v2(17.76,106.05) 18.04,106.32 18.47,106.32 18.53,106.26 U6531.10 U6531.1 20.13,106.26 20.5,106.63 20.95,106.63 21.25,106.33 21.25,106 21.67,105.58 22.16,105.58 R427.1
  BOTTOM w0.114: v2(17.76,106.05) 17.59,106.22 17.58,106.22 17.23,106.22 15.98,104.96 15.53,104.96 14.72,104.15 14.21,104.15 14.2,104.16 14.1,104.05 CN3.5
USB30_RX4+: length 105.5
  IN4 w0.089: v2(206.18,115.07) 206.42,114.83 206.42,114.57 206.2,114.35 202.59,114.35 199.89,117.04 192.93,117.04 191.91,118.06 181.07,118.06 180.52,117.5 174.8,117.5 174.42,117.12 174.42,115.52 173.78,114.89 173.78,114.78 173.25,114.25 171.8,114.25 170.96,113.41 167.97,113.41 167.46,112.9 167,112.9 165.48,111.38 153.49,111.38 153.08,111.78 152.45,111.78 149.4,114.83 149.4,117.62 145.03,121.99 139.44,121.99 136.67,124.76 136.67,125.09 133.45,128.32 133.45,130.4 130.67,133.18 127.66,133.18 127.43,132.95 127.43,132.61 v1(127.3,132.48)
  BOTTOM w0.089: U6539.CN5 122.27,132.89 122.77,132.89 123.13,132.77 124.28,132.77 124.38,132.86 126.92,132.86 v1(127.3,132.48)
  BOTTOM w0.114: v2(206.18,115.07) 206.36,114.89 206.36,114.08 206.22,113.94 206.04,113.94 205.95,113.85 CN48.14
USB30_RX4-: length 105.5
  IN4 w0.089: v2(206.89,115.07) 206.6,114.78 206.6,114.5 206.27,114.17 202.51,114.17 199.82,116.86 192.85,116.86 191.84,117.88 181.15,117.88 180.59,117.32 174.87,117.32 174.59,117.04 174.59,115.45 173.96,114.81 173.96,114.7 173.32,114.07 171.87,114.07 171.04,113.23 168.04,113.23 167.53,112.72 167.07,112.72 165.55,111.2 153.41,111.2 153.01,111.6 152.37,111.6 149.22,114.76 149.22,117.55 144.96,121.82 139.36,121.82 136.49,124.69 136.49,125.02 133.27,128.24 133.27,130.33 130.59,133 127.73,133 127.6,132.88 127.6,132.7 127.82,132.48 v1(127.93,132.48)
  BOTTOM w0.089: v1(127.93,132.48) 127.55,132.86 127.17,132.86 126.99,133.04 124.31,133.04 124.21,132.95 123.15,132.95 122.71,133.09 U6539.CN4
  BOTTOM w0.114: CN48.13 206.45,113.84 206.59,113.99 206.59,114.77 v2(206.89,115.07)
USB30_TX1+: length 147.4
  TOP w0.114: v2(19.16,86.67) 20.01,86.67 20.68,86 21.51,86 22.4,85.11 23.59,85.11 24.81,86.33 C520.1
  IN1 w0.089: v1(120.82,130.06) 120.83,130.06 121.38,129.51 122.02,129.51 122.75,128.77 122.75,127.53 122.22,127 122.22,126.13 121.84,125.75 121.84,124.87 122.12,124.59 122.12,124.02 118.61,120.52 118.61,120.11 117.72,119.22 106.98,119.22 106.45,118.69 102.99,118.69 102.05,119.63 100.66,119.63 100.48,119.81 95.65,119.81 93.11,117.27 90.32,117.27 89.52,116.47 84.9,116.47 83.18,114.75 82.52,114.75 81.46,113.69 77.91,113.69 77.01,112.8 73.66,112.8 67.56,106.7 67.56,106.22 65.45,104.11 65.45,103.45 64.44,102.44 63.63,102.44 62.46,101.27 58.44,101.27 58.24,101.47 52.32,101.47 52.02,101.16 47.87,101.16 47.47,101.57 44.67,101.57 43.73,102.51 33.65,102.51 32.71,103.45 30.05,103.45 29.94,103.35 25.65,103.35 24.71,102.41 22.3,102.41 18.28,98.39 18.28,92.96 18.77,92.48 18.77,88.06 18.46,87.75 18.46,87.15 18.72,86.88 18.95,86.88 v2(19.16,86.67)
  BOTTOM w0.114: v1(120.82,130.06) 120.82,129.81 U6539.DA8
USB30_TX1+_C: length 3.8
  TOP w0.114: R432.2 24.01,90.82 23.82,90.63 23.82,90.44 24.14,90.12 24.14,89.85 24.28,89.71 v2(24.71,89.71) 24.33,89.33 24.33,89.13 24.51,88.95 24.51,88.72 24.81,88.41 C520.2
USB30_TX1+_C_R: length 12.5
  TOP w0.114: R432.1 23.92,91.85 23.92,92.22 23.66,92.48 21.38,92.48 C522.1 20.44,92.5 19.34,92.5 19.22,92.62 U6530.5 U6530.6 17.46,92.62 17.3,92.45 16.79,92.45 16.05,91.72 15.23,91.72 14.65,92.29 14.23,92.29 14.1,92.42 CN2.9
USB30_TX1-: length 147.4
  TOP w0.114: C519.1 24.05,87.4 24.18,87.27 24.46,87.27 24.58,87.14 24.58,86.43 23.5,85.34 22.49,85.34 21.6,86.23 20.77,86.23 20.1,86.9 19.6,86.9 v2(19.16,87.35)
  IN1 w0.089: v1(121.46,130.04) 121.39,129.98 121.39,129.75 121.46,129.68 122.1,129.68 122.93,128.85 122.93,127.46 122.4,126.92 122.4,126.06 122.02,125.68 122.02,124.94 122.3,124.66 122.3,123.95 118.79,120.44 118.79,120.04 117.8,119.05 107.06,119.05 106.52,118.51 102.92,118.51 101.98,119.45 100.58,119.45 100.4,119.63 95.73,119.63 93.19,117.09 90.39,117.09 89.6,116.3 84.98,116.3 83.26,114.58 82.6,114.58 81.54,113.52 77.98,113.52 77.08,112.62 73.73,112.62 67.74,106.63 67.74,106.14 65.63,104.04 65.63,103.37 64.51,102.26 63.7,102.26 62.53,101.09 58.37,101.09 58.16,101.29 52.4,101.29 52.09,100.99 47.8,100.99 47.39,101.39 44.6,101.39 43.66,102.33 33.57,102.33 32.63,103.27 30.12,103.27 30.02,103.17 25.73,103.17 24.79,102.23 22.37,102.23 18.46,98.32 18.46,93.04 18.94,92.55 18.94,87.98 18.64,87.68 18.64,87.22 18.8,87.06 19.03,87.06 19.16,87.19 v2(19.16,87.35)
  BOTTOM w0.114: U6539.DA7 121.41,129.58 121.54,129.7 121.54,129.96 v1(121.46,130.04)
USB30_TX1-_C: length 3.8
  TOP w0.114: C519.2 24.05,88.41 24.28,88.64 24.28,88.85 24.1,89.03 24.1,89.25 23.92,89.43 23.73,89.43 v2(23.44,89.71) 23.79,89.71 23.91,89.84 23.91,90.03 23.59,90.35 23.59,90.44 R424.2
USB30_TX1-_C_R: length 12.5
  TOP w0.114: CN2.8 14.1,91.93 14.24,92.07 14.55,92.07 15.13,91.49 16.14,91.49 16.88,92.23 17.32,92.23 17.42,92.12 U6530.7 U6530.4 19.23,92.12 19.38,92.27 20.42,92.27 C521.1 21.36,92.25 23.57,92.25 23.69,92.12 23.69,91.76 23.53,91.6 R424.1
USB30_TX2+: length 133.1
  TOP w0.114: v1(30.65,102.82) 30.27,103.2 v2(30.27,104.29) 30.27,104.36 29.46,105.17 28.45,105.17 27.58,106.04 27.58,107.69 26.91,108.35 C531.1
  IN3 w0.114: v1(30.65,102.82) 30.51,102.68 30.17,102.68 29.89,102.4 29.89,100.39 30.34,99.95 30.34,99.72 30.81,99.25 39.93,99.25 40.46,98.71 58.44,98.71 59.04,99.31 66.75,99.31 67.98,100.54 69.76,100.54 71.85,102.64 75.61,102.64 77.26,104.29 77.64,104.29 78.34,104.99 79.36,104.99 79.93,105.56 80.56,105.56 81.2,106.19 82.68,106.19 83.31,106.82 83.86,106.82 84.13,107.1 94.93,107.1 97.07,109.24 99.97,109.24 101.24,110.51 102.79,110.51 103.65,111.38 106.29,111.38 106.69,111.77 108.06,111.77 109.04,112.75 109.04,113.5 110.26,114.72 110.94,114.72 111.36,115.15 113.48,115.15 114.73,116.39 114.73,116.74 115.03,117.04 115.95,117.04 116.25,117.34 123.85,117.34 124.25,117.75 124.25,118.31 125.6,119.66 125.6,120.97 125.76,121.13 125.76,122.97 124.15,124.58 124.15,129.5 122.25,131.4 121.25,131.4 v1(120.82,130.97)
  BOTTOM w0.114: U6539.CW8 v1(120.82,130.97)
USB30_TX2+_C: length 1.3
  TOP w0.114: R430.2 25.12,108.05 25.3,108.05 C531.2
USB30_TX2+_C_R: length 11.7
  TOP w0.114: R430.1 C533.1 22.23,108.07 20.28,108.07 20.09,108.26 U6531.5 U6531.6 18.44,108.26 18.38,108.2 17.71,108.2 16.52,109.39 15.52,109.39 14.57,110.33 14.23,110.33 14.1,110.46 CN3.9
USB30_TX2-: length 133
  TOP w0.114: C530.1 26.05,107.79 26.18,107.92 26.28,107.92 26.49,108.12 26.82,108.12 27.35,107.59 27.35,105.95 28.35,104.95 28.36,104.94 29.37,104.94 29.74,104.57 29.74,104.29 29.61,104.16 29.39,104.16 29.13,103.9 v2(29.13,103.65) 29.51,103.65 29.64,103.78 30.02,103.78 30.04,103.76 30.04,103.1 30.2,102.95 30.2,102.59 30.58,102.21 v1(30.65,102.21)
  IN3 w0.114: v1(30.65,102.21) 30.65,102.26 30.48,102.43 30.27,102.43 30.13,102.3 30.13,100.49 30.58,100.05 30.58,99.82 30.91,99.49 40.03,99.49 40.56,98.96 58.34,98.96 58.94,99.55 66.65,99.55 67.88,100.78 69.66,100.78 71.75,102.88 75.51,102.88 77.16,104.53 77.54,104.53 78.24,105.23 79.26,105.23 79.83,105.8 80.46,105.8 81.1,106.44 82.58,106.44 83.21,107.06 83.76,107.06 84.03,107.34 94.83,107.34 96.97,109.48 99.87,109.48 101.14,110.75 102.69,110.75 103.55,111.62 106.19,111.62 106.59,112.01 107.96,112.01 108.8,112.85 108.8,113.6 110.16,114.96 110.84,114.96 111.26,115.39 113.38,115.39 114.49,116.49 114.49,116.84 114.93,117.28 115.85,117.28 116.15,117.59 123.75,117.59 124.01,117.85 124.01,118.41 125.36,119.76 125.36,121.07 125.52,121.23 125.52,122.87 123.91,124.48 123.91,129.4 122.15,131.16 121.66,131.16 v1(121.47,130.97)
  BOTTOM w0.114: U6539.CW7 121.16,130.57 121.16,130.75 121.38,130.97 v1(121.47,130.97)
USB30_TX2-_C: length 1.3
  TOP w0.114: C530.2 25.37,107.82 25.08,107.82 R429.2
USB30_TX2-_C_R: length 11.8
  TOP w0.114: CN3.8 14.1,109.98 14.23,110.11 14.48,110.11 15.43,109.16 16.43,109.16 17.61,107.97 18.3,107.97 18.51,107.76 U6531.7 U6531.4 20.27,107.76 20.35,107.85 22.23,107.85 C532.1 R429.1
USB30_TX4+: length 107.2
  IN4 w0.089: v2(203.91,115.41) 203.98,115.41 204.13,115.57 204.13,116.74 202.03,118.84 192.91,118.84 192.58,118.51 179.88,118.51 179.27,117.9 174.44,117.9 174.01,117.47 174.01,115.67 173.34,115 173.34,114.9 173.09,114.65 171.65,114.65 170.81,113.81 167.81,113.81 167.3,113.31 166.85,113.31 165.31,111.77 153.86,111.77 153.39,112.24 152.62,112.24 150.22,114.64 150.22,118.45 146.15,122.53 139.93,122.53 138.17,124.28 138.17,125.42 137.89,125.7 137.38,125.7 135.57,127.52 135.57,129.04 135.17,129.44 134.67,129.44 134.16,129.94 134.16,130.33 132.96,131.52 132.96,132.66 132.05,133.58 124.71,133.58 123.06,131.92 122.14,131.92 121.73,132.34 121.26,132.34 v1(120.87,132.73)
  BOTTOM w0.114: v2(203.91,115.41) 204.13,115.18 204.13,114.2 203.95,114.01 CN48.18 ; U6539.CR8 120.87,132.6 v1(120.87,132.73)
USB30_TX4-: length 107.2
  IN4 w0.089: v1(121.5,132.73) 121.72,132.51 121.81,132.51 122.22,132.1 122.98,132.1 124.64,133.75 132.13,133.75 133.14,132.74 133.14,131.59 134.34,130.4 134.34,130.02 134.74,129.61 135.25,129.61 135.75,129.12 135.75,127.59 137.46,125.88 137.97,125.88 138.35,125.5 138.35,124.36 140,122.7 146.22,122.7 150.4,118.52 150.4,114.71 152.7,112.42 153.46,112.42 153.93,111.95 165.24,111.95 166.77,113.48 167.23,113.48 167.74,113.99 170.73,113.99 171.57,114.83 173.02,114.83 173.16,114.97 173.16,115.07 173.83,115.74 173.83,117.55 174.37,118.08 179.19,118.08 179.8,118.69 192.5,118.69 192.83,119.02 202.1,119.02 204.31,116.81 204.31,115.54 204.44,115.41 v2(204.77,115.41)
  BOTTOM w0.114: v1(121.5,132.73) 121.5,132.58 U6539.CR7 ; v2(204.77,115.41) 204.59,115.41 204.36,115.19 204.36,114.15 204.45,114.07 CN48.17
USB_BC_ON: length 251.6
  TOP w0.114: v2(24.18,102.82) 23.39,102.03 21.06,102.03 20.39,101.36 19.72,101.36 18.7,100.34 U14.4 ; v1(178.23,114.53) 177.64,113.94 172.38,113.94 171.83,113.38 170.28,113.38 170.07,113.59 168.63,113.59 167.2,112.16 166.03,112.16 165.86,111.99 U37.97
  IN2 w0.102: v2(200.58,101.11) 200.14,101.55 197.29,101.55 196.69,100.96 194.16,100.96 192.59,102.52 191.96,102.52 189.53,100.1 181.4,100.1 181.02,99.72 181.02,99.34 180.79,99.11 170.07,99.11 167.76,96.8 161.71,96.8 160.79,97.71 152.34,97.71 152.06,97.43 147.49,97.43 146.98,96.92 144.95,96.92 144.8,96.77 137.76,96.77 137.46,97.08 137.46,97.58 136.98,98.07 135.2,98.07 134.64,97.51 124.94,97.51 124.46,97.99 119.86,97.99 119.43,97.56 119.17,97.56 118.31,96.69 108.78,96.69 107.84,95.75 105.99,95.75 105.43,96.31 102.94,96.31 102.76,96.14 100.33,96.14 99.66,96.8 92.5,96.8 91.87,97.43 86.53,97.43 86.08,96.97 83.31,96.97 82.6,97.69 73.58,97.69 73.07,97.18 71.93,97.18 69.28,94.52 45.36,94.52 44.64,95.25 35.02,95.25 32.96,97.3 28.16,97.3 26.21,99.26 26.21,101.24 25.19,102.26 24.73,102.26 v2(24.18,102.82)
  IN3 w0.102: v1(178.23,114.53) 179.32,115.62 184.68,115.62 186.74,113.56 188.77,113.56 189.15,113.18 192.2,113.18 194.61,110.77 196.29,110.77 197.2,109.85 197.4,109.85 197.89,109.37 198.29,109.37 199.44,110.51 202.4,110.51 203.37,109.54 203.37,105.05 200.58,102.26 v2(200.58,101.11)
USB_CHARGE_ON: length 250.7
  TOP w0.114: U14.5 17.48,97.72 17.28,97.93 17.28,98.16 17.57,98.45 17.57,99.71 v2(17.83,99.97) 18.44,100.57 R416.1 18.72,100.74 19.6,101.62 20.28,101.62 20.95,102.3 22.97,102.3 v2(23.49,102.82) ; U37.96 168.48,109.54 168.68,109.34 v1(168.68,109.04)
  IN2 w0.102: v2(199.92,101.11) 199.72,101.32 197.38,101.32 196.79,100.73 194.06,100.73 192.5,102.28 192.07,102.28 190.16,100.38 190.16,99.34 189.91,99.08 181.66,99.08 181.43,98.85 170.17,98.85 167.89,96.57 161.61,96.57 160.7,97.48 153.72,97.48 153.13,96.9 152.73,96.9 152.45,97.18 147.95,97.18 146.68,95.91 144.83,95.91 144.19,96.54 137.66,96.54 137.23,96.97 137.23,97.41 136.8,97.84 135.3,97.84 134.74,97.28 124.79,97.28 124.3,97.76 120.01,97.76 119.55,97.3 119.3,97.3 118.46,96.47 109.19,96.47 108.25,95.53 105.84,95.53 105.28,96.08 103.09,96.08 102.92,95.91 100.22,95.91 99.59,96.54 92.63,96.54 92.07,95.98 87.09,95.98 86.33,96.75 83.15,96.75 82.47,97.43 73.71,97.43 73.2,96.92 72.05,96.92 69.41,94.28 42.21,94.28 42.16,94.33 35.6,94.33 32.88,97.05 28.06,97.05 25.83,99.29 25.83,101.21 25.03,102 24.3,102 v2(23.49,102.82)
  IN3 w0.102: v2(199.92,101.11) 199.94,101.14 199.94,102.13 202.99,105.18 202.99,107.46 202.36,108.1 200.32,108.1 199.94,107.72 194.1,107.72 192.32,109.5 192.32,110.13 190.93,111.53 186.41,111.53 184.25,113.69 180.46,113.69 180.11,113.33 180.11,112.76 179.4,112.05 175.76,112.05 172.27,108.56 169.16,108.56 v1(168.68,109.04)
USB_CLT1: length 225.9
  TOP w0.114: v2(22.83,102.82) 22.6,102.59 20.87,102.59 20.29,102.01 v2(18.16,102.01) 17.19,101.04 17.19,98.58 17.01,98.4 17.01,97.58 17.37,97.22 U14.6 ; v2(165.81,104.64) 166.06,104.64 166.53,104.17 166.53,102.92 166.71,102.74 U37.79
  IN1 w0.089: v2(165.81,104.64) 166.31,104.64 167.42,103.54 170.56,103.54 171.86,102.24 174.36,102.24 175.01,101.59 191.99,101.59 v2(192.22,101.82)
  IN2 w0.102: v2(22.83,102.82) 23.9,101.75 24.94,101.75 25.57,101.11 25.57,99.21 28.11,96.67 32.92,96.67 35.51,94.08 42.06,94.08 42.08,94.05 69.57,94.05 72.18,96.67 73.32,96.67 73.83,97.18 82.34,97.18 83,96.52 86.15,96.52 86.91,95.75 92.22,95.75 92.76,96.29 97.81,96.29 98.7,95.4 102.76,95.4 103.22,95.86 105.13,95.86 105.71,95.27 113.61,95.27 114.57,96.24 118.61,96.24 119.43,97.05 119.68,97.05 120.16,97.53 124.02,97.53 124.51,97.05 134.84,97.05 135.4,97.61 136.65,97.61 136.99,97.27 136.99,96.88 137.56,96.31 144.04,96.31 144.7,95.65 146.76,95.65 148.03,96.92 152.06,96.92 152.32,96.67 153.25,96.67 153.83,97.25 160.6,97.25 161.52,96.34 168.07,96.34 170.33,98.6 181.55,98.6 181.78,98.83 191.05,98.83 191.18,98.96 191.18,100.78 v2(192.22,101.82)
USB_ID: length 3.9
  BOTTOM w0.102: U6539.DF1 124.07,127 124.3,126.77 125.27,126.77 125.73,126.31 125.73,126.06 125.9,125.88 126.03,125.88
  BOTTOM w0.114: 126.03,125.88 R68423.2
USB_OC0#: length 147.9
  TOP w0.114: U14.13 21.69,96.22 21.95,96.49 22.83,96.49 23.39,97.05 24.94,97.05 v2(26.14,98.26) 28.18,98.26 28.62,98.7 28.62,99.46 v1(29,99.84) ; R68418.1 v1(125.78,124.63) ; v1(75.23,122.32) 74.09,122.32 71.67,119.91 71.67,116.86 73.2,115.34 73.2,108.48 73.58,108.1 73.58,107.46 73.17,107.06 73.17,104.52 70.33,101.67 70.33,100.3 71.55,99.08 v1(71.55,98.73)
  IN1 w0.089: v1(119.94,127.58) 119.55,127.97 119.55,128.29 119.17,128.67 118.28,128.67 117.9,129.05 117.9,130.96 116.63,132.23 108.5,132.23 106.98,130.71 99.61,130.71 99.23,131.09 85.77,131.09 77.77,123.09 75.99,123.09 v1(75.23,122.32)
  IN2 w0.102: v1(71.55,98.73) 71.45,98.62 71.45,97.46 68.97,94.98 45.61,94.98 44.89,95.7 35.56,95.7 33.32,97.94 29.89,97.94 29,98.83 v1(29,99.84)
  IN4 w0.089: v1(125.78,124.63) 125.78,125.12 125.65,125.24 123.79,125.24 121.25,127.78 121.25,128.37 121.05,128.57 120.59,128.57 120.31,128.29 120.31,127.91 119.98,127.58 v1(119.94,127.58)
  BOTTOM w0.102: U6539.DD8 119.99,127.58 v1(119.94,127.58)
USB_OC2#: length 184.8
  TOP w0.089: 101.9,124.61 102.15,124.36 102.15,124.1 102.38,123.87 102.38,123.49 102.53,123.34 102.92,123.34 103.17,123.59 103.17,124.7 103.56,125.09 v1(103.56,125.12)
  TOP w0.114: R68248.2 91.81,124.79 92.15,124.46 93.01,124.46 93.37,124.1 96.49,124.1 97.51,125.12 101.14,125.12 101.52,124.74 101.77,124.74 101.9,124.61
  IN4 w0.089: v1(103.56,125.12) 104.06,125.62 104.06,127.15 103.83,127.38 103.06,127.38 102.99,127.45 102.43,127.45 102.13,127.15 101.65,127.15 99.21,124.71 99.21,121.92 99.03,121.74 99.03,120.32 94.31,115.59 94.31,110.74 97.84,107.21 99.84,107.21 102.92,104.14 102.92,102.64 105.53,100.02 117.34,100.02 119.93,97.43 120.7,97.43 121.23,96.9 121.23,95.63 121.58,95.27 122.6,95.27 122.85,95.53 135.55,95.53 135.81,95.27 136.57,95.27 136.82,95.02 142.67,95.02 143.94,93.75 189.53,93.75 190.29,94.51 200.13,94.51 203.18,91.46 v2(212.14,91.46)
  BOTTOM w0.102: v1(103.56,125.12) 103.57,125.11 103.75,125.11 U6539.DK45
  BOTTOM w0.114: U18.3 216.9,105.42 216.58,105.1 v2(216.58,103.27) 214.8,101.5 214.8,99.97 214.29,99.46 214.29,93.62 v2(212.14,91.46)
USB_OC3#: length 140.6
  TOP w0.089: v1(103.56,125.73) 103.45,125.73 103.17,126.01 103.17,126.51 102.99,126.69 102.33,126.69 101.9,126.26
  TOP w0.114: v1(75.89,116.86) 74.8,115.77 74.8,110.94 75.89,109.85 75.89,106.24 75.51,105.86 75.51,102.79 74.85,102.13 v2(74.85,101.75) 75.15,101.44 v1(75.15,100.96) ; R68419.1 93.13,124.79 93.54,124.38 96.21,124.38 97.45,125.63 101.26,125.63 101.9,126.26
  IN1 w0.089: v1(103.56,125.73) 103.45,125.73 103.17,126.01 103.17,126.56 103.04,126.69 102.21,126.69 100.12,124.61 97.81,124.61 96.92,123.72 93.52,123.72 91.46,121.66 89.43,121.66 88.18,120.42 87.42,120.42 86.79,121.05 84.25,121.05 83.1,119.91 81.96,119.91 81.45,119.4 81.45,119 80.66,118.21 79.12,118.21 78.53,117.62 77.39,117.62 76.63,116.86 v1(75.89,116.86)
  IN2 w0.102: v2(24.79,103.15) 26.31,101.62 27.86,101.62 28.49,100.99 28.49,98.7 29.64,97.56 33.06,97.56 35.14,95.48 44.76,95.48 45.49,94.75 69.12,94.75 71.8,97.43 72.56,97.43 72.94,97.81 72.94,98.19 72.56,98.57 72.56,99.69 73.55,100.68 73.55,101.09 73.71,101.24 74.87,101.24 v1(75.15,100.96)
  BOTTOM w0.102: U6539.DJ45 103.71,125.73 v1(103.56,125.73)
  BOTTOM w0.114: U15.3 17.21,94.62 16.56,95.27 16.56,98.96 19.1,101.5 19.1,102.64 19.86,103.4 24.53,103.4 v2(24.79,103.15)
USB_VBUSSENSE: length 5.3
  TOP w0.203: R68422.2 122.38,128.77 121.56,129.59 118.82,129.59 118.46,129.23 v1(118.46,129.12)
  BOTTOM w0.254: U6539.DC12 118.46,128.84 v1(118.46,129.12)
USBON#: length 317.6
  TOP w0.114: v2(213.79,106.7) 214.68,107.59 214.68,111.53 213.61,112.6 213.61,120.21 212.9,120.93 212.9,121.31 212.52,121.69 212.52,122.45 v2(212.01,122.96) ; U37.99 165.06,112.01 165.21,112.16 165.6,112.16 165.91,112.47 167.12,112.47 168.53,113.87 170.17,113.87 170.38,113.66 171.72,113.66 172.28,114.22 176.98,114.22 178.99,116.23 178.99,118.01 177.46,119.53 177.46,121.56 178.48,122.58 v2(179.12,122.58) 179.88,122.58 180.36,122.09 v2(180.36,121.84)
  IN1 w0.089: v2(213.79,106.7) 213.41,107.08 208.96,107.08 v2(208.2,107.85)
  IN2 w0.102: v2(208.2,107.85) 207.56,108.48 202.99,108.48 202.74,108.23 201.1,108.23 199.88,107.01 184.15,107.01 180.52,110.63 179.74,110.63 179.07,111.31 176.61,111.31 172.05,106.74 168.72,106.74 167.4,105.43 161.95,105.43 159.74,103.22 152.78,103.22 151.53,101.98 146.63,101.98 145.94,102.66 139.57,102.66 139.19,102.28 131.06,102.28 130.04,103.3 123.03,103.3 122.93,103.4 115.49,103.4 115.26,103.17 110.05,103.17 109.39,102.51 101.52,102.51 101.11,102.92 94.43,102.92 94.15,102.64 92.88,102.64 92.27,102.03 88.26,102.03 88.11,101.88 87.55,101.88 87.22,102.21 80.23,102.21 79.93,102.51 79.04,102.51 78.79,102.26 72.72,102.26 72.02,101.56 72.02,101.15 72.13,101.04 72.13,100.68 71.88,100.43 71.12,100.43 70.33,99.64 70.33,98.04 68.3,96.01 46.05,96.01 45.33,96.72 37.71,96.72 34.72,99.72 34.72,102.77 35.22,103.27 35.22,106.96 34.95,107.24 31.82,107.24 30.53,105.94 27.5,105.94 v2(25.22,103.65)
  IN3 w0.102: v2(180.36,121.84) 181.38,121.84 181.78,121.43 187.12,121.43 187.5,121.05 190.82,121.05 191.08,121.31 196.45,121.31 199.72,124.58 202.76,124.58 204.13,125.95 206.85,125.95 207.66,125.14 209.83,125.14 v2(212.01,122.96)
  BOTTOM w0.114: U18.4 216.9,108.29 215.31,106.7 v2(213.79,106.7) ; v2(25.22,103.65) 25.32,103.55 25.32,102.77 24.81,102.26 22.52,102.26 21.76,103.02 19.86,103.02 19.48,102.64 19.48,101.37 16.94,98.83 16.94,95.4 17.19,95.15 20.54,95.15 21.07,94.62 U15.4
USBP1+_CR: length 176.6
  IN3 w0.089: 122.35,129.1 122.33,129.11 122.29,129.11 121.73,129.66 121.18,129.66 121.15,129.69 119.99,129.69 119.81,129.51 119.81,129.28 v1(119.65,129.12)
  IN3 w0.114: v1(28.04,64.97) 27.54,64.47 27.54,61.05 26.72,60.22 25.03,60.22 24.62,60.62 24.62,61.3 24.05,61.87 23.67,61.87 23.41,62.13 23.41,63.4 23.16,63.65 23.16,69.21 22.13,70.24 22.13,72.81 21,73.94 21,78.25 21.51,78.76 21.51,79.14 22.36,79.99 22.36,86.09 22.83,86.56 22.83,88.57 23.24,88.97 23.24,91.96 23.95,92.67 23.95,93.98 26.65,96.68 26.65,102.07 27.6,103.02 28.49,103.02 28.87,103.4 31.89,103.4 33.47,101.81 36.73,101.81 37.75,100.79 42.52,100.79 42.77,101.04 44.5,101.04 44.75,100.79 51.67,100.79 52.31,101.43 57.93,101.43 58.47,100.9 65.58,100.9 67.84,103.16 68.35,103.16 68.97,103.78 70.67,103.78 71.56,104.67 74.85,104.67 78.16,107.98 79.6,107.98 79.93,108.31 81.53,108.31 81.61,108.24 82.74,108.24 83.24,108.75 87.27,108.75 87.78,109.25 91.12,109.25 92.76,110.9 99.2,110.9 101.52,113.22 106.64,113.22 108.83,115.41 108.83,115.96 110,117.13 112.11,117.13 113.33,118.35 113.8,118.35 114.98,119.53 120.66,119.53 120.82,119.69 122.54,119.69 123.05,120.2 123.05,123.36 122.35,124.06 122.35,124.74 121.94,125.14 121.94,125.53 123.01,126.59 123.01,128.44 122.35,129.1
  BOTTOM w0.114: U6539.DC11 119.65,129.02 v1(119.65,129.12) ; v1(28.04,64.97) 28.64,64.97 29.26,64.35 U40.3
USBP1-_CR: length 176.6
  IN3 w0.089: v1(120.24,129.12) 120.15,129.12 119.98,129.28 119.98,129.44 120.06,129.51 121.08,129.51 121.11,129.49 121.66,129.49 122.16,128.99 122.16,128.94 122.17,128.93
  IN3 w0.114: 122.17,128.93 122.77,128.34 122.77,126.69 121.7,125.63 121.7,125.04 122.11,124.64 122.11,123.96 122.8,123.26 122.8,120.3 122.44,119.94 120.72,119.94 120.56,119.77 114.88,119.77 113.7,118.59 113.23,118.59 112.01,117.37 109.9,117.37 108.59,116.06 108.59,115.51 106.54,113.46 101.42,113.46 99.1,111.14 92.66,111.14 91.02,109.5 87.68,109.5 87.17,108.99 83.14,108.99 82.64,108.48 81.71,108.48 81.63,108.56 79.83,108.56 79.5,108.23 78.06,108.23 74.75,104.91 71.46,104.91 70.57,104.02 68.87,104.02 68.24,103.4 67.74,103.4 65.48,101.14 58.57,101.14 58.03,101.67 52.21,101.67 51.57,101.03 44.85,101.03 44.6,101.28 42.67,101.28 42.42,101.03 37.85,101.03 36.83,102.05 33.57,102.05 31.99,103.64 28.77,103.64 28.39,103.26 27.5,103.26 26.41,102.17 26.41,96.78 23.71,94.08 23.71,92.77 22.99,92.06 22.99,89.07 22.59,88.67 22.59,86.66 22.12,86.19 22.12,80.09 21.27,79.24 21.27,78.86 20.76,78.35 20.76,73.84 21.89,72.71 21.89,70.14 22.92,69.11 22.92,63.55 23.17,63.3 23.17,62.03 23.57,61.63 23.95,61.63 24.38,61.2 24.38,60.52 24.93,59.98 26.82,59.98 27.78,60.95 27.78,64.28 27.86,64.36 v1(28.01,64.36)
  BOTTOM w0.102: U6539.DC9 119.97,128.63 120.15,128.63 120.31,128.79 120.31,129.04 v1(120.24,129.12)
  BOTTOM w0.114: v1(28.01,64.36) 28.21,64.36 28.29,64.44 28.29,64.66 28.37,64.74 28.55,64.74 29.03,64.25 29.03,64.09 28.98,64.03 28.84,64.03 28.76,63.95 U40.2
USBP2+_TPC: length 193.9
  IN1 w0.089: v1(11.86,48.68) 11.86,48.69 12.57,48.69 12.8,48.92 12.8,53.31 12.16,53.95 12.16,59.77 12.44,60.04 13.71,60.04 14.69,61.02 14.69,64.12 13.81,65 13.81,67.64 14.65,68.48 14.65,70.84 19.02,75.21 19.02,80.16 19.6,80.74 19.6,84.48 21.08,85.95 22.09,85.95 22.93,86.79 22.93,88.57 23.26,88.9 23.26,91.49 22.78,91.97 22.01,91.97 21.32,92.67 21.32,99.28 23.06,101.01 25.34,101.01 25.82,101.5 28.7,101.5 30.78,99.41 37.66,99.41 38.15,99.89 47.11,99.89 47.29,99.72 62.91,99.72 64.21,101.02 65.07,101.02 67.66,103.6 67.66,104.32 69.31,105.97 69.31,106.45 73.81,110.94 76.75,110.94 77.01,111.2 77.69,111.2 78.79,112.29 82.72,112.29 85.51,115.08 90.46,115.08 91.18,115.8 93.64,115.8 96.23,118.39 99.77,118.39 100.96,117.19 108.48,117.19 109.09,117.8 119.91,117.8 120.62,118.51 120.62,118.9 121.38,119.66 121.38,120.85 121.84,121.31 122.29,121.31 124.18,123.19 124.18,127.58 124.63,128.04 127.45,128.04 127.68,128.27 v1(127.68,128.93)
  BOTTOM w0.089: U6539.DA5 121.96,129.39 122.4,129.83 122.7,129.83 122.89,129.75 123.06,129.75 123.16,129.8 125.79,129.8 125.9,129.69 127.31,129.69 127.55,129.46 127.55,129.06 v1(127.68,128.93)
  BOTTOM w0.114: U6555.23 11.98,48.81 v1(11.86,48.68)
USBP2+_TPC_BOT: length 23.5
  IN1 w0.089: v1(12.11,50.72) 12.12,50.71 arc(12.19,50.54) 12.12,50.37 arc(11.98,50.31) 11.83,50.36 11.76,50.42 arc(11.66,50.47) 11.56,50.49 arc(11.39,50.53) 11.24,50.62 9.6,52.26 arc(9.58,52.3) 9.57,52.34 9.57,61.12 arc(9.58,61.16) 9.6,61.2 9.79,61.38 arc(9.85,61.48) 9.88,61.59 9.88,62.82 arc(9.85,62.93) 9.79,63.02 arc(9.63,63.27) 9.57,63.55 arc(9.66,64) 9.91,64.37 10.43,64.89 arc(10.49,64.98) 10.51,65.09 10.51,66.71 arc(10.56,66.83) 10.68,66.87 10.74,66.87 arc(10.81,66.86) 10.87,66.82 11.08,66.61 arc(11.09,66.59) v1(11.09,66.57)
  BOTTOM w0.114: v1(12.11,50.72) 12.11,50.67 arc(12.22,50.41) 12.47,50.31 U6555.26 ; CN10.A6 9.36,66.54 arc(9.41,66.56) 9.46,66.59 9.55,66.68 arc(9.6,66.71) 9.65,66.72 10.19,66.72 arc(10.34,66.69) D13144.1 11,66.61 arc(11.05,66.6) v1(11.09,66.57)
USBP2+_TPC_TOP: length 25.8
  TOP w0.114: v5(7.92,66.93) 8.04,66.8 arc(8.09,66.77) 8.15,66.76 8.56,66.76 arc(8.61,66.77) 8.66,66.8 8.78,66.92 arc(8.83,66.95) 8.88,66.96 D13142.1 arc(9.02,66.95) 9.09,66.9 9.19,66.8 arc(9.31,66.75) 9.44,66.78 arc(9.63,66.88) 9.83,66.91 10.22,66.91 arc(10.52,66.79) 10.64,66.49 10.64,66.19 arc(10.67,66.1) 10.76,66.06 12.02,66.06 arc(12.18,66.09) 12.3,66.18 v1(12.42,66.29)
  IN1 w0.089: v1(12.42,66.29) 12.69,66.02 arc(12.72,65.99) 12.77,65.99 12.91,65.99 arc(13.1,65.91) 13.18,65.72 13.18,64.88 arc(13.19,64.81) 13.24,64.74 13.92,64.06 arc(13.98,63.97) 14,63.85 14,61.46 arc(13.98,61.35) 13.92,61.25 13.38,60.71 arc(13.28,60.65) 13.17,60.63 12.05,60.63 arc(12.01,60.62) 11.97,60.59 11.51,60.13 arc(11.48,60.09) 11.48,60.05 11.48,53.66 arc(11.45,53.55) 11.39,53.45 11.26,53.32 arc(11.23,53.28) 11.22,53.24 11.22,52.01 arc(11.23,51.97) 11.26,51.93 11.32,51.87 arc(11.35,51.85) 11.4,51.84 11.87,51.84 arc(12,51.86) v1(12.11,51.94)
  BOTTOM w0.114: CN10.B6 7.6,66.79 arc(7.78,66.83) v5(7.92,66.93) ; U6555.28 12.83,51.31 arc(12.77,51.32) 12.72,51.35 12.14,51.94 v1(12.11,51.94)
USBP2-_TPC: length 193.8
  IN1 w0.089: v1(11.86,49.3) 11.86,49.21 12.21,48.86 12.49,48.86 12.62,48.99 12.62,53.24 11.98,53.87 11.98,59.84 12.36,60.22 13.63,60.22 14.51,61.1 14.51,64.05 13.63,64.92 13.63,67.71 14.47,68.55 14.47,70.91 18.84,75.28 18.84,80.23 19.43,80.82 19.43,84.55 21,86.13 22.02,86.13 22.76,86.87 22.76,88.64 23.08,88.97 23.08,91.41 22.71,91.79 21.94,91.79 21.14,92.59 21.14,99.35 22.98,101.19 25.27,101.19 25.75,101.67 28.77,101.67 30.85,99.59 37.59,99.59 38.07,100.07 47.19,100.07 47.36,99.89 62.84,99.89 64.13,101.19 65,101.19 67.48,103.68 67.48,104.39 69.13,106.04 69.13,106.52 73.73,111.12 76.68,111.12 76.93,111.38 77.62,111.38 78.71,112.47 82.65,112.47 85.44,115.26 90.39,115.26 91.1,115.97 93.57,115.97 96.16,118.56 99.84,118.56 101.03,117.37 108.4,117.37 109.01,117.98 119.83,117.98 120.44,118.59 120.44,118.97 121.2,119.73 121.2,120.93 121.76,121.48 122.22,121.48 124,123.26 124,127.65 124.56,128.22 127.38,128.22 127.5,128.34 127.5,128.58 127.15,128.93 v1(127.07,128.93)
  BOTTOM w0.089: U6539.DA4 122.47,129.37 122.39,129.45 122.39,129.57 122.48,129.66 122.66,129.66 122.86,129.58 123.09,129.58 123.2,129.62 125.72,129.62 125.83,129.51 127.24,129.51 127.37,129.38 127.37,129.11 127.18,128.93 v1(127.07,128.93)
  BOTTOM w0.114: U6555.24 12.88,49.31 12.61,49.04 12.12,49.04 v1(11.86,49.3)
USBP2-_TPC_BOT: length 23.5
  IN1 w0.089: v1(11.09,67.18) 11.03,67.12 arc(10.96,67.07) 10.88,67.05 10.68,67.05 arc(10.43,66.95) 10.33,66.71 10.33,65.09 arc(10.32,65.05) 10.3,65.01 9.79,64.5 arc(9.5,64.06) 9.39,63.55 arc(9.46,63.2) 9.66,62.9 arc(9.69,62.86) 9.7,62.82 9.7,61.59 arc(9.69,61.54) 9.66,61.51 9.48,61.32 arc(9.42,61.23) 9.39,61.12 9.39,52.34 arc(9.42,52.23) 9.48,52.14 11.12,50.5 arc(11.32,50.36) 11.56,50.31 arc(11.6,50.31) 11.64,50.28 12.03,49.96 arc(12.07,49.94) v1(12.11,49.93)
  BOTTOM w0.114: U6555.25 13.15,49.81 arc(12.91,49.86) 12.72,49.99 arc(12.61,50.06) 12.49,50.08 12.39,50.08 arc(12.27,50.06) 12.17,49.99 v1(12.11,49.93) ; CN10.A7 9.35,67.04 arc(9.41,67.03) 9.46,67 arc(9.52,66.96) 9.59,66.95 9.93,66.95 arc(10.22,67) D13145.1 11.06,67.17 arc(11.08,67.17) v1(11.09,67.18)
USBP2-_TPC_TOP: length 25.8
  TOP w0.114: v5(7.92,66.39) 7.92,66.4 8,66.49 arc(8.05,66.52) 8.11,66.53 8.53,66.53 arc(8.59,66.52) 8.64,66.49 8.75,66.37 arc(8.8,66.34) 8.86,66.33 D13143.1 arc(9.07,66.35) 9.17,66.43 9.23,66.48 arc(9.27,66.51) 9.32,66.52 arc(9.45,66.54) 9.58,66.6 arc(9.7,66.66) 9.83,66.68 10.22,66.68 arc(10.35,66.63) 10.41,66.49 10.41,66.19 arc(10.51,65.94) 10.76,65.83 12.06,65.83 arc(12.25,65.8) 12.41,65.69 v1(12.42,65.68)
  IN1 w0.089: v1(12.42,65.68) 12.51,65.77 arc(12.55,65.8) 12.59,65.81 12.91,65.81 arc(12.97,65.78) 13,65.72 13,64.88 arc(13.03,64.74) 13.11,64.62 13.79,63.94 arc(13.82,63.9) 13.82,63.85 13.82,61.46 arc(13.82,61.42) 13.79,61.38 13.25,60.84 arc(13.21,60.81) 13.17,60.8 12.05,60.8 arc(11.94,60.78) 11.85,60.72 11.38,60.25 arc(11.32,60.16) 11.3,60.05 11.3,53.66 arc(11.29,53.62) 11.26,53.58 11.13,53.44 arc(11.07,53.35) 11.04,53.24 11.04,52.01 arc(11.07,51.9) 11.13,51.81 11.19,51.75 arc(11.28,51.68) 11.4,51.66 11.79,51.66 arc(11.85,51.65) 11.91,51.61 12.06,51.46 arc(12.1,51.4) v1(12.11,51.33)
  BOTTOM w0.114: U6555.27 13.11,50.81 arc(12.96,50.84) 12.83,50.93 12.38,51.37 arc(12.33,51.41) 12.27,51.42 arc(12.21,51.41) 12.15,51.37 v1(12.11,51.33) ; CN10.B7 7.69,66.3 arc(7.81,66.32) v5(7.92,66.39)
USBP3+_LTE: length 120.4
  IN4 w0.089: v1(126.66,127.53) 126.87,127.33 126.87,126.95 127.5,126.31 127.5,122.63 134.54,115.59 134.54,112.78 138.38,108.94 143.73,108.94 144.11,109.32 148.56,109.32 148.76,109.12 148.76,108.86 149.91,107.72 167.43,107.72 168.07,108.35 173.96,108.35 179.08,113.48 183.69,114.74 191.08,114.74 194.7,114.37 196.98,114.37 201.07,112.87 209.16,112.87 214.88,118.59 219.96,118.59 220.28,118.91 220.28,119.25 v2(220.52,119.49)
  BOTTOM w0.089: U6539.DB4 122.47,128.81 122.78,128.5 123.06,128.5 123.08,128.52 124.15,128.52 124.36,128.32 125.37,128.32 125.58,128.11 126.72,128.11 126.89,127.94 126.89,127.76 v1(126.66,127.53)
  BOTTOM w0.114: v2(220.52,119.49) 220.52,119.14 220.91,118.75 CN49.19
USBP3-_LTE: length 120.3
  IN4 w0.089: v1(127.3,127.53) 127.05,127.28 127.05,127.02 127.68,126.39 127.68,122.7 134.72,115.67 134.72,112.85 138.45,109.12 143.66,109.12 144.04,109.5 148.64,109.5 148.94,109.19 148.94,108.93 149.98,107.9 167.36,107.9 167.99,108.53 173.89,108.53 178.99,113.64 183.67,114.92 191.09,114.92 194.71,114.55 197.01,114.55 201.1,113.05 209.09,113.05 214.81,118.77 219.88,118.77 220.1,118.98 220.1,119.39 220,119.49 v2(219.76,119.49)
  BOTTOM w0.089: U6539.DB3 123.05,128.7 124.23,128.7 124.43,128.5 125.45,128.5 125.65,128.29 126.79,128.29 127.07,128.01 127.07,127.76 v1(127.3,127.53)
  BOTTOM w0.114: CN49.20 221.95,118.25 221.68,118.52 220.81,118.52 219.85,119.49 v2(219.76,119.49)
USBP4+: length 146.2
  TOP w0.114: v2(22.14,86.92) 21.93,87.13 21.71,87.13 21.39,87.44 21.39,87.89 21.23,88.06 21.01,88.06 20.88,87.93 R25518.2
  IN1 w0.089: v2(22.14,86.92) 21.79,87.27 21.25,87.27 19.35,85.37 18.21,85.37 17.78,85.8 17.78,87.98 18.08,88.29 18.08,92.22 17.6,92.71 17.6,98.72 22.27,103.4 23.67,103.4 25.32,105.05 32.05,105.05 33.72,103.37 44.01,103.37 45.13,102.26 47.72,102.26 48.15,101.83 51.61,101.83 51.94,102.16 58.95,102.16 59.18,101.93 62.2,101.93 63.37,103.1 64.16,103.1 64.64,103.58 64.64,104.24 66.34,105.94 66.34,106.42 73.4,113.48 76.75,113.48 77.6,114.34 79.36,114.34 79.72,114.7 81.45,114.7 82.39,115.64 83.11,115.64 84.59,117.12 89.21,117.12 90.02,117.93 92.83,117.93 95.4,120.49 100.73,120.49 100.93,120.29 101.78,120.29 102.41,120.93 106.42,120.93 106.77,120.57 109.82,120.57 110.69,121.43 114.85,121.43 116.4,119.88 117.45,119.88 117.93,120.36 117.93,120.82 120.32,123.21 120.32,128.42 120.82,128.93 120.82,129.1 120.82,129.1 v1(120.82,129.13)
  BOTTOM w0.114: U6539.DC8 120.82,128.89 v1(120.82,129.13)
USBP4+_R: length 6.1
  TOP w0.114: R25518.1 20.1,87.79 19.84,88.06 19.2,88.06 18.96,88.3 18.71,88.3 D13162.1 18.3,88.36 16.86,88.36 16.2,89.02 15.76,89.02 15.6,88.86 CN2.3
USBP4-: length 146.1
  TOP w0.114: v2(22.14,87.63) 22.14,87.53 21.98,87.36 21.8,87.36 21.62,87.54 21.62,87.99 21.32,88.29 21.01,88.29 20.88,88.41 R25517.2
  IN1 w0.089: v2(22.14,87.63) 21.97,87.45 21.18,87.45 19.28,85.54 18.28,85.54 17.95,85.87 17.95,87.91 18.26,88.21 18.26,92.3 17.78,92.78 17.78,98.65 22.35,103.22 23.74,103.22 25.4,104.87 31.97,104.87 33.65,103.2 43.94,103.2 45.05,102.08 47.65,102.08 48.08,101.65 51.68,101.65 52.01,101.98 58.87,101.98 59.1,101.75 62.27,101.75 63.44,102.92 64.23,102.92 64.82,103.5 64.82,104.16 66.52,105.86 66.52,106.35 73.48,113.31 76.82,113.31 77.68,114.16 79.43,114.16 79.79,114.53 81.53,114.53 82.47,115.47 83.18,115.47 84.66,116.94 89.28,116.94 90.09,117.75 92.91,117.75 95.47,120.32 100.66,120.32 100.86,120.11 101.85,120.11 102.48,120.75 106.34,120.75 106.7,120.39 109.9,120.39 110.76,121.26 114.78,121.26 116.33,119.71 117.52,119.71 118.11,120.29 118.11,120.75 120.5,123.14 120.5,128.35 120.82,128.67 120.98,128.67 v1(121.42,129.11)
  BOTTOM w0.114: U6539.DC7 121.24,128.99 121.37,129.11 v1(121.42,129.11)
USBP4-_R: length 6.1
  TOP w0.114: CN2.2 15.6,89.38 15.73,89.25 16.29,89.25 16.96,88.59 18.35,88.59 D13163.1 18.79,88.53 19.05,88.53 19.29,88.28 19.87,88.28 20.1,88.52 R25517.1
USBP5+_CAM: length 107.2
  IN4 w0.089: v1(118.28,130.03) 118.31,130.03 118.36,130.08 118.37,130.08 118.55,130.26 118.55,130.83 117.65,131.72 117.65,151.28 114.24,154.68 114.24,162.94 113.84,163.34 113.46,163.34 111.55,165.25 91.49,165.25 90.17,166.57 90.17,170.51 88.69,171.98 83.31,171.98 79.75,175.54 72.06,175.54 70.1,177.49 70.1,178.51 64.94,183.66 64.94,187.98 64.13,188.79 63.19,188.79 63.1,188.7 63.1,188.58 v2(63.39,188.29)
  BOTTOM w0.114: R25289.1 60.62,189.5 60.55,189.43 60.55,189.2 60.78,188.97 62.6,188.97 62.83,188.74 62.94,188.74 v2(63.39,188.29) ; v1(118.28,130.03) 118.28,129.94 U6539.DA12
USBP5+_CAM_C: length 3.2
  BOTTOM w0.114: R25289.2 60.6,190.68 60.6,190.88 60.79,191.07 D13111.2 60.79,191.37 60.62,191.54 60.62,191.92 60.15,192.39 CN29.8
USBP5-_CAM: length 107.2
  IN4 w0.089: v1(118.87,130.03) 118.85,130.03 118.72,130.16 118.72,130.9 117.83,131.8 117.83,151.35 114.42,154.76 114.42,163.01 113.91,163.52 113.53,163.52 111.63,165.43 91.56,165.43 90.34,166.65 90.34,170.58 88.77,172.16 83.38,172.16 79.82,175.71 72.13,175.71 70.28,177.57 70.28,178.58 65.12,183.74 65.12,188.06 64.21,188.97 63.12,188.97 62.92,188.78 62.92,188.58 v2(62.63,188.29)
  BOTTOM w0.114: U6539.DA11 118.87,130 v1(118.87,130.03) ; R25288.1 60.32,189.17 60.32,189.11 60.68,188.74 62.5,188.74 62.63,188.62 v2(62.63,188.29)
USBP5-_CAM_C: length 3.3
  BOTTOM w0.114: R25288.2 60.37,190.66 60.37,190.9 60.23,191.04 D13112.2 60.23,191.4 60.4,191.56 60.4,191.82 59.95,192.27 59.89,192.27 59.65,192.51 CN29.7
USBP6+_HUB: length 73.8
  TOP w0.114: R68565.1 79.93,107.85 79.66,107.58 79.66,107.22 80.08,106.8 80.79,106.8 81.15,106.44 81.15,105.33 v1(81.63,104.85)
  IN3 w0.114: v1(125.84,128.88) 125.65,128.68 125.65,128.48 125.84,128.29 128.28,128.29 128.62,127.95 128.62,127.11 127.81,126.3 127.81,121.43 128.3,120.94 128.3,119.94 126.42,118.05 126.42,117.63 124.67,115.88 120.61,115.88 120.13,115.41 119.11,115.41 117.28,113.57 114.7,113.57 113.91,112.79 111.12,112.79 109.08,110.74 109.08,110.23 108.69,109.85 105.68,109.85 104.06,108.23 101.23,108.23 99.97,106.97 98.41,106.97 97.84,106.4 97.84,106.07 96.86,105.09 95.17,105.09 94.32,105.94 87.26,105.94 86.89,105.57 85.02,105.57 84.81,105.36 81.57,105.36 81.44,105.24 81.44,105.04 v1(81.63,104.85)
  BOTTOM w0.089: U6539.DA1 123.98,129.31 124.25,129.31 124.38,129.44 125.17,129.44 125.34,129.27 125.45,129.27 v1(125.84,128.88)
USBP6+_HUB_R: length 1.9
  TOP w0.114: R68565.2 79.8,108.58 79.8,108.99 80.33,109.51 U6544.2
USBP6+_HUB_SM: length 152.3
  TOP w0.114: U6544.7 82.83,109.26 82.83,109.26 83.22,108.32 83.22,106.7 83.16,105.57 82.98,104.1 82.5,103.33 82.5,103.15 v1(82.75,102.89) ; v2(224.45,96.92) 224.45,96.74 224.33,96.61 223.78,96.61 223.65,96.74 R25560.1
  IN1 w0.089: v2(224.45,96.92) 223.95,96.63 213.28,95.98 204.77,95.98 201.01,96.16 182.8,96.16 170.36,97.02 170.36,97.02 163.3,97.25 163.3,97.25 162.06,97.25 152.5,98.01 148.38,98.83 147.11,98.83 142.74,99.54 140.33,99.54 140.23,99.44 137.64,99.44 137.39,99.51 137.03,99.51 135.11,99.23 132.63,99.23 121.46,100.33 119.81,100.33 114.28,99.44 111.21,99.44 102.58,99.82 100.24,99.82 97.12,99.67 96.09,99.67 91.6,99.96 87.65,100.79 82.58,102.32 82.47,102.47 82.47,102.61 v1(82.75,102.89)
USBP6+_HUB_SM_R: length 2
  TOP w0.114: R25560.2 222.52,96.67 222.25,96.67 222.03,96.88 U6509.9
USBP6+_HUB_TS: length 145.1
  TOP w0.114: U6544.4 81.33,109.5 81.07,109.24 81.07,108.99 v1(81.07,108.99)
  IN4 w0.089: v1(81.07,108.99) 80.94,108.87 80.94,108.48 80.74,108.28 80.36,108.28 80.18,108.1 78.18,108.1 76.65,106.58 76.25,106.58 75.69,106.02 68.07,106.02 64.56,102.51 60.24,102.51 59.74,103.02 55.17,103.02 54.46,103.73 50.77,103.73 49.45,105.05 46.27,105.05 45.79,105.53 45.79,122.3 45.13,122.96 43.48,122.96 42.97,123.47 42.97,157.76 43.61,158.39 43.61,159.16 42.96,159.8 42.96,170.82 46.15,174.01 56.66,174.01 59.94,177.29 59.94,182.34 61.01,183.41 61.01,186.79 61.24,187.02 61.57,187.02 v2(61.9,187.35)
  BOTTOM w0.114: R67414.1 58.33,189.5 58.2,189.37 58.2,188.87 58.33,188.74 59.74,188.74 60.4,188.08 60.85,188.08 61.23,187.7 61.23,187.25 61.39,187.09 61.67,187.09 61.9,187.32 v2(61.9,187.35)
USBP6+_HUB_TS_R: length 3.1
  BOTTOM w0.114: CN29.5 58.65,192.36 58.21,191.92 58.21,191.67 58.35,191.53 D13114.2 58.35,191.04 58.18,190.87 58.18,190.69 R67414.2
USBP6-_HUB: length 73.8
  TOP w0.114: v1(80.92,104.85) 80.92,106.35 80.69,106.58 79.99,106.58 79.43,107.13 79.43,107.58 79.17,107.85 R68564.1
  IN3 w0.114: v1(80.92,104.85) 81.2,105.13 81.2,105.34 81.47,105.61 84.71,105.61 84.92,105.81 86.79,105.81 87.16,106.18 94.42,106.18 95.27,105.33 96.76,105.33 97.59,106.17 97.59,106.5 98.31,107.21 99.87,107.21 101.13,108.47 103.96,108.47 105.58,110.09 108.59,110.09 108.83,110.33 108.83,110.84 111.02,113.03 113.81,113.03 114.6,113.81 117.18,113.81 119.01,115.65 120.03,115.65 120.51,116.13 124.57,116.13 126.18,117.73 126.18,118.15 128.06,120.04 128.06,120.84 127.57,121.33 127.57,126.4 128.38,127.21 128.38,127.85 128.18,128.05 125.74,128.05 125.41,128.38 125.41,128.72 v1(125.22,128.9)
  BOTTOM w0.089: v1(125.22,128.9) 125.22,129.13 125.1,129.26 124.45,129.26 124.33,129.13 123.67,129.13 123.43,129.37 U6539.DA2
USBP6-_HUB_R: length 1.9
  TOP w0.114: R68564.2 79.57,108.86 79.57,109.08 79.83,109.34 U6544.1
USBP6-_HUB_SM: length 152.3
  TOP w0.114: v1(82.05,102.89) 82.27,103.11 82.27,103.4 82.76,104.18 82.85,104.88 82.94,105.59 82.99,106.7 82.99,108.27 82.63,109.14 82.33,109.56 U6544.6 ; R25559.1 224,96.38 224.23,96.38 v2(224.45,96.16)
  IN1 w0.089: v2(224.45,96.16) 223.96,96.46 213.28,95.8 204.76,95.8 201.01,95.98 182.79,95.98 170.35,96.84 163.29,97.07 162.05,97.07 152.47,97.83 148.36,98.65 147.09,98.65 142.73,99.36 140.4,99.36 140.3,99.26 137.62,99.26 137.36,99.34 137.04,99.34 135.13,99.06 132.62,99.06 121.45,100.15 119.82,100.15 114.29,99.26 111.2,99.26 102.57,99.64 100.24,99.64 97.12,99.49 96.09,99.49 91.58,99.78 87.61,100.62 82.47,102.17 82.29,102.41 82.29,102.65 v1(82.05,102.89)
USBP6-_HUB_SM_R: length 2
  TOP w0.114: U6509.8 221.99,96.23 222.19,96.44 222.46,96.44 R25559.2
USBP6-_HUB_TS: length 145
  TOP w0.114: U6544.3 80.83,109.38 v1(80.43,108.99)
  IN4 w0.089: v2(61.9,186.46) 61.9,186.63 61.69,186.84 61.31,186.84 61.18,186.71 61.18,183.33 60.12,182.27 60.12,177.21 56.74,173.83 46.22,173.83 43.14,170.75 43.14,159.88 43.78,159.23 43.78,158.32 43.15,157.68 43.15,123.54 43.56,123.14 45.2,123.14 45.97,122.37 45.97,105.61 46.35,105.23 49.52,105.23 50.84,103.91 54.53,103.91 55.24,103.2 59.81,103.2 60.32,102.69 64.49,102.69 67.99,106.19 75.61,106.19 76.17,106.75 76.58,106.75 78.1,108.28 80.11,108.28 80.29,108.45 80.67,108.45 80.77,108.56 80.77,108.76 80.54,108.99 v1(80.43,108.99)
  BOTTOM w0.114: v2(61.9,186.46) 61.9,186.63 61.67,186.86 61.29,186.86 61.01,187.15 61.01,187.6 60.75,187.86 60.3,187.86 59.64,188.52 58.23,188.52 57.97,188.78 57.97,189.37 57.84,189.5 R67415.1
USBP6-_HUB_TS_R: length 3.1
  BOTTOM w0.114: CN29.4 58.15,192.18 57.98,192.01 57.98,191.82 57.79,191.63 D13113.2 57.79,191.07 57.95,190.91 57.95,190.52 57.71,190.28 R67415.2
USBP7+_FP: length 57.3
  IN3 w0.114: v1(125.39,127.53) 125.39,127.1 125.51,126.98 125.51,125.6 125.75,125.36 126,125.36 126.91,124.46 126.91,121.21 126.33,120.64 126.33,119.34 125.13,118.13 125.13,117.52 124.2,116.6 118.52,116.6 118.21,116.28 118.21,115.9 117.41,115.1 114.61,115.1 113.04,113.52 110.88,113.52 108.36,111.01 106.99,111.01 106.61,110.63 105.44,110.63 103.73,108.91 100.73,108.91 99.54,107.72 98.05,107.72 97.1,106.77 97.1,106.29 96.59,105.77 96.03,105.77 95.77,106.04 95.77,106.23 v1(95.55,106.45)
  BOTTOM w0.089: U6539.DD1 124.05,128.24 124.38,127.91 125.01,127.91 v1(125.39,127.53)
  BOTTOM w0.114: R67492.1 95.67,100.71 96.36,100.71 96.43,100.77 96.99,100.77 97.15,100.93 97.15,102.24 96.85,102.54 96.41,102.54 95.61,103.34 95.61,106.39 v1(95.55,106.45)
USBP7+_FP_P2: length 23.1
  BOTTOM w0.114: CN14.7 74.45,100.46 74.49,100.5 74.49,101.25 74.87,101.63 78.65,101.63 79.07,101.22 82.5,101.22 83.03,101.75 86.02,101.75 87.03,100.75 93.02,100.75 EC7.2 93.73,100.78 94.28,100.78 94.41,100.91 94.41,101.19 R67492.2
USBP7+_FP_P4: length 121.7
  TOP w0.114: v2(208.01,99.79) 207.79,99.57 207.79,99.41 EC16.2 208.15,98.58 208.01,98.45 207.48,98.45 207.37,98.33 207.37,97.79 207.5,97.66 207.59,97.66 v2(207.87,97.94)
  IN1 w0.089: v2(207.87,97.94) 207.56,97.63 207.01,97.63 206.04,96.67 203.7,96.67 203.57,96.8 196.26,96.8 195.69,97.36 193.39,97.36 193.13,97.1 183.63,97.1 183.25,97.48 178.17,97.48 177.96,97.7 177.96,97.8 177.54,98.22 168.04,98.22 167.82,98.43 162.11,98.43 161.92,98.62 153.03,98.62 152.09,99.56 147.16,99.56 146.55,100.17 139.98,100.17 139.82,100.02 138.04,100.02 137.89,100.17 135.58,100.17 135.25,99.84 133.14,99.84 132.38,100.61 128.31,100.61 127.68,101.24 121.33,101.24 121.05,101.52 119.2,101.52 118.54,100.86 114.96,100.86 114.12,100.02 111.63,100.02 110.66,100.99 108.88,100.99 108.12,101.75 104.06,101.75 103.3,100.99 96.95,100.99 v1(96.69,101.24)
  BOTTOM w0.114: CN52.7 207.85,100.27 207.78,100.2 207.78,100.02 v2(208.01,99.79) ; v1(96.69,101.24) 96.64,101.19 R67497.1
