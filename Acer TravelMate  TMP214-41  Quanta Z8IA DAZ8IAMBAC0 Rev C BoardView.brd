# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RT3612_PVCC: length 5.6
  TOP w0.178: PC7011.1 v2(157.62,147.82) 157.27,148.18 v2(157.27,148.89)
  TOP w0.508: PC7011.1 159.06,147.78 PR7008.1
  BOTTOM w0.178: PU7000.29 158.24,147.87 158.24,147.91 157.96,148.2 157.93,148.2 157.44,148.69 157.44,148.72 v2(157.27,148.89)
RT3612_RGND: length 41.9
  TOP w0.203: PR7057.1 142.95,153.66 v2(143.05,153.57)
  IN2 w0.203: v2(143.05,153.57) 143.05,149.88 143.43,149.5 143.43,146.96 144.32,146.07 144.32,140.48 144.57,140.23 150.16,140.23 151.37,139.02 154.67,139.02 156.38,137.31 158.92,137.31 160.12,138.5 160.12,139.52 161.86,141.26 161.86,142.17 v1(162.46,142.77)
  BOTTOM w0.178: PC7044.1 163.77,142.78 PC7043.2 162.5,142.78 162.49,142.77 v1(162.46,142.77) 162.4,142.77 162.28,142.9 162.28,143.27 PU7000.13
RT3612_SET1: length 5.8
  TOP w0.178: v2(166.16,145.54) 165.75,145.13 PR7018.2 PR7026.1
  BOTTOM w0.178: 162.37,146.29 162.78,146.71 163.24,146.71 163.83,146.12 164.82,146.12 v2(165.4,145.54) v2(166.16,145.54)
RT3612_SET2: length 5.1
  TOP w0.178: v2(165.02,146.63) 165.52,146.63 165.7,146.45 PR7019.2 166.11,146.05 PR7027.2
  BOTTOM w0.152: PU7000.7 162.57,147.06 163.65,147.06 v2(164.08,146.63) v2(165.02,146.63)
RT3612_SET3: length 6.1
  TOP w0.178: v2(165.09,147.84) 165.31,147.84 165.35,147.8 165.45,147.8 165.68,147.57 PR7020.2 166.21,147.24 PR7000.1
  BOTTOM w0.152: v2(165.09,147.84) 165.37,147.62 165.37,147.39 v2(165.22,147.24) 165.2,147.22 164.64,147.22 164.43,147.42 162.36,147.42 PU7000.6
RT3612_TSEN: length 13
  IN2 w0.178: v2(155.38,140.4) 155.38,140.5 155.95,141.07 155.95,143 v2(156.43,143.48)
  BOTTOM w0.178: PU7000.21 157.96,144.15 157.96,144.1 157.49,143.63 PR7025.1 156.58,143.63 v2(156.43,143.48) ; PR7022.1 149.56,139.47 150.03,139.47 150.16,139.34 151.3,139.34 v2(151.81,139.85) 152.32,139.34 154.08,139.34 155.11,140.37 155.33,140.37 155.35,140.4 v2(155.38,140.4)
RT3612_UG1: length 10
  IN4 w0.508: v2(153.97,141.5) 153.97,143.89 v2(156.92,146.84)
  BOTTOM w0.178: v2(156.92,146.84) 156.97,146.84 157.09,146.96 157.46,146.96 157.84,146.58
  BOTTOM w0.508: v2(153.97,141.5) v2(153.28,140.81) PR7009.1
RT3612_UG1_R: length 2.7
  BOTTOM w0.114: PR7009.2 150.7,140.14 v2(150.41,139.85)
  BOTTOM w0.508: PR7009.2 149.24,140.81 PQ7000.1
RT3612_UG2: length 19.8
  IN2 w0.508: v2(159.43,149.65) 159.43,149.76 155.57,153.62 155.57,162.79 157.05,164.27 v2(157.05,165.76)
  BOTTOM w0.508: PR7024.1 157.47,166.17 v2(157.05,165.76)
RT3612_UG2_R: length 2.2
  BOTTOM w0.508: PR7024.2 156.2,167.01 v2(156.2,166.06) 156.2,165.69 156.47,165.42 PQ7001.1
RT3612_VCC: length 5.1
  TOP w0.381: PC7002.1 162.83,144.8 v2(163.27,144.8)
  TOP w0.508: PR7002.1 v2(162.9,146.11) 163.27,145.74 v2(163.27,144.8)
  BOTTOM w0.178: v2(163.27,144.8) 162.46,144.8 162.44,144.81 PU7000.10
RT3612_VCLK: length 3
  BOTTOM w0.152: 163.9,148 163.61,148 v2(163.46,147.85) 163.33,147.72 162.1,147.72 PU7000.5
  BOTTOM w0.178: PR7043.2 163.9,148
RT3612_VDIO: length 3.5
  BOTTOM w0.152: 163.16,148.33 163.03,148.19 v2(162.22,148.19) 162.01,148.19 PU7000.4
  BOTTOM w0.178: 163.16,148.33 163.85,148.33 164.18,148.67 PR7046.2
RT3612_VIN: length 4.8
  TOP w0.178: v2(157.32,144.22) 157.75,144.22 PC7003.2
  TOP w0.381: v2(157.32,144.22) 157.12,144.22 v2(156.66,144.68) v2(156.66,145.44)
  BOTTOM w0.178: PU7000.22 157.68,144.43 157.66,144.43 157.45,144.22 v2(157.32,144.22)
  BOTTOM w0.381: v2(156.66,145.44) 156.27,145.44 PR7003.2
RT3612_VR_READY: length 2.7
  BOTTOM w0.178: PR7041.2 155.76,144.31 156.31,144.31 156.5,144.49 156.5,144.56 156.98,145.04 157.16,145.04 PU7000.24
RT3612_VRHOT: length 2.3
  BOTTOM w0.152: PU7000.2 161.12,148.44 161.12,148.88 v2(161.46,149.22) 162.03,149.22 PR7042.2
RT3612_VRON: length 28.3
  IN3 w0.102: v2(154.94,141.58) 155.38,141.58 157.98,138.97 157.98,138.46 158.6,137.84 159.83,137.84 161.71,139.72 162.47,139.72 164.59,141.84 164.59,148 165.55,148.96 v2(165.55,148.97)
  BOTTOM w0.178: 157.84,145.16 157.83,145.16 157.38,144.71 157.12,144.71 156.83,144.42 156.83,144.33 156.47,143.98 156.23,143.98 155.94,143.69 155.94,143.28 155.95,143.26 155.95,143.25 155.98,143.22 155.98,142.52 PC7038.2 155.65,142.19 PR7050.2 155.14,141.37 v2(154.94,141.58)
  BOTTOM w0.203: v2(165.55,148.97) 165.35,149.17 PR9289.1 165.65,149.43 165.65,149.43 165.74,149.43 165.86,149.31 165.87,149.31 166,149.18 166,149.16 166.1,149.07 PU9006.4
RT3612_VSEN: length 46.2
  TOP w0.203: v2(143.05,154.33) 142.95,154.23 PR7056.1
  IN2 w0.203: v1(162.45,142.03) 162.22,141.8 162.22,141.12 160.47,139.37 160.47,138.22 159.18,136.93 156.13,136.93 154.48,138.58 151.18,138.58 149.86,139.9 144.14,139.9 143.75,140.29 143.75,146.01 143.05,146.71 143.05,149.25 142.54,149.76 142.54,153.82 v2(143.05,154.33)
  BOTTOM w0.178: PR7055.2 PC7041.1 164.88,141.36 PC7039.1 163.74,142.14 163.61,142 PC7043.1 162.51,142 162.45,142.06 ; PU7000.14 161.82,143.17 v4(161.82,142.97) 161.82,142.69 162.45,142.06 ; 162.45,142.06 v1(162.45,142.03)
RT6543_BOOT:
  vias: v2(160.95,132.23)
RT6543_COMP: length 3.1
  BOTTOM w0.178: 165.27,133.5 165.26,133.51 PU7001.5
  BOTTOM w0.203: PC7067.1 167.1,133.55 166.96,133.41 PC7069.1 165.75,133.41 165.7,133.46 165.31,133.46 165.27,133.5
RT6543_CS_DSI: length 2.9
  BOTTOM w0.178: 165.17,135.38 164.9,135.11 PU7001.1
  BOTTOM w0.203: 165.17,135.38 165.6,135.81 v2(165.7,135.81) 165.86,135.96 166.33,135.96 PR7070.2
RT6543_EN: length 4.6
  BOTTOM w0.203: PU7001.19 163.39,136.44 163.57,136.62 163.57,136.88 163.98,137.28 PC7066.2 164.43,137.61 164.59,137.77 PR7078.2 165.22,138.03 PR7080.2 PR7082.2
RT6543_FB:
  vias: v2(165.65,132.61)
RT6543_FSWSEL: length 2.7
  BOTTOM w0.203: PR7089.2 PR7086.2 161.98,131.4 162.59,132.01 PU7001.9
RT6543_ISN: length 3.5
  BOTTOM w0.203: PR7079.2 167.29,135.05 167.16,134.92 165.76,134.92 165.15,134.31 PU7001.3
RT6543_ISP: length 2.3
  BOTTOM w0.203: PU7001.2 165.04,134.71 165.6,135.28 166.36,135.28 PR7079.1
RT6543_LG: length 10.6
  IN4 w0.508: v2(160.29,134.39) 154.75,134.39 v2(153.02,132.67)
  BOTTOM w0.203: v2(160.29,134.39) 160.37,134.31 PU7001.13
  BOTTOM w0.508: PQ7003.4 v2(153.02,132.67)
RT6543_PG: length 3.5
  BOTTOM w0.203: PU7001.4 165.34,133.91 165.44,133.82 166.11,133.82 166.19,133.9 166.69,133.9 166.9,134.11 PR7073.2 PR7074.2
RT6543_PH: length 13.4
  IN4 w0.508: v2(159.42,133.13) 155.21,133.13 v2(152.99,130.91)
  BOTTOM w0.203: PU7001.12 160.78,133.91 160.36,133.49
  BOTTOM w0.508: v2(159.42,133.13) 159.52,133.23 PC7053.1 160.1,133.23 160.36,133.49 ; PQ7003.5 151.03,128.95 v2(152.99,130.91)
  vias: v2(147.37,128.22) v2(147.37,127.56) v2(147.37,126.9) v2(148,127.78)
RT6543_RGND: length 51.2
  IN3 w0.102: v1(164.32,132.03) 163.25,130.96 161.97,130.96 160.45,132.48 158.8,132.48 156,135.28 154.86,135.28 152.83,137.31 152.83,138.96 v2(153.77,139.9)
  IN4 w0.089: v2(153.77,139.9) 153.77,139.98 153.37,140.37 144.32,140.37 141.9,142.79 141.9,147.47 139.26,150.11 131.22,150.11 v2(130.74,149.63)
  BOTTOM w0.114: PR7090.1 PR7091.1 130.2,150.17 v2(130.74,149.63)
  BOTTOM w0.203: PU7001.7 163.39,132.17 163.54,132.03 v1(164.32,132.03)
RT6543_UG: length 6.5
  IN4 w0.508: v2(155.74,131.8) 156.17,132.23 160.17,132.23 v2(160.9,132.97)
  BOTTOM w0.508: PR7071.1 155.64,131.9 v2(155.74,131.8)
RT6543_VCC:
  vias: v2(160.45,136.04)
RT6543_VID0: length 1.1
  BOTTOM w0.203: PR7077.2 163.11,136.67 162.99,136.55 PU7001.18
RT6543_VID1: length 1.2
  BOTTOM w0.203: PU7001.17 162.59,136.44 162.38,136.65 PR7076.2
RT6543_VOUT: length 1.5
  BOTTOM w0.203: PU7001.8 162.99,131.94 163.04,131.89 PR7081.2
RT6543_VSYS: length 12.8
  TOP w0.254: v2(164.13,136.65) 163.27,135.79 v2(161.84,135.79) 160.45,135.79 160.07,136.17 157.91,136.17 156.13,137.94 v2(156.13,138.33)
  BOTTOM w0.178: PU7001.20 163.79,136.31 v2(164.13,136.65)
  BOTTOM w0.203: PC7045.2 164.28,136.8 v2(164.13,136.65)
  BOTTOM w0.254: PR7066.1 156.74,138.1 156.51,138.33 v2(156.13,138.33)
RT_I2C_INT: length 30.7
  TOP w0.079: 18.47,60.52 18.59,60.63 18.59,60.68 19.03,61.12 U6549.A10
  TOP w0.114: v1(18.43,60.47) 18.47,60.52
  IN2 w0.102: v2(8.89,42.19) 10.08,43.38 10.08,46 10.71,46.63 11.22,46.63 17.62,53.03 17.62,56.08 18.16,56.61 18.16,58.77 18.43,59.05 v1(18.43,60.47)
  BOTTOM w0.114: v1(18.43,60.47) 17.95,60 R68897.1 ; v2(8.89,42.19) 9.2,41.87 v2(11.49,41.87) 11.92,41.87 12.08,41.71 R68982.2 13.23,41.71 13.47,41.47 Q6629.1
RT_I2C_INT_C: length 23.5
  IN1 w0.089: v1(12.67,54.17) 12.67,54.12 13.63,53.16 13.63,46.12 15.16,44.6 15.16,43.3 v2(14.78,42.92)
  BOTTOM w0.114: v2(14.78,42.92) 14.67,42.81 R68974.1 13.81,42.39 13.97,42.24 Q6629.3 13.68,41.76 13.28,42.16 R68982.1 R68984.2 ; R68885.1 13.76,56.66 13.46,56.36 R68970.2 13.14,55.66 12.95,55.47 12.95,54.71 12.67,54.43 v1(12.67,54.17) 12.67,53.29 12.59,53.21 12.59,52.19 12.98,51.81 U6555.29
RT_I2C_SCL: length 28.6
  TOP w0.079: U6549.C9 v5(18.99,62.23)
  IN2 w0.102: v5(18.99,62.23) 18.99,58.93 19.6,58.32 19.6,56.66 18.13,55.19 18.13,52.85 11.35,46.07 11.35,44.98 11.22,44.85 10.94,44.85 10.84,44.95 v2(10.84,45.87)
  BOTTOM w0.114: Q6623.1 9.5,45.29 9.82,45.62 10.59,45.62 v2(10.84,45.87) 10.84,45.77 11.22,45.39 R68888.2 ; v5(18.99,62.23) 18.99,59.99 18.71,59.71 R68895.1
RT_I2C_SDA: length 30.1
  TOP w0.079: U6549.E7 19.71,62.95 v5(19.71,62.23)
  IN2 w0.102: v5(19.71,62.23) 19.35,61.87 19.35,59.2 19.98,58.57 19.98,56.41 18.59,55.01 18.59,52.8 11.7,45.91 11.7,44.83 11.25,44.37 11.25,43.61 v1(10.84,43.2)
  BOTTOM w0.114: Q6621.1 9.5,42.87 9.83,43.2 v1(10.84,43.2) 11,43.36 R68887.2 ; R68896.1 19.48,59.59 19.38,59.69 19.38,61.9 v5(19.71,62.23)
RT_PWR_EN+RESET: length 5.4
  BOTTOM w0.114: R68971.2 30.41,42.68 30.37,42.72 D13160.1 28.91,43.45 28.65,43.71 R68976.1 28.65,44.53 R68968.1 28.29,44.63 28.01,44.35 U6564.2
RT_PWR_EN_P1: length 46.3
  TOP w0.114: U6550.C2 31.95,63.78 R68634.1 31.95,62.22 v2(32.43,61.74) v2(33.95,61.74)
  IN1 w0.089: v2(29.26,42.95) 29.76,42.44 29.76,39.27 31.54,37.49 31.54,35.84 33.38,33.99 34.02,33.99 34.51,34.49 34.51,58.44 34.72,58.65 34.72,60.98 v2(33.95,61.74)
  BOTTOM w0.114: R68972.2 28.38,42.57 R68719.2 28.63,42.32 v2(29.26,42.95)
RT_RESET_P1: length 56.7
  TOP w0.114: Q6612.3 v2(16.17,73.94) 15.03,72.79 15.03,72.29 15.67,71.65 R68630.2 16.58,71.19 v1(16.89,70.89)
  IN1 w0.089: v2(28.24,40.92) 28.24,42.44 26.72,43.96 21.94,43.96 20.06,42.08 16.91,42.08 15.95,43.05 15.95,45.97 15.16,46.76 15.16,52.85 13.76,54.25 v1(13.28,54.25)
  IN2 w0.102: v1(13.28,54.25) 14.14,54.25 16.68,56.79 16.68,58.82 16.94,59.08 16.94,66.67 15.67,67.94 15.67,69.67 v1(16.89,70.89)
  BOTTOM w0.114: R68969.2 29.39,40.4 28.88,40.92 v2(28.24,40.92) ; v1(13.28,54.25) 13.46,54.43 R68970.1
RTC_RST#: length 49
  TOP w0.089: v1(107.2,124.41) 106.84,124.05 106.84,122.44 106.47,122.07 106.34,122.07
  TOP w0.114: 106.34,122.07 105.86,121.59 105.86,119 104.49,117.62 100.66,117.62 99.69,118.59 96.03,118.59 93.39,115.95 93.39,111.88 v1(93.64,111.63) ; v1(82.21,108.98) 82.21,108.46 v2(82.47,108.2) 82.47,106.65 82.21,106.4 J9007.1 81.78,106.31 81.66,106.18 81.66,105.48 82.09,105.05 82.09,104.67 81.18,103.76 C1217.1 79.73,103.76 79.6,103.63 Q22.3 79.6,102.58 79.83,102.36 79.83,101.65 79.65,101.47 R979.2
  IN3 w0.102: v1(93.64,111.63) 92.35,111.63 90.85,110.13 83.36,110.13 v1(82.21,108.98)
  BOTTOM w0.102: v1(107.2,124.41) 107.33,124.41 U6539.DN37
RTC_X1: length 6.7
  BOTTOM w0.079: 102.15,120.38 102.15,120.55 102.59,120.98 102.59,122.25 102.71,122.37 102.71,122.95 U6539.DR47
  BOTTOM w0.102: 102.15,120.38 102.15,119.35 102.41,119.1 102.41,118.44 102.53,118.31 R68434.1 102.74,118.07 102.92,117.89 102.92,117.75 102.84,117.67 R68433.1
RTC_X1_R: length 3.3
  BOTTOM w0.114: R68433.2 102.53,117.07 102.76,116.84 C96709.2 102.76,116.38 102.92,116.23 102.92,115.59 103.04,115.47 103.3,115.47 103.39,115.37 Y5.1
RTC_X2: length 5.6
  BOTTOM w0.079: 103.19,118.59 103.19,118.58 ; U6539.DT47 103.02,122.43 102.75,122.16 102.75,120.89 102.41,120.55 102.41,120.17
  BOTTOM w0.102: 102.41,120.17 102.41,119.38 103.19,118.59 ; R68438.1 103.42,117.88 103.19,118.11 R68434.2 103.19,118.58
RTC_X2_R: length 2.2
  BOTTOM w0.114: R68438.2 103.42,117.07 103.6,116.89 103.6,116.18 103.65,116.13 C96710.2 R68435.1
S5_ON: length 350.7
  TOP w0.114: v2(197.28,116.35) 197.78,116.86 197.78,124.86 198.55,125.63 v2(198.55,126.39) 198.83,126.67 PR6015.1 ; PU9005.1 32.57,141.87 32.05,142.39 32.05,143.02 v2(31.54,143.53) ; v1(172.23,120.29) 172.25,120.28 172.25,119.93 172.26,119.91 172.26,118.74 170.92,117.4 170.92,115.69 172.03,114.58 172.03,114.35 171.62,113.94 170.48,113.94 170.28,114.14 168.37,114.14 167.18,112.95 R25309.1 166.7,112.95 166.49,112.75 165.78,112.75 165.46,112.43 165.06,112.43 164.66,112.03 U37.100 ; PR6027.1 37.28,168.78 v2(37.32,168.81) ; PR566.2 38.88,140.33 v2(39.05,140.5)
  IN3 w0.102: v2(111.7,96.03) 113.23,94.51 116.76,94.51 117.77,95.53 120.75,95.53 121.48,96.26 122.6,96.26 122.85,96.01 142.64,96.01 143.58,96.95 147.34,96.95 149.02,95.27 151.3,95.27 151.38,95.35 152.93,95.35 153.64,94.64 197.12,94.64 197.78,95.3 201.24,95.3 201.72,95.78 204.9,95.78 206.26,97.14 206.26,100.06 206.8,100.61 208.07,100.61 209.47,102 209.47,108.48 209.01,108.94 209.01,110.84 207.56,112.29 204.52,112.29 200.45,116.35 v2(197.28,116.35) 196.46,117.17 193.42,117.17 192.25,118.34 178.79,118.34 176.04,121.08 172.46,121.08 172.23,120.85 v1(172.23,120.29)
  IN4 w0.089: v2(111.7,96.03) 111.7,95.4 111.58,95.27 108.88,95.27 108.53,95.63 101.29,95.63 99.87,97.05 99.36,97.05 97.45,98.96 95.04,98.96 94.41,99.59 82.21,99.59 81.96,99.34 78.28,99.34 76.25,97.3 73.96,97.3 73.45,96.8 72.18,96.8 70.58,95.2 57.83,95.2 57.37,95.65 53.28,95.65 49.22,99.72 47.8,99.72 47.29,100.23 45.13,100.23 44.37,100.99 42.72,100.99 42.59,100.86 40.18,100.86 37.89,103.15 37.89,113.05 36.75,114.2 36.75,118.59 34.46,120.88 34.46,126.26 33.13,127.59 33,127.59 31.8,128.8 31.8,129.82 32.64,130.66 32.64,140.41 31.54,141.5 v2(31.54,143.53) 33.45,145.44 33.45,155.99 33.83,156.37 33.83,160.75 35.54,162.46 35.54,164.92 37.64,167.02 37.64,168.49 v2(37.32,168.81)
  BOTTOM w0.114: v2(39.05,140.5) 38.04,141.5 37.64,141.5 34.84,144.29 32.3,144.29 v2(31.54,143.53)
SATA_LED#: length 7.5
  BOTTOM w0.102: U6539.DV11 119.54,121.5 119.54,120.8 119.58,120.76 119.58,120.06 120.15,119.49 120.15,118.73 119.98,118.56 119.98,117.67 120.72,116.94 120.72,116.86
  BOTTOM w0.114: 120.72,116.86 120.87,116.71 120.87,116.28 120.44,115.85 120.44,115.47 120.29,115.31 R68355.2
SATA_RXN0_CN: length 10.1
  TOP w0.114: C6596.1 229.46,111.49 229.25,111.28 229.25,110.8 232.51,107.54 232.51,105.26 v2(232.77,104.99)
  BOTTOM w0.114: CN11.16 232.64,103.98 232.5,104.11 232.5,104.73 v2(232.77,104.99)
SATA_RXN0_HDD: length 148.2
  TOP w0.114: v2(227.76,120.67) 227.58,120.67 227.45,120.55 227.45,120.2 227.62,120.04 227.94,120.04 228.2,120.29 228.97,120.29 229.28,119.98 229.28,119.75 229.41,119.63 C6588.2
  IN1 w0.089: v2(227.76,120.67) 227.58,120.67 227.32,120.41 227.32,120.14 227.09,119.91 226.36,119.91 226.2,120.07 224.99,120.07 223.69,118.77 220.77,118.77 220.21,118.21 216.28,118.21 211.45,113.38 201.9,113.38 200.76,114.53 198.62,114.53 198.24,114.14 196.72,114.14 195.67,113.1 193.13,113.1 192.7,112.67 188.89,112.67 188.26,113.31 186.23,113.31 184.33,115.21 179.7,115.21 177.13,112.65 174.52,112.65 173.86,113.31 172.31,113.31 172.03,113.03 168.68,113.03 168.04,112.39 166.72,112.39 166.47,112.14 160.68,112.14 160.03,111.49 153.35,111.49 152.04,112.8 148.89,112.8 148.03,111.93 139.49,111.93 139.11,112.32 138.32,112.32 136.19,114.45 136.19,116.22 136.82,116.86 136.82,118.89 137.54,119.61 137.54,121.26 138.76,122.48 138.76,136.4 137.84,137.31 137.34,137.31 136.57,138.07 136.57,138.45 135.83,139.19 131.84,139.19 131.39,138.73 130.07,138.73 129.78,139.02 129.78,139.38 v1(129.32,139.84)
  BOTTOM w0.089: U6539.CF3 123.17,136.23 123.28,136.34 123.91,136.34 124.39,136.81 125.53,136.81 126.28,137.56 127.38,137.56 127.4,137.59 127.43,137.59
  BOTTOM w0.114: v1(129.32,139.84) 129.59,139.57 129.59,139.21 128.98,138.6 128.98,138.02 128.54,137.59 127.43,137.59
SATA_RXN0_IN: length 1.8
  TOP w0.114: C6588.1 229.44,119.18 229.27,119.01 229.27,118.4 229.42,118.25 U42.4
SATA_RXN_OUT: length 2.1
  TOP w0.114: C6596.2 229.47,111.94 229.28,112.13 229.28,113.05 229.42,113.19 U42.12
SATA_RXP0_CN: length 10.1
  TOP w0.114: v2(232.01,104.99) 232.28,105.27 232.28,107.45 229.02,110.7 229.02,111.3 228.82,111.49 C6597.1
  BOTTOM w0.114: v2(232.01,104.99) 232.28,104.72 232.28,104.09 232.14,103.95 CN11.15
SATA_RXP0_HDD: length 148.2
  TOP w0.114: C6589.2 228.9,119.63 229.03,119.75 229.03,119.91 228.87,120.06 228.29,120.06 228.04,119.81 227.52,119.81 227.22,120.11 227.22,120.44 v2(226.99,120.67)
  IN1 w0.089: v1(129.95,139.84) 129.95,139.1 130.14,138.91 131.31,138.91 131.77,139.37 135.91,139.37 136.75,138.53 136.75,138.15 137.41,137.49 137.92,137.49 138.93,136.47 138.93,122.4 137.71,121.18 137.71,119.53 137,118.82 137,116.79 136.37,116.15 136.37,114.52 138.4,112.49 139.18,112.49 139.57,112.11 147.95,112.11 148.82,112.98 152.12,112.98 153.42,111.67 159.95,111.67 160.6,112.32 166.39,112.32 166.65,112.57 167.97,112.57 168.6,113.2 171.96,113.2 172.24,113.48 173.93,113.48 174.6,112.82 177.06,112.82 179.62,115.39 184.4,115.39 186.3,113.48 188.33,113.48 188.97,112.85 192.63,112.85 193.06,113.28 195.6,113.28 196.64,114.32 198.17,114.32 198.55,114.7 200.83,114.7 201.97,113.56 211.38,113.56 216.2,118.39 220.14,118.39 220.7,118.94 223.62,118.94 224.92,120.25 226.27,120.25 226.43,120.09 227.02,120.09 227.15,120.21 227.15,120.52 v2(226.99,120.67)
  BOTTOM w0.089: 127.43,137.36 127.4,137.36 127.38,137.39 126.36,137.39 125.6,136.63 124.46,136.63 123.99,136.16 123.36,136.16 123.13,135.93 122.81,135.93 122.51,136.23 U6539.CF4
  BOTTOM w0.114: v1(129.95,139.84) 129.81,139.7 129.81,139.12 129.2,138.51 129.2,137.93 128.64,137.36 127.43,137.36
SATA_RXP0_IN: length 1.8
  TOP w0.114: U42.5 228.92,118.28 229.04,118.4 229.04,119.01 228.87,119.18 C6589.1
SATA_RXP_OUT: length 2.1
  TOP w0.114: U42.11 228.92,113.16 229.05,113.03 229.05,112.16 228.83,111.94 C6597.2
SATA_TXN0_CN: length 10.1
  TOP w0.114: v2(233.51,104.99) 233.76,105.24 233.76,107.36 230.51,110.61 230.51,111.3 230.32,111.49 C6595.1
  BOTTOM w0.114: CN11.18 233.64,103.95 233.78,104.09 233.78,104.72 v2(233.51,104.99)
SATA_TXN0_HDD: length 149.6
  TOP w0.114: v2(230.3,120.16) 230.54,119.92 230.54,119.77 230.4,119.63 C6587.2
  IN1 w0.089: v1(120.26,140.1) 120.26,140.37 120.36,140.47 126.81,140.47 127.25,140.03 127.25,139.52 127.67,139.1 128.18,139.1 129.13,138.15 133.96,138.15 134.86,137.25 136,137.25 136.82,136.42 136.82,136.01 137.43,135.4 137.84,135.4 138.17,135.08 138.17,122.78 136.9,121.51 136.9,120.11 136.01,119.22 136.01,117.19 135.58,116.76 135.58,114.05 138.02,111.6 138.86,111.6 139.11,111.35 151.48,111.35 152.32,110.51 160.32,110.51 161.36,111.55 166.69,111.55 166.87,111.73 168.27,111.73 168.46,111.92 169.6,111.92 170.12,112.44 172.28,112.44 172.51,112.67 173.69,112.67 174.3,112.06 177.36,112.06 179.88,114.58 183.82,114.58 185.85,112.54 188.01,112.54 188.47,112.09 197.07,112.09 198.87,113.89 200.38,113.89 201.52,112.75 211.7,112.75 216.58,117.62 220.59,117.62 221.15,118.18 225.9,118.18 226.74,119.02 227.5,119.02 229.23,120.75 230.48,120.75 230.68,120.55 230.68,120.29 230.49,120.1 230.36,120.1 v2(230.3,120.16)
  BOTTOM w0.114: v1(120.26,140.1) 120.26,139.95 U6539.BV9
SATA_TXN0_IN: length 1.8
  TOP w0.114: U42.2 230.42,118.32 230.55,118.46 230.55,119.02 230.4,119.18 C6587.1
SATA_TXN_OUT: length 2.1
  TOP w0.114: U42.14 230.42,113.19 230.58,113.03 230.58,112.19 230.33,111.94 C6595.2
SATA_TXP0_CN: length 10.1
  TOP w0.114: C6594.1 230.95,111.49 230.74,111.28 230.74,110.7 233.99,107.46 233.99,105.27 v2(234.27,104.99)
  BOTTOM w0.114: CN11.19 234.14,103.95 234.01,104.08 234.01,104.73 v2(234.27,104.99)
SATA_TXP0_HDD: length 149.6
  TOP w0.114: C6586.2 230.91,119.63 230.79,119.74 230.79,119.9 v2(231.06,120.16)
  IN1 w0.089: v1(120.27,141.01) 120.27,140.84 120.46,140.65 126.88,140.65 127.43,140.1 127.43,139.6 127.74,139.28 128.25,139.28 129.2,138.33 134.03,138.33 134.93,137.42 136.08,137.42 137,136.5 137,136.09 137.51,135.58 137.92,135.58 138.35,135.15 138.35,122.7 137.08,121.43 137.08,120.04 136.19,119.15 136.19,117.12 135.76,116.68 135.76,114.12 138.09,111.78 138.93,111.78 139.18,111.53 151.56,111.53 152.4,110.69 160.25,110.69 161.29,111.73 166.62,111.73 166.8,111.91 168.19,111.91 168.38,112.1 169.53,112.1 170.05,112.62 172.21,112.62 172.44,112.85 173.76,112.85 174.37,112.24 177.29,112.24 179.8,114.75 183.89,114.75 185.92,112.72 188.08,112.72 188.54,112.26 197,112.26 198.8,114.07 200.45,114.07 201.59,112.93 211.63,112.93 216.51,117.8 220.52,117.8 221.08,118.36 225.83,118.36 226.67,119.2 227.43,119.2 229.15,120.93 230.55,120.93 230.86,120.62 230.86,120.37 v2(231.06,120.16)
  BOTTOM w0.114: v1(120.27,141.01) 120.27,140.88 U6539.BT9
SATA_TXP0_IN: length 1.8
  TOP w0.114: C6586.1 230.96,119.18 230.78,119 230.78,118.46 230.92,118.32 U42.1
SATA_TXP_OUT: length 2.1
  TOP w0.114: C6594.2 230.92,111.94 230.8,112.06 230.8,113.05 230.92,113.16 U42.15
SC_PWRSV#: length 149.1
  TOP w0.114: v2(210.17,92.79) R67606.1 210.73,93.12 210.59,93.27 R25557.2
  IN4 w0.089: v1(112.66,125.12) 113.08,124.7 113.08,122.83 113.71,122.2 114.98,122.2 116.38,120.8 116.38,120.55 116.76,120.16 117.65,120.16 117.9,119.91 120.44,119.91 121.71,118.64 121.71,117.8 122.65,116.86 124.63,116.86 124.76,116.74 124.76,114.12 130.22,108.66 131.59,108.66 133.14,107.11 133.14,106.65 133.8,105.99 135.89,105.99 136.62,105.25 139.82,105.25 140.08,105 144.78,105 145.56,105.79 147.8,105.79 148.15,106.14 158.03,106.14 158.52,105.66 167.05,105.66 167.58,105.13 173.45,105.13 175.48,103.1 179.22,103.1 181.3,105.18 181.3,111.12 181.58,111.4 182.98,111.4 184.86,113.28 192.98,113.28 194.2,112.06 195.85,112.06 196.72,111.2 203.45,111.2 203.75,110.89 210.36,110.89 211.12,110.13 215.56,110.13 v2(215.95,109.75)
  BOTTOM w0.102: U6539.DK25 112.84,125.12 v1(112.66,125.12)
  BOTTOM w0.114: v2(210.17,92.79) 210.54,92.79 213.79,96.03 213.79,99.84 214.29,100.35 v2(214.29,101.52) 214.29,105.18 213.28,106.19 213.28,106.96 213.51,107.18 214.52,107.18 215.95,108.61 v2(215.95,109.75)
SCARDC6: length 11
  TOP w0.114: U6509.2 222.28,92.33 v2(222.42,92.48)
  BOTTOM w0.114: v2(222.42,92.48) 223.57,92.48 223.9,92.81 223.9,94.76 224.07,94.94 224.07,95.53 223.9,95.7 CN53.4
SCARDC8: length 12.7
  TOP w0.114: v2(222.42,91.68) U6509.1
  BOTTOM w0.114: v2(222.42,91.68) 223.28,91.68 224.34,92.74 224.34,94.13 225.98,95.77 225.98,97.3 224.9,98.38 CN53.3
SCARDCLK: length 8.1
  TOP w0.114: U6509.6 v2(222.42,94.93) 222.42,94.36 v2(222.63,94.15)
  BOTTOM w0.114: v2(222.42,94.93) 221.9,95.46 CN53.6
SCARDDATA: length 7.7
  TOP w0.114: R25558.1 223.95,94.61 224.1,94.77 C20053.1 224.08,95.15 v2(223.44,95.15)
  BOTTOM w0.114: v2(223.44,95.15) 222.36,96.23 222.36,99.44 222.9,99.98 CN53.5
SCARDFCB: length 9.4
  TOP w0.114: U6509.3 v2(219.88,92.98)
  BOTTOM w0.114: v2(219.88,92.98) 220.9,94 CN53.7
SCARDRST: length 7.6
  TOP w0.114: v2(219.9,94.38) 220,94.28 U6509.5
  BOTTOM w0.114: v2(219.9,94.38) CN53.8
SCL_GSENSOR: length 135.4
  TOP w0.114: v2(156.76,216.18) 156.5,215.91 156.5,215.53 U6516.E5
  IN1 w0.089: v2(51.23,198.88) 51.96,198.14 56.18,198.14 57.07,197.25 61.13,197.25 61.77,197.89 70.91,197.89 72.05,199.03 73.2,199.03 74.59,197.63 77.26,197.63 80.18,194.71 91.1,194.71 92.53,196.14 94.53,196.14 95.14,196.75 97.38,196.75 98.14,197.51 102.41,197.51 104.54,195.37 111.68,195.37 112.31,194.74 114.12,194.74 116.58,197.2 116.58,205.71 118.61,207.74 118.61,209.06 121.84,212.29 126.49,212.29 128.98,214.78 132.51,214.78 132.76,214.53 135.81,214.53 136.34,215.06 139.44,215.06 139.8,215.41 143.81,215.41 144.57,216.18 148.25,216.18 149.04,216.96 155.6,216.96 156.38,216.18 v2(156.76,216.18)
  BOTTOM w0.114: R25638.2 151.55,216.95 151.59,216.91 R25636.2 152.16,216.91 152.66,217.41 155.53,217.41 v2(156.13,216.81) v2(156.76,216.18) ; CN67.4 50.9,198.55 v2(51.23,198.88)
SCL_GSENSOR_MB: length 20.5
  TOP w0.114: v2(148.89,213.56) 148.89,214.14 148.64,214.4 147.87,214.4 147.71,214.56 R67875.2 ; Q6567.1 152.14,215.15 152.4,215.41 v2(152.57,215.41) ; U6515.12 140.38,214.91 139.85,214.37 v2(139.85,213.15)
  IN1 w0.089: v2(148.89,213.56) 147.95,213.56 147.82,213.69 140.81,213.69 140.28,213.15 v2(139.85,213.15)
  BOTTOM w0.114: v2(148.89,213.56) 148.89,214.02 v2(150.3,215.42) 150.3,215.93 150.53,216.17 R25638.1 151.8,215.41 v2(152.57,215.41)
SCL_HUB_TO_CPU: length 101.3
  TOP w0.079: 154.96,215.64 154.86,215.54 154.86,214.9 U6516.C4
  TOP w0.114: v2(154.99,215.67) 154.96,215.64
  IN1 w0.089: v2(154.99,215.67) 154.99,214.53 157.14,212.37 159.6,212.37 160.47,211.5 160.47,209.72 160.07,209.32 157.4,209.32 156.69,210.03 151.77,210.03 148.26,206.52 139.11,206.52 138.73,206.91 136.7,206.91 136.06,206.27 125.78,206.27 125.14,205.64 125.14,204.8 124.05,203.7 124.05,197.61 123.49,197.05 123.49,194.66 123.13,194.31 123.13,189.02 122.09,187.98 122.09,187.22 121.45,186.57 119.18,186.57 118.93,186.32 118.14,186.32 117.14,185.32 113.51,185.32 113.3,185.11 110.59,185.11 109.93,184.45 108.91,184.45 108.48,184.02 102.51,184.02 v2(101.9,183.41)
  BOTTOM w0.114: v2(101.9,183.41) 102.66,182.65 102.97,182.65 103.17,182.44 103.17,181.12 103.04,181 102.28,181 101.71,180.43 Q6632.1 102.26,180 103.81,178.45 v2(103.81,177.7) R25632.2 R25631.2
SCL_SRC: length 2.8
  TOP w0.114: R68200.2 28.59,120.83 28.11,121.31 27.99,121.31 27.66,121.64 27.45,121.64 v2(27.41,121.68) 27.1,121.99 U6537.34
SD_CDZ: length 7.2
  BOTTOM w0.114: Q6565.3 30.68,55.37 v2(30.4,55.65) 30.14,55.9 30.14,56.66 30.37,56.89 31.01,56.89 31.41,57.29 31.41,58.05 30.76,58.69 U40.13
SD_CDZ_R: length 5.3
  TOP w0.114: CN62.11 34.31,55.68 33.95,56.04 v2(33.95,56.83)
  BOTTOM w0.114: R67539.2 32.05,55.27 32.91,56.12 32.91,56.35 33.39,56.83 v2(33.95,56.83)
SD_CLK: length 30.9
  IN1 w0.089: v2(30.4,57.91) 31.41,56.89 31.41,52.98 31.54,52.85 32.8,52.85 32.93,52.73 32.93,52.6 32.8,52.47 32.05,52.47 31.92,52.35 31.92,52.22 32.05,52.09 32.85,52.09 32.94,52.01 32.94,51.83 32.85,51.74 32.52,51.74 32.43,51.65 32.43,51.47 32.52,51.38 32.85,51.38 32.94,51.29 32.94,51.12 32.85,51.03 32.52,51.03 32.43,50.94 32.43,50.78 32.52,50.69 32.85,50.69 32.94,50.6 32.94,50.43 32.85,50.34 32.52,50.34 32.43,50.25 32.43,50.07 32.52,49.98 32.85,49.98 32.94,49.89 32.94,49.71 32.85,49.63 32.52,49.63 32.43,49.54 32.43,49.36 32.52,49.27 32.85,49.27 32.94,49.18 32.94,49 32.85,48.91 32.52,48.91 32.43,48.83 32.43,48.61 32.52,48.52 33.36,48.52 33.45,48.43 33.45,48.25 33.36,48.16 32.52,48.16 32.43,48.07 32.43,47.89 32.52,47.81 33.36,47.81 33.45,47.72 33.45,47.54 33.36,47.45 32.52,47.45 32.43,47.36 32.43,47.18 32.52,47.09 33.36,47.09 33.45,47.01 33.45,46.83 33.36,46.74 32.52,46.74 32.43,46.65 32.43,45.11 32.68,44.85 33.07,44.85 33.19,44.98 33.19,46.25 33.32,46.38 v1(33.83,46.38)
  BOTTOM w0.114: U40.15 29.76,58.19 30.04,57.91 v2(30.4,57.91) ; R67532.1 33.7,46.53 33.83,46.41 v1(33.83,46.38)
SD_CLK_R: length 2.8
  TOP w0.114: v1(33.83,47.6) 34.01,47.6 34.43,47.18 CN62.6
  BOTTOM w0.114: R67532.2 C1648.1 33.78,47.55 v1(33.83,47.6)
SD_CMD: length 30.9
  IN1 w0.089: v2(29.13,55.65) 29.92,54.86 29.92,51.81 30.88,50.85 30.88,41.2 31.09,40.98 31.22,40.98 32.04,41.81 32.17,41.81 32.3,41.69 32.3,41.56 31.47,40.73 31.47,40.61 31.6,40.48 31.72,40.48 32.55,41.31 32.67,41.31 32.8,41.18 32.8,41.06 31.97,40.23 31.97,40.1 32.1,39.98 32.22,39.98 33.05,40.81 33.18,40.81 33.3,40.68 33.3,40.55 32.48,39.73 32.48,39.6 32.81,39.27 v2(33.57,39.27)
  BOTTOM w0.114: U40.18 28.26,56.39 29,55.65 v2(29.13,55.65) ; R67899.1 33.35,39.04 v2(33.57,39.27)
SD_CMD_R: length 3
  TOP w0.114: v2(33.57,40.03) 33.93,39.68 CN62.3
  BOTTOM w0.114: R67899.2 C1647.1 33.55,40.06 v2(33.57,40.03)
SD_D0/MS_D6: length 30.4
  IN1 w0.089: v2(33.88,59.2) 32.05,59.2 31.92,59.08 31.92,58.53 32.01,58.44 33.1,58.44 33.19,58.35 33.19,58.17 33.1,58.09 32.01,58.09 31.92,58 31.92,57.82 32.01,57.73 33.1,57.73 33.19,57.64 33.19,57.46 33.1,57.37 32.01,57.37 31.92,57.29 31.92,57.11 32.01,57.02 33.1,57.02 33.19,56.93 33.19,56.75 33.1,56.66 32.01,56.66 31.92,56.57 31.92,56.4 32.01,56.31 33.1,56.31 33.19,56.22 33.19,56.04 33.1,55.95 32.01,55.95 31.92,55.86 31.92,55.68 32.01,55.6 33.1,55.6 33.19,55.51 33.19,55.33 33.1,55.24 32.01,55.24 31.92,55.15 31.92,54.97 32.01,54.88 33.1,54.88 33.19,54.8 33.19,54.62 33.1,54.53 32.01,54.53 31.92,54.44 31.92,54.25 32.05,54.12 33.36,54.12 33.45,54.04 33.45,51.08 v2(33.95,50.57)
  BOTTOM w0.114: v2(33.95,50.57) 33.47,50.09 33.47,49.86 33.32,49.71 R67897.1 ; U40.11 32.83,60.49 v2(32.94,60.37) 33.88,59.43 v2(33.88,59.2)
SD_D0/MS_D6_R: length 2.9
  TOP w0.114: CN62.8 34.11,51.18 v2(33.95,51.33)
  BOTTOM w0.114: R67897.2 C1643.1 33.35,50.72 v2(33.95,51.33)
SD_D1/MS_D7: length 31
  IN1 w0.089: v2(33.95,53.62) 33.95,54.25 33.52,54.68 33.52,58.56 33.66,58.7 34.21,58.7 34.34,58.82 34.34,59.5 34.2,59.64 31.12,59.64 31.03,59.72 31.03,60.01 31.12,60.1 32.72,60.1 32.81,60.19 32.81,60.36 32.72,60.45 31.12,60.45 31.03,60.54 31.03,60.72 31.12,60.81 32.72,60.81 32.81,60.9 32.81,61.08 32.72,61.16 31.12,61.16 31.03,61.25 31.03,61.43 31.12,61.52 32.72,61.52 32.81,61.61 32.81,61.79 32.72,61.88 31.12,61.88 31.03,61.96 31.03,62.14 31.12,62.23 33.21,62.23 33.45,62 33.45,60.6 v2(33.95,60.09)
  BOTTOM w0.114: R67898.1 33.55,53.21 v2(33.95,53.62) ; v2(33.95,60.09) 33.06,60.99 U40.10
SD_D1/MS_D7_R: length 2.9
  TOP w0.114: v2(33.95,52.85) 34.13,52.68 CN62.9
  BOTTOM w0.114: v2(33.95,52.85) 33.29,52.19 C1644.1 R67898.2
SD_D2/MS_D5: length 31.5
  IN1 w0.089: v2(29,54.63) 29,53.87 29.31,53.57 29.31,51.46 30.25,50.52 30.25,39.54 32.94,36.85 32.94,35.81 v2(33.57,35.18)
  BOTTOM w0.114: v2(29,54.63) 27.73,55.9 26.72,55.9 v2(26.21,56.41) 26.64,56.84 26.64,59.28 26.36,59.56 26.36,60.4 26.59,60.63 26.59,60.86 26.72,60.99 U40.21 ; R67895.1 33.45,34.98 33.57,35.1 v2(33.57,35.18)
SD_D2/MS_D5_R: length 3.7
  TOP w0.114: CN62.1 34.21,34.68 34.08,34.8 34.08,35.33 v2(33.57,35.84)
  BOTTOM w0.114: v2(33.57,35.84) 33.42,35.99 C1645.1 R67895.2
SD_D3/MS_D4: length 30.8
  IN1 w0.089: v2(29.51,54.12) 29.61,54.02 29.61,51.61 30.58,50.64 30.58,39.72 31.41,38.88 31.54,38.88 31.99,39.33 32.11,39.33 32.24,39.2 32.24,39.08 31.79,38.63 31.79,38.51 31.92,38.38 32.04,38.38 32.49,38.83 32.61,38.83 32.74,38.7 32.74,38.58 32.29,38.13 32.29,38 32.43,37.87 32.56,37.87 33.24,38.55 v2(33.57,38.55)
  BOTTOM w0.114: U40.20 26.91,60.49 26.69,60.27 26.69,59.74 26.97,59.46 26.97,57.05 v2(27.48,56.54) 27.73,56.28 27.81,56.28 28.95,55.14 29.26,55.14 29.51,54.89 v2(29.51,54.12) ; R67896.1 33.5,38.47 v2(33.57,38.55)
SD_D3/MS_D4_R: length 3.2
  TOP w0.114: v2(33.57,37.69) 33.65,37.69 34.17,37.18 CN62.2
  BOTTOM w0.114: v2(33.57,37.69) 33.34,37.46 C1646.1 R67896.2
SD_WP/MS_D1: length 9
  BOTTOM w0.114: Q6570.3 32.68,58.32 32.94,58.57 33.98,58.57 34.49,59.08 34.49,62.23 v2(34.08,62.63) 33.07,62.63 32.42,61.99 U40.8
SD_WP/MS_D1_R: length 3.3
  TOP w0.114: v2(33.95,54.89) 33.95,54.38 34.16,54.18 CN62.10
  BOTTOM w0.114: R67887.2 33.57,53.99 33.95,54.38 v2(33.95,54.89)
SDA_GSENSOR: length 136.6
  TOP w0.079: U6516.E4 156.46,214.64 156.6,214.79 156.63,214.79 156.63,214.78 156.74,214.78 156.74,214.79
  TOP w0.114: 156.74,214.79 156.75,214.79 157.65,214.79 158.13,214.3 R25635.2 158.75,214.3 158.87,214.17 v2(158.87,213.87) 158.93,213.82 R25637.2
  IN1 w0.089: v2(50.72,199.31) 51.61,199.31 52.4,198.52 56.31,198.52 57.22,197.61 60.85,197.61 61.64,198.4 70.78,198.4 71.8,199.41 73.45,199.41 74.72,198.14 77.39,198.14 80.44,195.09 90.98,195.09 92.37,196.49 94.28,196.49 94.91,197.13 97.25,197.13 98.01,197.89 102.66,197.89 104.82,195.73 111.93,195.73 112.57,195.09 113.96,195.09 116.23,197.35 116.23,206.12 118.16,208.05 118.16,209.11 121.69,212.65 126.31,212.65 128.82,215.16 132.63,215.16 132.89,214.91 135.55,214.91 136.06,215.41 139.29,215.41 139.64,215.77 143.53,215.77 144.32,216.56 148,216.56 148.76,217.32 155.75,217.32 156.43,216.63 156.94,216.63 157.65,215.92 157.65,215.03 158.82,213.87 v2(158.87,213.87)
  BOTTOM w0.114: CN67.3 50.1,198.69 v2(50.72,199.31)
SDA_GSENSOR_MB: length 29.8
  TOP w0.114: U6515.2 141.15,213.64 141.02,213.51 v2(141.02,213.13) ; v2(157.25,213.95) 157.84,213.95 v2(157.91,213.89) 158.15,213.65 R25637.1 ; Q6567.4 149.38,216.45 v2(149.14,216.21) 149.13,216.2 R67873.2
  IN1 w0.089: v2(149.14,216.21) 149.17,216.18 149.9,216.18 150.67,215.41 150.67,213.64 150.01,212.98 147.77,212.98 147.42,213.33 141.22,213.33 v2(141.02,213.13)
  IN4 w0.089: v2(149.14,216.21) 149.43,215.92 153.21,215.92 154.22,216.94 156.38,216.94 156.64,216.68 156.84,216.68 157.53,216 157.53,214.27 v2(157.91,213.89)
SDA_HUB_TO_CPU: length 100.4
  TOP w0.114: U6516.C5 155.49,215.53 v2(155.49,216.18)
  IN1 w0.089: v2(155.49,216.18) 155.49,214.65 157.4,212.75 159.81,212.75 160.83,211.73 160.83,209.57 160.19,208.94 157.14,208.94 156.43,209.65 151.87,209.65 148.37,206.14 138.98,206.14 138.6,206.52 136.82,206.52 136.19,205.89 125.9,205.89 125.52,205.51 125.52,204.67 124.43,203.58 124.43,197.48 123.87,196.92 123.87,194.54 123.52,194.18 123.52,188.77 122.47,187.73 122.47,186.97 121.69,186.18 119.32,186.18 119.01,185.86 118.19,185.86 117.29,184.96 113.69,184.96 113.48,184.76 110.87,184.76 110.21,184.1 109.06,184.1 108.63,183.66 102.92,183.66 v2(102.66,183.41)
  BOTTOM w0.114: R25629.2 105.87,175.98 R25630.2 105.83,177.12 105.65,177.3 Q6633.1 105.14,178.9 104.44,179.6 104.44,180.87 103.55,181.76 103.55,182.65 102.79,183.41 v2(102.66,183.41)
SDATA_SRC: length 2.3
  TOP w0.114: R68201.2 27.55,120.83 27.12,121.26 27.12,121.31 26.7,121.73 U6537.33
SDREG: length 3.3
  BOTTOM w0.305: C1651.1 v2(31.92,64.28) 31.22,64.28 30.76,63.82 U40.6
SENSEA: length 2.2
  BOTTOM w0.203: U20.13 22.31,28.81 22.43,28.68 23,28.68 v2(23.08,28.6) 23.08,27.86 R451.1
SET1_1: length 0.6
  TOP w0.178: PR7018.1 PR7014.2
SET1_2: length 1.4
  TOP w0.114: v2(166.7,143.96) 166.74,144.01 PR7026.2
  TOP w0.178: PR7032.2 PR7026.2
SET2_1: length 0.5
  TOP w0.178: PR7015.2 PR7019.1
SET2_2: length 0.5
  TOP w0.203: PR7033.1 PR7027.1
SET3_1: length 0.5
  TOP w0.178: PR7020.1 PR7016.2
SET3_2: length 0.5
  TOP w0.178: PR7034.1 167.2,147.23 PR7000.2
SIO_EXT_SCI#: length 138.8
  TOP w0.114: U37.23 152.59,100.74 153.12,101.27 154.85,101.27 155.11,101.01 155.11,100.61 154.55,100.05 154.55,98.9 v1(152.95,97.3)
  IN1 w0.089: v1(152.95,97.3) 146.4,97.3 145.36,98.35 143.96,98.35 143.51,97.89 138.65,97.89 137.97,98.57 125.01,98.57 124.53,98.09 119.96,98.09 119.45,97.58 118.05,97.58 117.27,96.8 105.33,96.8 105.02,97.1 103.86,97.1 103.55,96.8 93.39,96.8 92.9,97.29 90.78,97.29 88.79,95.3 84.6,95.3 83.48,96.42 82.6,96.42 80.18,98.83 v1(80.18,100.48)
  IN4 w0.089: v1(80.18,100.48) 80.18,102.26 80.41,102.48 82.37,102.48 82.85,102 85.64,102 85.87,102.23 v1(85.87,102.87)
  BOTTOM w0.102: U6539.CY49 101.69,130.4 98.64,130.4 97.43,129.18 94.79,129.18 94.66,129.05 93.14,129.05 92.88,128.8
  BOTTOM w0.114: v1(85.87,102.87) 85.35,103.4 85.11,103.4 82.8,105.71 82.8,106.96 82.91,107.07 82.91,109.38 82.8,109.5 82.8,110.31 82.27,110.84 82.27,114.5 85.85,118.08 85.85,120.9 86.91,121.97 86.91,123.72 88.18,124.99 88.18,126.01 88.69,126.51 90.34,126.51 92.63,128.8 92.88,128.8
SKTOCC#: length 7.6
  BOTTOM w0.102: 99.87,164.1 100.66,164.1 U6539.D52
  BOTTOM w0.114: 99.87,164.1 95.17,164.1 v2(94.79,164.49) 94.15,164.49 93.87,164.2 R68314.1
SLEEVE: length 23.6
  IN3 w1.016: 6.13,15.15 6.67,15.15 7.18,15.67 9.26,15.67 9.8,15.13 11.15,15.13 12.3,16.28 14.21,16.28 17.71,19.78 17.71,19.79 18.69,20.77 18.69,21.02 21.12,23.46 21.12,25.17 20.24,26.06
  BOTTOM w0.203: v2(20.16,27.81) 20.31,27.96 U20.18
  vias: v2(4.47,15.52) v2(5.13,15.52) v2(19.58,27.48) v2(20.17,27.15)
SLP_A#: length 16.9
  TOP w0.102: 101.17,121.76 103.75,121.76 105.33,123.34 105.33,123.71 105.32,123.72 v1(105.32,123.75)
  TOP w0.114: R68933.2 90.96,121.38 93.01,121.38 93.14,121.26 93.98,121.26 94.38,121.66 100.22,121.66 100.45,121.89 101.04,121.89 101.17,121.76
  BOTTOM w0.079: U6539.DR41 105.65,123.4 105.46,123.58
  BOTTOM w0.102: 105.46,123.58 105.32,123.73 v1(105.32,123.75)
SLP_LAN#: length 138.5
  TOP w0.114: R67507.1 34.29,174.95 34.72,174.52 v2(34.72,174.27) 34.72,174.22 v2(34.21,173.71) ; C96905.1 81.45,121.66 81.34,121.77 v1(81.33,121.77)
  IN1 w0.089: v2(79.04,171.88) 70.12,171.88 65.07,176.93 61.74,176.93 61.39,176.58 53.36,176.58 51.87,178.06 44.25,178.06 43.86,178.46 42.82,178.46 38.07,173.71 v2(34.21,173.71) ; v1(107.2,123.72) 106.73,124.19 106.73,127.66 106.45,127.94 105.23,127.94 105.07,127.78 102.41,127.78 99.74,125.12 97.58,125.12 96.59,124.13 93.16,124.13 91.16,122.12 86.71,122.12 85.9,121.31 84.12,121.31 82.98,120.16 81.71,120.16 81.33,120.55 v1(81.33,121.77)
  BOTTOM w0.102: v1(107.2,123.72) 106.83,124.09 U6539.DN39
  BOTTOM w0.114: v2(79.04,171.88) 79.04,130.96 81.33,128.67 v1(81.33,121.77)
SLP_S0#: length 200.7
  TOP w0.114: R68750.1 145.87,95.37 145.18,96.06 145.18,96.39 v2(145.21,96.42) ; R592.1 81.48,95.12 v1(80.94,95.65) 82.21,96.92 82.21,99.84 82.57,100.2 82.57,101.47 83.23,102.13 83.49,102.13 83.89,102.54 83.89,103.93 v2(84.2,104.24) 85.9,105.94 85.9,106.45 86.28,106.83 86.28,108.35 86.53,108.61 86.53,109.47 v2(86.66,109.6) ; v2(205.79,106.07) 206.11,106.4 206.34,106.4 R68953.2
  IN1 w0.089: v2(145.21,96.42) 145.18,96.42 144.78,96.82 137.79,96.82 137,97.61 135.55,97.61 135,97.05 120.44,97.05 120.11,96.72 118.66,96.72 116.56,94.61 96.21,94.61 95.68,95.15 92.5,95.15 91.99,94.64 81.96,94.64 v1(80.94,95.65) ; v2(209.98,102.13) 209.47,102.64 209.47,103.53 206.93,106.07 v2(205.79,106.07)
  IN3 w0.102: v2(209.98,102.13) 209.98,101.37 209.21,100.61 209.21,99.34 208.96,99.08 207.18,99.08 206.55,98.45 206.55,96.8 204.39,94.64 200.96,94.64 200.71,94.38 147.24,94.38 v2(145.21,96.42)
  BOTTOM w0.102: 92.12,123.44 92.78,124.1 ; 94.33,124.53 94.66,124.53 95.11,124.99 R68485.1 95.11,125.36 95.44,125.68 R68486.1 96.08,125.68 96.31,125.45 97.18,125.45 97.58,125.85 97.58,126.18 99.27,127.87 100.47,127.87 100.53,127.81 101.7,127.81 101.76,127.87 102.83,127.87 103.04,127.66 104.83,127.66 U6539.DD42
  BOTTOM w0.114: v2(86.66,109.6) 85.52,110.74 85.52,113.18 86.15,113.81 89.58,113.81 90.22,114.45 90.22,120.16 90.95,120.9 90.95,123.06 91.23,123.34 92.02,123.34 92.12,123.44 ; 92.78,124.1 93.04,124.36 94.15,124.36 94.33,124.53
SLP_S5#: length 160.7
  TOP w0.102: 101.62,122.45 102.61,122.45 103.35,123.19 103.91,123.19 104.14,123.42 104.14,125.17 104.32,125.35 105,125.35 v1(105.34,125)
  TOP w0.114: v1(15.54,72.67) 15.79,72.41 R68628.2 ; R338.1 91.94,122.45 92.27,122.78 92.83,122.78 93.01,122.96 94.03,122.96 94.48,122.5 99.92,122.5 100.17,122.75 101.32,122.75 101.62,122.45
  IN1 w0.089: v1(105.34,125) 104.99,125.36 104.33,125.36 103.93,124.96 103.93,124.86 103.82,124.75 103.31,124.75 103.14,124.58 103.14,123.56 102.92,123.35 102.61,123.35 102.39,123.56 102.39,123.61 102.38,123.62 102.38,123.77 102.28,123.87 102.28,124.86 102.15,124.99 100.88,124.99 100.25,124.36 97.84,124.36 97.01,123.53 93.68,123.53 91.56,121.41 89.56,121.41 88.06,119.91 83.48,119.91 83.23,119.66 82.72,119.66 82.34,119.28 82.34,118.91 82.2,118.77 81.79,118.77 81.02,118.01 79.29,118.01 78.66,117.37 77.52,117.37 76.25,116.1 75.13,116.1 73.88,114.86 72.54,114.86 64.89,107.21 64.31,107.21 63.47,106.37 63.47,105.45 63.29,105.27 63.01,105.27 62.66,104.92 60.62,104.92 59.86,104.16 59.81,104.16 59.2,103.55 57.96,103.55 57.09,104.42 55.16,104.42 54.91,104.16 50.72,104.16 50.06,104.82 47.95,104.82 47.92,104.85 46.73,104.85 45.18,106.4 45.18,109.45 44.24,110.39 37.13,110.39 36.37,109.62 36.37,105.31 35.73,104.67 33.12,104.67 32.23,105.56 25.06,105.56 24.33,104.82 21.48,104.82 19.48,102.82 19.48,101.75 17.11,99.39 17.11,92.3 17.57,91.84 17.57,89.23 16.77,88.43 16.77,86.12 17.19,85.7 17.19,84.1 17.57,83.72 17.57,74.7 v1(15.54,72.67)
  BOTTOM w0.102: v1(105.34,125) 105.19,125 U6539.DM43
SLP_SUS#_EC: length 195.9
  TOP w0.114: v2(30.63,142.9) 31.03,142.9 v2(31.31,142.62) 31.92,142.01 PU9005.2 ; R68765.1 150.16,108.33 v2(149.58,108.91)
  IN1 w0.089: v2(30.63,142.9) 30.65,142.9 31.29,142.26 31.29,131.21 30.45,130.37 30.45,123.16 31.16,122.45 35.35,122.45 37.26,120.55 43.38,120.55 v2(43.73,120.9)
  IN2 w0.102: v1(94.53,108.38) 97.87,108.38 98.34,108.86 101.26,108.86 101.65,109.24 106.85,109.24 108,110.39 108,110.69 108.22,110.92 111.55,110.92 111.96,110.51 118.79,110.51 118.92,110.39 127.17,110.39 130.47,113.69 132.91,113.69 138.12,108.48 141.32,108.48 141.96,109.12 144.67,109.12 145.31,108.48 148.48,108.48 148.92,108.91 v2(149.58,108.91)
  IN4 w0.089: v1(94.53,108.38) 94.31,108.38 92.63,106.7 88.18,106.7 86.15,104.67 84.88,104.67 84.12,103.91 78.91,103.91 76.5,101.5 76.5,99.08 75.43,98.02 73.5,98.02 72.18,99.34 70.66,99.34 69.95,98.62 53.37,98.62 50.09,101.9 48.53,101.9 46.91,103.53 46.27,103.53 44.65,105.15 44.65,119.99 v2(43.73,120.9)
  BOTTOM w0.079: 101.31,119.96 101.68,120.32 101.68,120.58 102.28,121.18 102.28,121.61 102.28,121.78 U6539.DV49
  BOTTOM w0.102: 100.27,117.88 100.86,117.88 100.98,118.01 R68475.2 100.98,118.51 101.31,118.84 101.31,119.96
  BOTTOM w0.114: v1(94.53,108.38) 94.53,110.26 94.1,110.69 94.1,111.81 93.52,112.39 93.52,113.18 93.42,113.28 93.42,115.16 93.59,115.34 93.59,116.15 95.58,118.13 95.93,118.13 96.44,118.64 99.51,118.64 100.27,117.88
SM_VREF: length 143.3
  TOP w0.508: R242.1 45.25,120.81 45.38,120.67 C266.1 44.69,120.05 v2(44.55,120.19) 43.86,120.19 v2(43.84,120.16)
  IN3 w0.508: v2(85.39,174.39) 85.33,174.33 63.23,174.33 62.93,174.03 60.63,174.03 59.25,172.64 57.81,172.64 56.95,171.79 56.95,154.06 56.69,153.8 56.69,136.42 57.65,135.45 57.65,120.75 56.27,119.37 53.93,119.37 53.39,119.91 53.39,121.56 52.31,122.63 45.76,122.63 45.29,122.16 45.29,121.09 44.37,120.16 v2(43.84,120.16)
  BOTTOM w0.152: 90.88,148.36 90.99,148.26 95.81,148.26 96.03,148.04 97.13,148.04 97.76,148.67 100.38,148.67 100.62,148.91 101.61,148.91 101.62,148.91 101.64,148.91 101.94,149.21 U6539.AU49
  BOTTOM w0.508: 90.88,148.36 89.45,148.36 86.66,151.15 86.66,169.57 85.39,170.84 v2(85.39,174.39)
SMARTCARD_ON: length 90.8
  TOP w0.114: v2(233.22,99.08) v2(233.92,98.38) 235.14,97.16 Q6605.2 ; v2(157.73,105.23) 157.65,105.31 157.65,105.56 156.13,107.08 154.99,107.08 154.1,107.97 152.95,107.97 152.59,108.34 U37.4
  IN1 w0.089: v2(157.73,105.23) 157.81,105.31 163.88,105.31 164.13,105.06 165.06,105.06 165.37,104.75 165.37,104.39 165.6,104.16 166.29,104.16 167.2,103.25 170.53,103.25 171.83,101.95 174.37,101.95 174.92,101.4 192.58,101.4 193.06,101.88 195.5,101.88 196.13,102.51 201.29,102.51 202.1,101.7 203.7,101.7 204.47,102.46 208.76,102.46 209.6,101.62 210.23,101.62 210.4,101.79 213.09,101.79 v2(213.41,102.1)
  IN2 w0.102: v2(213.41,102.1) 213.51,102.21 227.3,102.21 229.66,99.84 232.46,99.84 v2(233.22,99.08)
SMB_ALERT#: length 13.6
  TOP w0.089: v1(115.38,124.43) 115.75,124.07 115.75,123.46 115.87,123.34 115.87,123.34 116,123.21 116,122.45 116.12,122.32 116.12,122.07
  TOP w0.114: 116.12,122.07 116.12,119.91 116.33,119.71 116.33,119.27 116.86,118.74 117.04,118.74 117.7,118.08 117.7,117.73 v2(118.03,117.4) 118.03,115.11 118.16,114.99 R68388.2 R68395.1 118.21,114.42 118.05,114.27 118.05,113.66 118.31,113.4 R68389.2
  BOTTOM w0.102: U6539.DN19 115.49,124.43 v1(115.38,124.43)
SMB_ME1_CLK: length 185.3
  IN2 w0.102: v1(34.08,48.79) 33.32,48.79 33.09,49.02 33.09,63.92 33.47,64.3 33.47,77.39 35,78.91 35,87.93 37.14,90.07 74.21,90.07 74.8,90.65 77.21,90.65 v2(78.02,91.46)
  IN3 w0.102: v1(130.22,111.25) 130.22,109.88 126.72,106.37 122.96,106.37 121.38,104.8 120.57,104.8 117.44,101.67 115.79,101.67 114.07,99.95 111.15,99.95 109.65,98.45 109.01,98.45 107.28,96.72 106.14,96.72 105.58,96.16 103.17,96.16 102.66,95.65 102.66,95.02 101.75,94.1 93.26,94.1 93.01,93.85 79.9,93.85 78.02,91.97 v2(78.02,91.46)
  IN4 w0.089: v1(130.22,111.25) 130.22,111.66 128.57,113.31 127.96,113.31 126.79,114.47 126.79,116.99 126.16,117.62 126.16,118.39 125.65,118.89 124.4,118.89 123.36,119.94 123.36,120.55 122.84,121.07 121.6,121.07 120.65,122.02 118.71,122.02 117.61,123.12 117.18,123.12 116.66,123.64 116.66,125.33 v1(116.29,125.69)
  BOTTOM w0.102: U6539.DK17 116.44,125.69 v1(116.29,125.69)
  BOTTOM w0.114: v1(34.08,48.79) 33.7,48.79 33.32,48.41 v2(31.92,48.41) 29.76,48.41 28.77,49.4 28.77,51.3 28.36,51.72 Q6624.1 25.18,51.72 R68729.1 ; R68350.1 128.82,112.42 129.82,111.42 130.07,111.42 130.22,111.27 v1(130.22,111.25)
SMB_ME1_CLK_D: length 8.2
  BOTTOM w0.114: Q6624.3 25.25,52.86 R68729.2 24.59,53.08 22.5,53.08 22.43,53.01 R68731.1 21.69,52.65 21.41,52.37 21.41,52.07 v2(21.38,52.04) 21.25,51.91 21.25,51.51 20.56,50.81 U6555.4
SMB_ME1_DAT: length 186.5
  IN2 w0.102: v1(33.7,49.3) 33.45,49.55 33.45,63.78 33.83,64.16 33.83,77.24 35.35,78.76 35.35,87.78 37.28,89.71 74.44,89.71 75,90.27 77.59,90.27 v2(78.02,90.7)
  IN3 w0.102: v1(130.86,111.5) 130.86,109.88 126.94,105.97 123.13,105.97 121.58,104.42 120.7,104.42 117.55,101.27 115.92,101.27 114.19,99.54 111.32,99.54 109.72,97.94 109.24,97.94 107.59,96.29 106.47,96.29 105.96,95.78 103.3,95.78 103.04,95.53 103.04,94.76 102.03,93.75 93.44,93.75 93.19,93.49 80.06,93.49 78.53,91.97 78.53,91.21 v2(78.02,90.7)
  IN4 w0.089: v1(130.86,111.5) 130.86,111.53 128.7,113.69 128.09,113.69 127.17,114.6 127.17,117.12 126.54,117.75 126.54,118.51 125.78,119.28 124.6,119.28 123.74,120.13 123.74,120.67 122.98,121.43 121.74,121.43 120.77,122.4 118.84,122.4 117.77,123.47 117.09,123.47 116.84,123.72 116.84,125.82 v1(116.29,126.36)
  BOTTOM w0.102: U6539.DJ17 116.42,126.36 v1(116.29,126.36)
  BOTTOM w0.114: R68732.1 25.18,54 Q6622.1 27.72,54 27.86,53.87 27.86,53.62 28.11,53.36 28.62,53.36 29.15,52.83 29.15,49.65 29.9,48.9 v2(30.65,48.9) 33.21,48.9 33.6,49.3 v1(33.7,49.3) ; v1(130.86,111.5) 130.32,112.04 129.97,112.04 129.59,112.42 R68351.1
SMB_ME1_DAT_D: length 10
  BOTTOM w0.114: U6555.3 20.42,51.31 20.87,51.76 20.87,52.4 v2(21.75,53.27) 21.89,53.41 21.89,53.74 22.02,53.87 R68733.1 22.43,53.59 22.65,53.36 23.92,53.36 24.3,53.74 24.3,55.01 24.44,55.15 R68732.2 25.25,55.15 Q6622.3
SMB_RUN_CLK: length 122.8
  TOP w0.114: R25531.2 33.83,147.23 v2(34.01,147.05) ; Q6585.1 78.55,120.28 78.69,120.14 R68362.1 79.9,120.14 80.03,120.01 v1(80.03,119.15) 80.03,119 79.8,118.77 R68363.1
  IN1 w0.089: v1(80.03,119.15) 79.57,118.69 78.46,118.69 77.95,118.18 76.53,118.18 73.68,115.34 72.05,115.34 67.41,110.69 66.44,110.69 62.58,106.83 58.59,106.83 58.21,106.45 58.21,105.81 58.47,105.56 59.08,105.56 59.79,104.85 v2(59.79,104.8) 59.76,104.8 59,104.04 58.14,104.04 55.71,106.47 51.15,106.47 v2(50.24,105.56) 49.98,105.31 48.31,105.31 47.24,106.37 46.48,106.37 45.66,107.18 45.66,109.98 45.28,110.36 45.28,120.9 44,122.19 38.16,122.19 36.46,123.88 36.46,127.31 36.09,127.68 36.09,130.25 37.89,132.05 37.89,135.91 40.83,138.85 40.83,143.87 43.81,146.85 v2(43.81,146.94)
  BOTTOM w0.114: JDIM1.253 51.94,106.57 50.93,105.56 v2(50.24,105.56) ; JDIM02.253 63.95,106.57 63.49,106.11 63.49,105.31 63.1,104.92 59.91,104.92 v2(59.79,104.8) ; v2(43.81,146.94) 43.7,146.83 41.83,146.83 40.82,145.82 35.86,145.82 35.23,146.45 33.83,146.45 33.63,146.65 33.63,146.83 33.85,147.05 v2(34.01,147.05)
SMB_RUN_DAT: length 117.6
  TOP w0.114: Q6585.4 77.25,119.54 77.11,119.69 R68360.1 76.25,119.12 76.32,119.05 v1(76.32,119.03) 76.32,119.02 76.25,118.94 R68361.1 ; R25530.2 v2(32.81,147.04)
  IN1 w0.089: v2(43.81,146.28) 41.17,143.64 41.17,138.55 38.29,135.68 38.29,131.94 36.44,130.1 36.44,127.83 36.8,127.48 36.8,124.05 38.32,122.53 44.16,122.53 45.63,121.07 45.63,110.52 46.02,110.13 46.02,107.34 46.63,106.73 47.39,106.73 48.29,105.83 v2(49.56,105.83) 50.54,106.81 55.85,106.81 58.27,104.39 58.72,104.39 v2(59.13,104.8) 58.72,105.2 58.31,105.2 57.83,105.69 57.83,106.58 58.47,107.21 62.45,107.21 66.31,111.07 67.28,111.07 71.89,115.68 73.52,115.68 76.37,118.54 77.68,118.54 77.83,118.69 77.83,118.87 77.68,119.02 76.35,119.02 76.33,119.03 v1(76.32,119.03)
  BOTTOM w0.114: JDIM02.254 57.98,106.32 58.17,106.13 58.17,105.73 58.59,105.31 58.72,105.31 59.13,104.9 v2(59.13,104.8) ; v2(49.56,105.83) 48.17,105.83 47.52,106.48 46.23,106.48 46.07,106.32 JDIM1.254 ; v2(43.81,146.28) 43.64,146.45 41.97,146.45 40.97,145.45 35.71,145.45 35.09,146.07 33.68,146.07 33.24,146.5 33.24,146.78 32.99,147.04 v2(32.81,147.04)
SMB_SML0_CLK: length 84.3
  TOP w0.079: U6549.A7 20.41,60.9 20.28,60.77 20.28,60.52
  TOP w0.114: v1(20.65,59.99) 20.62,59.99 20.28,60.33 20.28,60.52 ; v2(72.31,95.65) 72.44,95.78 72.9,95.78 R68893.1 72.97,95.12 72.91,95.06 Q6616.4
  IN1 w0.089: v2(72.31,95.65) 72.31,94.76 69.44,91.89 36.93,91.89 35,89.96 35,89.46 33.68,88.13 33.68,82.27 30.4,78.99 30.4,72.16 25.7,67.46 24.05,67.46 23.67,67.08 23.67,66.47 22.97,65.77 22.97,61.43 23.67,60.73 23.67,59.84 23.03,59.2 21.36,59.2 20.65,59.92 v1(20.65,59.99)
  BOTTOM w0.114: v1(20.65,59.99) 20.24,59.59 R68898.1
SMB_SML0_DAT: length 87.7
  TOP w0.079: U6549.B7 20.62,61.6 20.62,60.72 20.7,60.65 v1(20.7,60.6)
  TOP w0.114: v2(71.42,94.64) 71.42,92.48 v2(71.93,91.97) 72.05,91.84 73.55,91.84 73.8,92.1 R68894.1 73.8,92.96 74.2,93.35 Q6616.1
  IN1 w0.089: v2(71.42,94.64) 69.08,92.3 36.84,92.3 34.65,90.11 34.65,89.61 33.32,88.29 33.32,82.42 30.04,79.14 30.04,72.31 25.57,67.84 23.92,67.84 23.29,67.21 23.29,66.65 22.63,65.99 22.63,61.26 23.29,60.6 23.29,59.97 22.91,59.59 21.48,59.59 21.08,59.99 21.08,60.22 v1(20.7,60.6)
  BOTTOM w0.114: v1(20.7,60.6) 21.1,60.19 21.1,59.81 21,59.71 R68899.1
SMDDR_VREF_DQ1_M3: length 127.4
  TOP w0.508: R67514.1 57.43,122.58 57.43,121.86 C20130.1 56.14,121.82 56.13,121.82 v1(55.54,121.82)
  IN3 w0.508: v1(55.54,121.82) 56.51,122.78 56.51,132.66 56.18,132.99 56.18,135.02 53.89,137.31 53.89,153.81 54.37,154.28 54.37,171.19 55.39,172.21 55.75,172.21 57.32,173.78 58.77,173.78 60.2,175.21 62.26,175.21 62.53,175.47 71.36,175.47 71.48,175.6 86.09,175.6 86.61,175.08 v2(86.61,174.39)
  BOTTOM w0.15: 100.17,148.94 100.32,148.94 100.6,149.21 U6539.AU52
  BOTTOM w0.152: 100.17,148.94 97.67,148.94 97.03,148.29 96.17,148.29 95.87,148.59 91.7,148.59 91.05,149.25
  BOTTOM w0.508: 91.05,149.25 90.22,149.25 87.8,151.66 87.8,170.33 86.61,171.52 v2(86.61,174.39)
SML0_ALERT#: length 12.7
  TOP w0.089: v1(116.29,124.36) 116.25,124.31 116.25,124.3 115.93,123.98 115.93,123.53 116.25,123.21 116.25,122.58 116.38,122.45 116.38,122.07
  TOP w0.114: R68540.1 R68536.2 119.45,114.99 119.71,115.24 119.71,116.33 v2(119.36,116.67) 118.16,117.88 118.16,118.01 117.14,119.02 116.89,119.02 116.58,119.33 116.58,119.83 116.38,120.04 116.38,122.07
  BOTTOM w0.102: v1(116.29,124.36) 116.48,124.36 U6539.DN17
