# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_AUXN: length 121.4
  TOP w0.114: v2(36.88,151.41) 36.62,151.15 36.21,151.15 C20014.1
  IN1 w0.089: v1(120.27,155.65) 119.89,156.03 117.7,156.03 117.52,155.85 116.76,155.85 115.29,157.32 114.91,157.32 114.6,157.63 114.6,159.23 114.24,159.59 114.24,162.89 114.17,162.97 114.17,164.41 113.64,164.94 113.26,164.94 112.52,165.68 112.52,168.73 111.17,170.08 111.17,170.46 110.51,171.12 105.73,171.12 104.59,169.97 103.45,169.97 101.72,168.25 100.83,168.25 100.37,167.79 92.63,167.79 92.32,167.48 64.87,167.48 63.39,168.96 56.92,168.96 55.98,169.9 53.79,169.9 49.8,173.89 46.02,173.89 40.66,168.53 40.66,154.69 37.81,151.84 36.55,151.84 36.24,151.53 36.24,151.05 36.37,150.92 36.92,150.92 37.05,151.05 37.05,151.23 v2(36.88,151.41)
  BOTTOM w0.114: v1(120.27,155.65) 120.27,155.52 U6539.AD9
DP_AUXP: length 121.5
  TOP w0.114: C20015.1 36.24,150.92 36.47,150.92 v2(36.88,150.52)
  IN1 w0.089: v2(36.88,150.52) 36.65,150.75 36.29,150.75 36.06,150.98 36.06,151.61 36.47,152.02 37.74,152.02 40.48,154.76 40.48,168.6 45.95,174.06 49.88,174.06 53.87,170.08 56.05,170.08 56.99,169.14 63.47,169.14 64.94,167.66 92.25,167.66 92.55,167.97 100.3,167.97 100.76,168.42 101.65,168.42 103.38,170.15 104.52,170.15 105.66,171.29 110.58,171.29 111.35,170.53 111.35,170.15 112.69,168.8 112.69,165.76 113.33,165.12 113.71,165.12 114.35,164.49 114.35,163.04 114.42,162.96 114.42,159.66 114.78,159.31 114.78,157.71 114.98,157.5 115.36,157.5 116.84,156.03 117.45,156.03 117.63,156.21 119.93,156.21 120.26,156.54 v1(120.26,156.57)
  BOTTOM w0.114: U6539.AB9 120.26,156.43 v1(120.26,156.57)
DP_D0N: length 117
  TOP w0.114: v2(36.88,153.95) 36.62,153.69 36.21,153.69 C20017.1
  IN1 w0.089: v2(36.88,153.95) 37.03,153.79 38.38,153.79 39.9,155.31 39.9,168.9 45.72,174.72 50.11,174.72 52.6,172.23 55.93,172.23 56.48,171.68 56.48,171.17 57.32,170.33 63.16,170.33 65.25,168.25 91.31,168.25 91.62,168.55 99.87,168.55 100.33,169.01 101.22,169.01 102.94,170.74 104.28,170.74 105.41,171.87 110.9,171.87 112.09,170.68 112.84,170.68 113.28,170.25 113.28,169.36 113.69,168.96 113.69,166.6 114.35,165.93 114.35,165.38 114.96,164.77 114.96,163.24 115.36,162.84 115.36,159.47 115.68,159.15 117.06,159.15 117.27,158.95 119.76,158.95 119.98,158.72 119.98,158.65 v1(120.24,158.4)
  BOTTOM w0.114: U6539.V9 120.24,158.24 v1(120.24,158.4)
DP_D0P: length 116.9
  TOP w0.114: C20016.1 36.24,153.46 36.6,153.46 v2(36.88,153.18)
  IN1 w0.089: v2(36.88,153.18) 36.88,153.39 37.1,153.62 38.45,153.62 40.08,155.24 40.08,168.83 45.79,174.55 50.04,174.55 52.52,172.06 55.85,172.06 56.31,171.6 56.31,171.09 57.25,170.15 63.09,170.15 65.17,168.07 91.38,168.07 91.69,168.37 99.94,168.37 100.4,168.83 101.29,168.83 103.02,170.56 104.35,170.56 105.48,171.69 110.83,171.69 112.01,170.51 112.77,170.51 113.1,170.18 113.1,169.29 113.51,168.88 113.51,166.52 114.17,165.86 114.17,165.3 114.78,164.69 114.78,163.17 115.18,162.76 115.18,159.39 115.6,158.98 116.99,158.98 117.19,158.77 119.68,158.77 119.8,158.66 119.8,158.58 v1(119.62,158.4)
  BOTTOM w0.114: U6539.V11 119.62,158.27 v1(119.62,158.4)
DP_D1N: length 116
  TOP w0.114: v2(36.88,155.72) 36.47,155.32 36.24,155.32 C20019.1
  IN1 w0.089: v2(36.88,155.72) 37.13,155.47 37.13,155.34 37.03,155.24 36.37,155.24 36.24,155.37 36.24,156.36 38.02,158.14 38.02,163.6 38.7,164.28 38.7,167.92 39.03,168.25 39.03,168.68 45.47,175.12 50.35,175.12 52.6,172.87 56.06,172.87 57.02,171.91 57.02,171.53 57.76,170.79 63.34,170.79 65.48,168.65 83.26,168.65 84.12,169.52 92.43,169.52 92.5,169.44 101.09,169.44 102.79,171.14 104.11,171.14 105.23,172.26 111.15,172.26 111.76,171.65 112.87,171.65 113.69,170.84 113.69,169.6 114.08,169.2 114.08,166.76 114.8,166.04 114.8,165.56 115.36,165 115.36,163.73 116.12,162.96 116.12,160.96 117.4,159.69 119.32,159.69 119.41,159.78 119.8,159.78 119.95,159.63 119.95,159.44 119.82,159.31 v1(119.68,159.31)
  BOTTOM w0.114: U6539.P9 119.94,159.44 119.82,159.31 v1(119.68,159.31)
DP_D1P: length 116
  TOP w0.114: C20018.1 36.21,155.09 36.62,155.09 v2(36.88,154.84)
  IN1 w0.089: v1(120.31,159.31) 120.12,159.5 120.12,159.7 119.88,159.95 119.34,159.95 119.25,159.86 117.47,159.86 116.3,161.03 116.3,163.04 115.54,163.8 115.54,165.07 114.98,165.63 114.98,166.11 114.26,166.83 114.26,169.27 113.86,169.67 113.86,170.91 112.95,171.83 111.83,171.83 111.22,172.44 105.15,172.44 104.04,171.32 102.72,171.32 101.01,169.62 92.58,169.62 92.5,169.69 84.05,169.69 83.18,168.83 65.55,168.83 63.42,170.96 57.83,170.96 57.2,171.6 57.2,171.98 56.13,173.05 52.67,173.05 50.43,175.29 45.4,175.29 38.86,168.75 38.86,168.32 38.53,167.99 38.53,164.36 37.84,163.67 37.84,158.21 36.06,156.43 36.06,155.29 36.29,155.06 36.65,155.06 v2(36.88,154.84)
  BOTTOM w0.114: U6539.T9 120.31,159.23 v1(120.31,159.31)
DP_HPD: length 145.8
  TOP w0.114: R61.1 35.6,146.06 35.21,145.67 34.78,145.67 34.03,144.93 32.05,144.93 v2(31.92,145.06) 31.29,145.06 v2(31.16,144.93)
  IN3 w0.102: v2(48.05,104.29) 47.42,104.92 44.62,104.92 43.73,104.04 38.91,104.04 35.22,107.72 30.91,107.72 29.26,109.37 26.01,109.37 25.25,110.13 25.25,116.66 30.91,122.32 30.91,129.82 31.67,130.58 31.67,135.79 31.06,136.39 31.06,144.83 v2(31.16,144.93)
  IN4 w0.089: v2(48.05,104.29) 48.05,103.58 48.81,102.82 51.56,102.82 52.24,102.13 53.77,102.13 54.02,102.38 59.35,102.38 59.86,101.88 65.07,101.88 66.37,103.17 76.14,103.17 78.79,105.81 82.85,105.81 83.1,105.56 85.52,105.56 85.9,105.94 85.9,107.34 86.91,108.35 89.83,108.35 91.61,110.13 91.61,115.34 95.17,118.89 95.17,119.91 97.35,122.09 97.35,123.62 98.7,124.96 98.7,126.29 100.2,127.78 101.87,127.78 102.15,128.06 103.27,128.06 103.32,128.01 104.31,128.01 v1(105.35,126.97)
  BOTTOM w0.102: v1(105.35,126.97) 105.21,126.97 U6539.DG43
DP_HPD_R: length 6.7
  TOP w0.114: R61.2 35.39,146.84 35.1,146.55 R25534.1 34.59,148.48 33.47,149.6 v2(32.96,149.6) 32.47,149.6 32.18,149.89 U67.32
DP_RCOMP: length 5
  BOTTOM w0.203: U6539.AB1 124.25,156.23 124.3,156.18 125.19,156.18 125.9,155.47 126.37,155.47 127.01,154.84 127.39,154.84
  BOTTOM w0.254: 127.39,154.84 v2(127.62,154.84) R68245.1
DPWROK_EC: length 113.1
  TOP w0.114: v1(84.75,119.25) 84.65,119.15 R68481.1 83.08,119.87 C96717.1 R68479.1 ; v1(151.63,96.16) 152.29,96.82 153.11,96.82 153.53,97.24 153.53,97.37 154.85,98.69 154.85,99.96 155.38,100.49 155.38,102.12 155.3,102.19 155.3,104.13 154.99,104.44 153.87,104.44 153.7,104.27 153.7,103.64 153.46,103.4 152.95,103.4 152.79,103.57 152.79,103.72 152.57,103.94 U37.15
  IN1 w0.089: v1(151.63,96.16) 151.3,96.16 150.67,95.53 149.27,95.53 148.53,96.26 147.04,96.26 146.68,95.91 144.95,95.91 144.24,96.62 137.71,96.62 136.93,97.41 135.63,97.41 135.07,96.85 120.67,96.85 120.34,96.52 119.15,96.52 118.36,95.73 v1(118.36,94.89)
  IN4 w0.089: v1(118.36,94.89) 118.36,95.7 117.14,96.92 117.14,98.32 116.45,99.01 104.92,99.01 100.05,103.88 85.75,103.88 85.52,103.65 84.88,103.65 84.37,103.15 84.37,102.92 v1(84.35,102.89)
  BOTTOM w0.114: v1(84.35,102.89) 84.35,103.3 81.45,106.19 81.45,107.08 81.96,107.59 81.96,108.48 81.77,108.67 81.77,110.25 81.71,110.31 81.71,114.7 84.75,117.75 v1(84.75,119.25)
DRAM_RESET#: length 14.1
  TOP w0.114: v1(102.79,120.32) 101.54,120.32 101.37,120.14 95.14,120.14 94.79,119.78 94.15,119.78 94.03,119.91 93.52,119.91 93.14,119.53 93.14,119.02 93.01,118.89 R68252.2 R68253.1
  BOTTOM w0.102: v1(102.79,120.32) 102.79,120.64 103.33,121.19 103.33,121.66 U6539.DV47
DSI_DE_TE_2: length 13.2
  TOP w0.089: 123.49,159.69 121.45,159.69 v1(120.91,160.23)
  TOP w0.114: R68246.1 130.75,162.61 130.63,162.48 130.63,162.23 129.58,161.18 129.58,160.14 129.1,159.66 128.13,159.66 127.93,159.85 125.2,159.85 125.01,159.66 v2(124.58,159.66) 124.56,159.69 123.49,159.69
  BOTTOM w0.102: U6539.M8 120.59,160.55 v1(120.91,160.23)
DWL_REQ: length 72.8
  TOP w0.114: Q6558.3 69.9,95.53 69.77,95.65 69.13,95.65 69.04,95.75 R67556.2 R67569.1 ; R67569.1 68.34,96.7 67.76,97.28 67.76,98.57 67.94,98.75 68.55,98.75 68.78,98.98 68.78,99.56 68.63,99.72 v2(68.63,100.35) 68.78,100.5 68.78,102.87 69.36,103.45 69.36,104.77 71.67,107.08 71.67,107.59 71.78,107.69 71.78,108.33 v1(71.75,108.35) ; R67569.1 68.34,95.5 68.24,95.4 R67567.1
  IN3 w0.089: v1(112.66,123.8) 112.9,123.55
  IN3 w0.102: v1(71.75,108.35) 72.44,108.35 73.2,109.12 73.2,110.13 75.23,112.16 76.12,112.16 77.33,113.37 77.33,114.39 78.26,115.32 78.67,115.32 79.73,116.38 80.59,116.38 82.55,118.34 90.73,118.34 92.66,120.27 100.2,120.27 100.81,119.66 101.87,119.66 102.81,118.72 106.42,118.72 106.98,119.28 108.76,119.28 109.39,118.64 111.27,118.64 112.95,120.32 112.95,123.5 112.9,123.55
  BOTTOM w0.102: v1(112.66,123.8) 112.82,123.8 U6539.DN25
EC_CCG1_I2C_INT_D: length 9.6
  BOTTOM w0.114: U6555.15 16.81,46.25 17.32,45.74 17.7,45.74 18.24,45.21 R68727.1 18.74,45.21 18.84,45.11 18.84,44.47 19.48,43.84 19.65,43.84 R68722.2 19.87,43.09 19.58,42.8 19.58,42.21 19.78,42.01 Q6626.3 21.52,42.06 22.25,42.06 v2(22.32,42.14)
EC_CCG_I2C_INT#: length 197.8
  TOP w0.114: v1(136.57,97.02) 135.68,97.91 v2(135.68,99.72) 135.68,101.34 137.6,103.26 137.6,104.88 138.25,105.53 138.25,106.85 139.37,107.96 139.89,107.96 142.06,110.13 147.49,110.13 147.67,110.31 149.7,110.31 149.88,110.13 R67604.1 150.29,109.88 150.59,110.18 152.76,110.18 153.01,109.93 154.2,109.93 154.66,110.39 U37.125
  IN2 w0.102: v1(136.57,97.02) 136.37,96.82 124.35,96.82 123.87,97.3 120.31,97.3 119.81,96.8 119.55,96.8 118.77,96.01 117.01,96.01 116.05,95.04 105.58,95.04 105,95.63 103.32,95.63 102.84,95.15 96.95,95.15 96.34,95.75 93.01,95.75 92.55,95.3 84.48,95.3 83.79,95.98 82.52,95.98 81.83,96.67 79.72,96.67 76.92,93.88 73.73,93.88 71.55,91.69 35.98,91.69 33.07,88.78 33.07,79.4 31.54,77.87 31.54,65.81 31.16,65.43 31.16,45.62 29.64,44.09 20.57,44.09 v1(20.39,44.27)
  BOTTOM w0.114: Q6626.1 20.31,42.51 20.65,42.86 R68722.1 20.65,43.93 20.39,44.19 v1(20.39,44.27)
EC_CCG_I2C_SCL: length 195.5
  TOP w0.114: R67448.2 143.88,109.32 141.96,109.32 140.1,107.46 139.57,107.46 138.76,106.65 138.76,105.33 138.53,105.1 138.53,103.4 136.19,101.06 136.19,98.19 137.97,96.42 139.11,96.42 v2(139.24,96.29) 140.54,94.99 v1(140.54,94.59)
  IN1 w0.089: v1(17.34,42.97) 17.75,42.57 19.86,42.57 21.87,44.58 28.47,44.58 29.23,45.34 29.23,46.96 29.51,47.24 29.51,49.81 29,50.31 27.73,50.31 27.55,50.49 27.55,54.71 28.49,55.65 28.49,62.71 33.32,67.54 33.32,77.7 36.6,80.97 36.6,87.25 37.31,87.96 37.31,88.46 38.4,89.56 76.75,89.56 77.39,90.19 77.39,92.22 78.91,93.74 121.45,93.74 122.6,94.89 122.98,94.89 123.29,95.2 136.77,95.2 137,94.97 140.15,94.97 v1(140.54,94.59)
  BOTTOM w0.114: Q6628.1 15.67,41.3 15.77,41.4 15.77,42.16 15.92,42.31 16.21,42.31 R68724.1 17.18,42.81 v1(17.34,42.97)
EC_CCG_I2C_SCL_D: length 9.4
  BOTTOM w0.114: R68724.2 17.41,43.59 17.88,43.13 17.88,42.87 16.76,41.76 Q6628.3 ; R68724.2 16.71,43.86 16.89,44.04 16.89,44.9 16.58,45.21 R68725.1 16.3,45.56 15.81,46.06 U6555.17 ; R68724.2 16.51,43.59 15.64,42.72 v2(15.46,42.72)
EC_CCG_I2C_SDA: length 193.8
  TOP w0.114: v1(141.2,94.59) 141.2,95.22 v2(141.17,95.25) 139.49,96.92 138.02,96.92 136.57,98.37 136.57,100.91 138.89,103.23 138.89,104.92 139.14,105.17 139.14,106.51 139.71,107.08 140.25,107.08 142.08,108.91 143.88,108.91 R67447.2
  IN1 w0.089: v1(19.1,42.97) 19.76,42.97 21.74,44.96 28.34,44.96 28.85,45.47 28.85,47.09 29.13,47.37 29.13,49.68 28.87,49.93 27.6,49.93 27.2,50.34 27.2,54.86 28.09,55.75 28.09,62.81 32.98,67.7 32.98,77.91 36.24,81.18 36.24,87.4 36.96,88.12 36.96,88.63 38.25,89.91 76.47,89.91 77.01,90.45 77.01,92.61 78.49,94.08 121.16,94.08 122.35,95.27 122.73,95.27 123.01,95.55 136.93,95.55 137.16,95.32 140.46,95.32 v1(141.2,94.59)
  BOTTOM w0.114: Q6627.1 17.91,41.51 18.08,41.68 18.51,41.68 18.97,42.14 18.97,42.85 v1(19.1,42.97) 18.93,43.14 R68723.1
EC_CCG_I2C_SDA_D: length 5.8
  BOTTOM w0.114: U6555.16 16.31,46.04 17.14,45.21 R68726.1 17.6,45.21 17.83,44.98 17.83,43.93 R68723.2 18.15,43.41 18.41,43.15 Q6627.3
EC_FPBACK#: length 273.5
  TOP w0.114: v2(207.69,102.89) 208,102.89 214.37,109.27 214.37,111.46 213.34,112.49 213.34,119.34 v2(212.64,120.04) 212.39,120.29 v2(212.39,121.05) ; v1(168.85,105.71) 168.68,105.54 U37.86
  IN1 w0.089: v2(207.69,102.89) 206.55,104.04 205.91,104.04 205.86,104.09 199.98,104.09 199.5,103.61 195.04,103.61 194.61,104.04 194.61,105.98 193.59,107.01 185.39,107.01 181.66,103.28 176.06,103.28 173.02,106.32 169.44,106.32 168.85,105.74 v1(168.85,105.71)
  IN3 w0.102: v2(83.54,188.08) 83.97,188.52 85.11,188.52 86.79,186.84 91.87,186.84 91.99,186.71 91.99,186.08 92.25,185.82 92.25,184.46 93.83,182.88 99.84,182.88 99.94,182.98 102.89,182.98 103.68,183.77 105.61,183.77 105.74,183.64 110.51,183.64 111.86,182.29 111.86,181.73 111.96,181.63 111.96,180.24 112.44,179.75 112.44,179.12 114.96,176.6 114.96,175.64 115.85,174.75 116.81,174.75 118.69,172.87 121.61,172.87 123.49,170.99 123.49,170.58 125.06,169.01 127.1,169.01 127.43,168.68 127.43,167.15 130.09,164.49 131.24,164.49 133.01,162.71 133.01,157.12 132.38,156.49 132.38,155.47 133.01,154.84 136.82,154.84 138.37,153.29 138.37,147.55 138.88,147.04 138.88,129.28 139.87,128.29 139.87,124.61 140.25,124.23 140.25,123.59 138.98,122.32 138.98,121.71 138.68,121.41 138.68,120.55 138.22,120.09 138.22,119.15 138.6,118.77 138.6,113.18 140.25,111.53 147.59,111.53 148.25,112.19 148.25,112.8 148.45,112.99 148.67,112.99 150.31,114.63 153.39,114.63 155.49,116.74 156.76,116.74 157.4,117.37 160.07,117.37 161.34,118.64 162.22,118.64 162.61,118.26 164.13,118.26 165.78,119.91 166.2,119.91 167.34,121.05 169.51,121.05 170.38,121.92 176.22,121.92 178.52,119.62 184.26,119.62 184.7,119.18 189.05,119.18 189.78,119.9 191.29,119.9 191.56,120.17 205.03,120.17 205.61,120.75 212.09,120.75 v2(212.39,121.05)
  BOTTOM w0.114: Q6522.2 82.48,188.75 82.75,188.49 83.13,188.49 v2(83.54,188.08)
EC_PECI: length 77.6
  TOP w0.114: R380.2 159.69,114.7 159.95,114.45 160.95,114.45 161.34,114.83 162.48,114.83 162.66,115.01 164.46,115.01 164.89,115.44 164.89,117.37 165.53,118.01 165.88,118.01 166.73,118.86 v2(166.73,120.11) 166.73,121.63 v1(166.14,122.22)
  IN1 w0.089: v1(137.21,143.28) 137.64,143.28 138.53,142.39 138.53,138.53 142.41,134.64 150.79,134.64 151.81,133.63 151.81,132.71 159.26,125.26 159.26,124.39 159.94,123.72 161.35,123.72 162.49,122.58 165.78,122.58 v1(166.14,122.22)
  IN4 w0.089: v1(137.21,143.28) 136.44,144.04 136.44,145.95 134.16,148.23 130.86,148.23 127.71,145.08 121.99,145.08 v1(121.58,144.68)
  BOTTOM w0.102: U6539.BK9 120.43,143.79 121.28,143.79 121.58,144.09 v1(121.58,144.68)
EC_PECR_R: length 4.2
  TOP w0.114: U37.117 157.86,112.07 158.01,112.21 158.01,113.86 v2(158.4,114.26) 158.85,114.7 R380.1
EC_PWROK: length 130.7
  TOP w0.114: v2(160.07,108.35) 160.07,103.78 159.18,102.89 157.2,102.89 156.22,101.91 156.22,100.57 155.44,99.79 155.44,98.52 154.22,97.3 154.22,97.18 153.46,96.41 U37.33 153.46,94.64 153.35,94.53 153.19,94.53 153.06,94.65 153.06,95.42 152.94,95.54 152.41,95.54 v1(151.81,94.94) ; v1(130.22,112.82) 129.2,113.84 v2(129.2,114.2) 129.2,116.61 128.92,116.89 R68478.2 127.4,116.89 127.27,117.02 R68484.1 ; R68467.2 108.83,109.19 108.63,108.99 108,108.99 107.82,108.81 107.82,107.54 107.51,107.24 105.88,107.24 104.78,106.14 103.87,106.14 103.54,105.81 103.54,102.25 102.94,101.65 102.94,97.96 102.66,97.69 102.66,94.64 102.92,94.38 104.44,94.38 104.82,94.76 v1(104.82,95.22)
  IN1 w0.089: v2(160.07,108.35) 159.63,108.78 154.35,108.78 153.87,108.3 152.29,108.3 150.67,109.92 141.21,109.92 140.58,109.29 137.61,109.29 134.23,112.67 130.37,112.67 v1(130.22,112.82)
  IN2 w0.102: v2(119.88,96.03) 119.93,96.03 120.7,96.8 123.62,96.8 124.12,96.29 136.88,96.29 137.31,95.86 143.66,95.86 144.57,94.94 v1(151.81,94.94)
  BOTTOM w0.114: v1(104.82,95.22) 105.53,94.51 116.73,94.51 117.75,95.53 119.43,95.53 119.88,95.98 v2(119.88,96.03)
EC_SIM_DET: length 72.1
  TOP w0.114: U37.94 166.14,108.74 v1(165.76,108.35) ; v1(195.24,110.13) 195.3,110.18 195.3,110.69 195.85,111.25 195.85,114.68 v2(196.01,114.83) v1(196.01,116.35)
  IN1 w0.089: v2(221.67,124.23) 221.67,123.73 220.9,122.96 216.07,122.96 213.15,120.04 208.33,120.04 206.42,118.13 201.59,118.13 200.22,116.76 196.41,116.76 v1(196.01,116.35) ; v1(165.76,108.35) 166.86,109.46 168.78,109.46 168.82,109.5 169.62,109.5 171.14,111.02 172.97,111.02 173.6,110.39 174.54,110.39 174.8,110.64 180.51,110.64 181.15,111.27 183.05,111.27 184.32,110 194.61,110 194.74,110.13 v1(195.24,110.13)
  BOTTOM w0.114: CN49.12 222.11,122.25 221.93,122.43 arc(221.92,122.44) 221.92,122.46 221.92,123.95 arc(221.92,123.97) 221.91,123.99 v2(221.67,124.23)
EC_SIM_SW#: length 89.7
  TOP w0.114: v2(156.23,108.35) 155.72,107.85 155.24,107.85 154.73,108.35 152.95,108.35 152.57,108.74 U37.3
  IN3 w0.102: v2(156.23,108.35) 156.66,107.92 157.6,107.92 158.1,108.42 158.1,108.54 159.56,110 164.38,110 165.27,109.12 165.27,107.85 165.78,107.34 166.8,107.34 167.18,106.96 167.53,106.6 169.74,106.6 170.23,107.08 172.11,107.08 176.15,111.13 181.13,111.13 181.78,111.78 185.82,111.78 187.35,110.26 190.93,110.26 193.85,107.34 200.96,107.34 v2(201.21,107.59)
  BOTTOM w0.114: v2(201.21,107.59) 201.21,107.16 201.84,106.54 210.7,106.54 213.43,109.26 213.43,111.29 213.52,111.39 213.52,116.15 217.88,120.52 219.98,120.52 v2(221.15,121.69) 221.94,121.69 222,121.75 CN49.13
EC_VOLDN_BTN_ODL: length 99.9
  TOP w0.114: v1(169.01,110.92) 169.06,110.87 169.06,110.43 R69088.1
  IN1 w0.089: v1(134.44,118.67) 134.44,115.11 133.52,114.2 133.52,113.81 133.78,113.56 134.41,113.56 138.07,109.9 140.33,109.9 140.96,110.53 151,110.53 151.91,109.62 160.7,109.62 161.36,110.28 168.37,110.28 v1(169.01,110.92) 169.01,110.89 169.08,110.82 169.08,110.64 169.26,110.46 169.74,110.46 170.94,111.66 173.17,111.66 173.81,111.02 174.29,111.02 174.52,111.25 179.09,111.25 180.21,112.37 180.21,113.2 180.44,113.43 183.05,113.43 185.08,111.4 185.97,111.4 186.35,111.02 187.88,111.02 188.13,111.27 191.05,111.27 191.41,110.92 197.94,110.92 198.29,111.27 198.29,112.04 199.18,112.93 199.82,112.93 202.99,109.75 206.93,109.75 v2(207.44,109.24)
  IN3 w0.102: v2(207.44,109.24) 208.66,108.02 208.66,104.75 208.35,104.44 v2(208.35,102.03)
  BOTTOM w0.114: U6556.10 134.94,119.67 134.44,119.17 v1(134.44,118.67) ; v2(208.35,102.03) CN52.6
EC_VOLUP_BTN_ODL: length 127
  TOP w0.114: R69090.2 148.28,101.58 148,101.3 147.85,101.3 v1(147.54,100.99)
  IN1 w0.089: v1(134.01,114.04) 134.31,114.04 138.25,110.11 140.23,110.11 140.86,110.74 151.07,110.74 151.94,109.88 160.57,109.88 161.18,110.49 168.04,110.49 168.85,111.3 169.87,111.3 170.42,111.85 173.26,111.85 173.88,111.22 174.19,111.22 174.42,111.45 178.91,111.45 180,112.54 180,113.31 180.39,113.69 183.18,113.69 185.21,111.66 186.1,111.66 186.48,111.27 187.75,111.27 187.96,111.48 191.23,111.48 191.56,111.15 197.78,111.15 198.04,111.4 198.04,112.16 199.05,113.18 199.84,113.18 203.02,110 207.94,110 v2(209.72,111.78) ; v1(147.54,100.99) 146.91,101.62 144.58,101.62 v1(143.94,102.26)
  IN3 w0.102: v2(209.72,111.78) 209.98,111.53 209.98,108.86 209.85,108.73 209.85,103.02 v2(209.98,102.89)
  BOTTOM w0.114: CN52.5 208.85,102.15 209.6,102.89 v2(209.98,102.89) ; U6556.9 135.44,119.66 134.92,119.15 134.92,118.26 134.82,118.16 134.82,115.87 134.01,115.06 v1(134.01,114.04) 134.01,113.71 134.18,113.53 134.18,111.31 135.49,110.01 135.49,109.69 v2(136.04,109.14) 136.42,108.76 136.42,108.12 136.74,107.81 136.74,106.28 137,106.02 137.61,106.02 137.69,105.94 140.26,105.94 v1(143.94,102.26)
EC_VSTBY_FSPI: length 6.1
  TOP w0.114: PU8000.5 18.73,116.75 18.68,116.7 PC8006.1 18.08,116.69 18.08,116.1 17.32,115.34 PD8004.2 16.98,115.36 PR8036.2 16.34,116.95 v2(16.07,116.68)
ECAGND: length 19.2
  TOP w0.114: C6564.1 172.82,95.4 v1(173.02,95.6) ; U37.75 168.98,101.14 169.32,101.48 170.69,101.48 C96797.2 C6566.2 171.58,101.44 172.02,101.88 L11.1 172.5,101.5 172.63,101.37 174.04,101.37 v2(174.47,100.94) 174.82,100.59 176.4,100.59 177.09,99.9 177.09,97.83 v2(177.34,97.58)
  BOTTOM w0.114: v1(173.02,95.6) 173.96,96.54 176.29,96.54 v2(177.34,97.58)
EEDI: length 4.1
  TOP w0.114: U6521.30 16.74,166.21 16.48,166.47 15.72,166.47 TP13155.1 14.78,167.41 14.4,167.41 14.24,167.25 R4008.1
EEPROM_SCL: length 1.5
  TOP w0.114: U6544.18 81.33,115.85 81.55,116.07 R68559.1
EEPROM_SDA: length 2.8
  TOP w0.114: TP13304.1 76.73,111.73 77.59,111.73 78.03,112.17 U6544.26
EN: length 3.4
  TOP w0.114: R1238.1 225.39,116.8 225.74,117.15 226.59,117.15 226.65,117.08 226.92,116.82 R1236.2 227.38,116.22 U42.7
EN_3V_DX_LTE: length 102.3
  TOP w0.114: R67871.2 171.62,104.19 v2(172.18,103.63) 172.18,102.94 171.09,101.85 169.37,101.85 v2(168.85,102.36) 168.44,101.94 U37.77
  IN1 w0.089: v2(224.33,124.94) 224.91,124.36 225.85,124.36 226.99,125.5 231.31,125.5 234.49,122.32 234.49,118.89 232.71,117.12 228.9,117.12 227.78,116 227.78,113.45 224.92,110.58 224.92,108.56 220.9,104.54 220.9,103.65 219.76,102.51 215.82,102.51 214.88,101.57 210.94,101.57 210.43,101.06 201.65,101.06 200.96,101.75 199.69,101.75 199.11,101.16 193.31,101.16 192.98,100.83 174.62,100.83 174.08,101.37 169.84,101.37 v2(168.85,102.36)
  BOTTOM w0.114: CN49.7 224.14,124.75 v2(224.33,124.94)
ENSWREG: length 6.3
  TOP w0.114: U6521.6 24.09,165.81 24.21,165.69 v4(25.01,165.69) 27.04,165.69 R67513.2 R67476.1 29.15,166.78 R67475.2
EQ1: length 4
  TOP w0.114: U42.17 232.68,115.22 v2(232.91,114.98) 233.53,114.98 R497.2 233.63,115.22 233.95,115.55 234.81,115.55 235.15,115.2 R498.1
EQ2: length 3.7
  TOP w0.114: R495.1 233.9,115.85 233.63,116.12 R1234.2 233.01,116.35 v2(232.93,116.27) 232.88,116.22 U42.19
EQ_SEL_A0: length 4.2
  TOP w0.114: U6537.5 26.3,129.91 26.87,130.48 R68211.1 R68210.2 26.87,131.85 26.79,131.93 26.79,132.5 v2(26.87,132.58)
ESPI_0: length 95.8
  TOP w0.114: v2(156.76,103.91) 156.26,103.4 155.8,103.4 155.62,103.58 155.62,104.26 155.09,104.8 154.35,104.8 154.05,105.1 154.05,105.48 153.59,105.94 U37.10
  IN1 w0.089: v2(156.76,103.91) 156.76,103.96 156.36,104.37 155.8,104.37 155.25,104.91 154.52,104.91 153.67,105.76 150.34,105.76 150.16,105.94 144.95,105.94 144.72,105.71 140.58,105.71 140.2,106.09 136.95,106.09 135.86,107.18 129.61,107.18 129.48,107.31 122.42,107.31 121.18,106.07 116.82,106.07 116.41,105.65 115.47,105.65 115.31,105.81 112.62,105.81 112.26,105.46 102.28,105.46 100.66,103.83 96.13,103.83 94.99,102.69 v1(91.84,102.69)
  BOTTOM w0.102: 93.87,121.03 R68343.2 ; 92.48,119.63 92.48,119.12 92.27,118.92
  BOTTOM w0.114: 92.27,118.92 92.27,113.48 92.81,112.95 92.81,110.18 91.74,109.12 91.74,106.07 92.07,105.74 92.07,102.92 v1(91.84,102.69) ; 92.48,119.63 93.87,121.03
ESPI_0_R: length 8
  BOTTOM w0.102: R68343.1 95.32,121.03 95.98,121.69 97.7,121.69 98.21,122.2 98.57,122.2 99.21,122.83 99.21,123.69 99.39,123.87 99.97,123.87 100.09,123.99 100.37,123.99 100.69,123.68 U6539.DP52
ESPI_1: length 98.1
  TOP w0.114: v2(156.08,103.91) 156.08,104.25 155.21,105.13 154.66,105.13 154.36,105.42 154.36,105.67 153.7,106.34 U37.9
  IN1 w0.089: v2(156.08,103.91) 155.84,103.91 155.13,104.62 152.29,104.62 152.09,104.42 148.76,104.42 147.87,105.31 145.33,105.31 145.08,105.05 140.38,105.05 139.95,105.48 136.52,105.48 136.06,105.95 133.74,105.95 133.08,106.6 129.33,106.6 129.2,106.73 122.7,106.73 121.28,105.31 116.91,105.31 116.67,105.06 115.2,105.06 115.08,105.18 113.08,105.18 112.75,104.85 103.98,104.85 102.28,103.15 96.31,103.15 95.17,102 91.74,102 v1(91.36,101.62)
  BOTTOM w0.102: R68342.2 95.96,121.33 95.3,120.67
  BOTTOM w0.114: v1(91.36,101.62) 91.36,101.88 91.59,102.1 91.89,102.1 92.4,102.61 92.4,105.91 92.12,106.19 92.12,108.78 v2(93.14,109.8) 93.14,113.08 92.63,113.59 92.63,118.77 92.71,118.84 92.71,119.48 93.9,120.67 95.3,120.67
ESPI_1_R: length 5.3
  BOTTOM w0.102: R68342.1 98.01,121.33 100.02,123.34 101.01,123.34 101.39,123.72 U6539.DP50
ESPI_2: length 105.6
  TOP w0.114: v2(156,105.23) 155.19,106.04 154.5,106.04 153.8,106.74 U37.8
  IN1 w0.089: v2(156,105.23) 155.14,106.09 154.58,106.09 154.3,106.37 150.74,106.37 150.52,106.6 144.6,106.6 144.32,106.32 141.3,106.32 140.36,107.26 136.62,107.26 135.91,107.97 132.25,107.97 131.87,108.35 130.73,108.35 130.27,107.9 121.25,107.9 120.11,106.75 115.92,106.75 115.58,106.41 112.35,106.41 112.01,106.07 102,106.07 100.38,104.44 95.83,104.44 94.74,103.36 89.79,103.36 89.23,102.79 89.23,102.48 v1(90.09,101.62)
  BOTTOM w0.102: R68341.2 96.36,124.28 96.18,124.1 96.18,123.62 95.52,122.96 92.63,122.96 91.54,121.87 91.54,119.71 90.93,119.1 90.93,118.89
  BOTTOM w0.114: v1(90.09,101.62) 89.26,102.45 89.26,103.08 88.87,103.48 88.87,108.18 91.28,110.59 91.28,111.22 90.93,111.58 90.93,118.89
ESPI_2_R: length 5.1
  BOTTOM w0.102: U6539.DH50 101.49,126.1 101.19,125.8 100.55,125.8 100.48,125.73 99.82,125.73 99.44,125.35 98.52,125.35 97.45,124.28 R68341.1
ESPI_3: length 103.6
  TOP w0.114: v2(156.76,105.23) 155.62,106.37 154.68,106.37 153.91,107.14 U37.7
  IN1 w0.089: v2(156.76,105.23) 155.49,106.5 154.66,106.5 154.48,106.68 150.95,106.68 150.72,106.91 144.24,106.91 143.96,107.18 141.04,107.18 140.67,107.55 136.79,107.55 135.9,108.44 134.83,108.44 134.54,108.73 130.45,108.73 129.9,108.19 121.04,108.19 119.93,107.08 115.74,107.08 115.49,106.83 109.75,106.83 109.49,106.58 102.08,106.58 100.25,104.75 95.63,104.75 94.53,103.65 89.65,103.65 88.82,102.82 v1(88.82,102.69)
  BOTTOM w0.102: 94.94,123.19 95.37,123.62 R68340.2
  BOTTOM w0.114: 94.94,123.19 92.55,123.19 91.28,121.92 91.28,119.83 90.6,119.15 90.6,111.43 90.95,111.07 90.95,110.72 88.54,108.3 88.54,103.3 88.82,103.02 v1(88.82,102.69)
ESPI_3_R: length 5.3
  BOTTOM w0.102: R68340.1 95.78,124.07 96.34,124.63 97.52,124.63 98.43,125.55 99.33,125.55 99.81,126.03 U6539.DJ53
ESPI_CLK: length 96.7
  TOP w0.114: R402.2 150.44,104.85 v2(150.49,104.8) 150.55,104.74 U37.13 152.77,104.74 152.98,104.95 v1(152.98,105.25)
  IN1 w0.089: v1(90.62,102.69) 91,102.31 95.04,102.31 96.26,103.53 102.15,103.53 103.78,105.15 112.54,105.15 112.87,105.48 115.21,105.48 115.34,105.36 116.53,105.36 116.86,105.69 121.23,105.69 122.56,107.02 129.34,107.02 129.47,106.89 133.21,106.89 133.85,106.25 136.18,106.25 136.65,105.79 140.08,105.79 140.46,105.41 144.93,105.41 145.16,105.64 149.54,105.64 149.74,105.43 150.1,105.43 150.19,105.34 150.19,104.89 150.28,104.8 150.46,104.8 150.55,104.89 150.55,105.34 150.63,105.43 150.81,105.43 150.9,105.34 150.9,104.89 150.99,104.8 151.17,104.8 151.26,104.89 151.26,105.34 151.35,105.43 151.52,105.43 151.61,105.34 151.61,104.89 151.7,104.8 151.88,104.8 151.97,104.89 151.97,105.34 152.06,105.43 152.8,105.43 v1(152.98,105.25)
  BOTTOM w0.102: R68339.2 C96700.2 95.96,121.97 95.37,121.38 93.85,121.38 93.59,121.13
  BOTTOM w0.114: v1(90.62,102.69) 90.62,103.43 90.98,103.78 90.98,104.67 90.49,105.16 90.49,108.42 92.37,110.31 92.37,111.5 91.92,111.96 91.92,119 92.25,119.33 92.25,119.78 93.59,121.13
ESPI_CLK_R: length 4.6
  BOTTOM w0.102: R68339.1 98.49,122.42 99,122.93 99,123.8 99.28,124.08 99.87,124.08 99.99,124.2 100.45,124.2 U6539.DN53
ESPI_CS#: length 106.3
  TOP w0.114: U37.6 154.02,107.54 154.86,106.7 156,106.7 157.25,105.46 157.25,104.11 v2(157.45,103.91)
  IN1 w0.089: v1(89.71,102.69) 90.08,103.06 94.91,103.06 95.98,104.14 100.53,104.14 102.15,105.76 112.14,105.76 112.49,106.12 115.44,106.12 115.61,105.95 116.29,105.95 116.79,106.45 121.08,106.45 122.23,107.6 130.49,107.6 130.93,108.05 131.67,108.05 132.05,107.67 135.8,107.67 136.5,106.97 140.19,106.97 141.14,106.02 144.52,106.02 144.8,106.3 150.31,106.3 150.54,106.07 153.79,106.07 154.66,105.2 155.44,105.2 155.9,104.75 156.66,104.75 157.45,103.96 v2(157.45,103.91)
  BOTTOM w0.102: 92.37,122.29 92.76,122.68 R68353.1 93.53,122.68 93.61,122.75 95.63,122.75 96.44,123.57 R68344.2
  BOTTOM w0.114: v1(89.71,102.69) 89.71,103.4 89.19,103.91 89.19,108.04 91.61,110.46 91.61,111.35 91.26,111.71 91.26,119 91.79,119.53 91.79,121.71 92.37,122.29
ESPI_CS#_R: length 4.4
  BOTTOM w0.102: R68344.1 97.17,123.66 98.65,125.14 99.53,125.14 99.91,125.52 100.65,125.52 U6539.DK52
ESPI_RESET#: length 88.5
  TOP w0.114: R894.2 148.31,100.66 148.64,100.99 v1(148.76,100.99)
  IN1 w0.089: v1(146.55,104.8) 146.52,104.76 140.24,104.76 139.82,105.18 136.32,105.18 135.84,105.65 133.61,105.65 132.95,106.31 129.19,106.31 129.07,106.44 122.84,106.44 121.33,104.92 116.95,104.92 116.77,104.75 115.08,104.75 114.96,104.87 113.28,104.87 112.96,104.56 104.2,104.56 102.43,102.79 96.39,102.79 94.81,101.22 91.13,101.22 v1(90.72,101.62)
  BOTTOM w0.102: 92.02,119.43 92.02,120.57 92.69,121.24 R68354.2 93.28,121.24 93.63,121.59 94.81,121.59 95.02,121.79 R68345.2
  BOTTOM w0.114: v1(90.72,101.62) 90.72,101.88 90.17,102.43 90.17,103.91 90.08,103.99 90.08,108.47 91.99,110.39 91.99,111.43 91.59,111.83 91.59,119 92.02,119.43 ; v1(146.55,104.8) 146.63,104.72 146.63,103.88 148.74,101.77 148.74,101.01 v1(148.76,100.99)
ESPI_RESET#_EC: length 4
  TOP w0.114: R894.1 R68864.1 C2374.1 150.01,100.05 150.67,100.71 150.67,100.86 150.95,101.14 U37.22
ESPI_RESET#_R: length 7.7
  BOTTOM w0.102: R68345.1 95.72,122.24 96.49,123.01 97.94,123.01 98.27,123.34 98.67,123.34 98.8,123.47 98.8,123.9 99.18,124.28 99.78,124.28 99.91,124.41 100.21,124.41 100.4,124.6 100.6,124.6 100.66,124.55 101.07,124.55 101.36,124.84 U6539.DL50
FAN1_RPM: length 108.9
  TOP w0.114: v2(208.33,122.07) 208.58,121.82 v2(208.58,121.43) 208.71,121.31 208.71,119.91 211.45,117.17 211.45,113.26 210.99,112.8 210.99,109.12 207.44,105.56 207.18,105.56 206.29,104.67 204.9,104.67 203.91,103.68 202.64,103.68 201.34,102.38 201.34,97.69 198.17,94.51 159.18,94.51 159.06,94.63 U37.47
  IN3 w0.102: v2(208.33,122.07) 208.33,122.32 207.5,123.15 202.67,123.15 200.61,121.08 191.18,121.08 190.91,120.82 187.35,120.82 186.99,121.18 183.64,121.18 183.19,120.73 v2(183.17,120.73)
  BOTTOM w0.114: FAN3.2 181.9,117.18 182.13,117.4 182.13,120.13 182.42,120.42 R25372.2 182.97,120.96 183.17,120.76 v2(183.17,120.73)
FAN_PWM: length 131.4
  TOP w0.114: v2(148.13,95.4) 148.64,94.89 150.67,94.89 151.18,95.4 151.18,96.72 151.6,97.14 U37.32 ; v2(197.66,126.39) 197.28,126.01 v2(197.28,124.1) 197.28,123.8 196.87,123.39 196.87,122.48 197.12,122.22 197.12,117.34 196.5,116.72 196.5,114.44 196.13,114.07 196.13,111.15 195.7,110.72 195.7,108.94 195.91,108.73 195.91,106.55 197.28,105.18 v2(197.4,105.18)
  IN4 w0.089: v2(197.66,126.39) 197.53,126.26 194.74,126.26 194.23,126.77 189.53,126.77 187.85,125.09 180.23,125.09 176.58,121.43 176.58,120.42 176.04,119.88 172.36,119.88 171.24,118.77 167.31,118.77 166.47,117.93 165.47,117.93 164.76,118.64 164.76,120.07 164.41,120.43 164.41,121.41 164,121.82 164,123.34 164.18,123.52 164.21,123.52 v1(164.26,123.57)
  BOTTOM w0.114: v1(164.26,123.57) 164.21,123.57 164.18,123.59 163.75,123.59 163.41,123.94 Q6523.1 ; v2(197.4,105.18) 196.92,104.7 196.92,101.98 196.64,101.7 196.64,99.34 195.83,98.52 175.38,98.52 173.91,97.05 173.4,97.05 171.54,95.19 154.4,95.19 153.62,95.96 152.54,95.96 151.84,96.67 151.43,96.67 151.11,96.35 151.11,95.72 150.59,95.19 148.25,95.19 148.13,95.32 v2(148.13,95.4)
FAN_PWM_C: length 17.9
  BOTTOM w0.114: FAN3.3 179.84,118.43 177.16,121.11 173.35,121.11 171.73,122.73 170.97,122.73 v2(170.23,123.47) 170,123.69 R25373.2 168.48,123.69 168.27,123.9 166.47,123.9 166.16,123.59 Q6523.3
FB_CAL_PD_VDDQ: length 10.5
  TOP w0.381: v2(146.04,181.56) 145.46,182.14 v2(145.46,182.8)
  IN1 w0.381: v1(138.02,184.45) 138.25,184.68 139.36,184.68 139.82,184.22 139.97,184.22 140.41,183.79 142.29,183.79 142.72,183.36 145.13,183.36 145.46,183.03 v2(145.46,182.8)
  BOTTOM w0.381: U8.D22 137.62,184.85 v1(138.02,184.45)
FB_CAL_PU_GND: length 8.4
  TOP w0.114: v2(144.8,182.8) 144.8,182.9 145.36,183.46 v2(145.56,183.46) 145.97,183.05 145.97,182.9 146.13,182.74 R319.2
  IN1 w0.089: v1(139.72,183.64) 140.05,183.64 140.43,183.26 142.03,183.26 142.54,182.75 144.7,182.75 144.75,182.8 v2(144.8,182.8)
  BOTTOM w0.102: U8.C24 139.72,183.65 v1(139.72,183.64)
FB_CAL_TERM_GND: length 5.7
  BOTTOM w0.203: 142.81,183.16 142.49,183.16 141.99,183.65 140.53,183.65 U8.B25
  BOTTOM w0.508: 142.81,183.16 144.22,183.16 144.57,183.51 145.3,183.51
  vias: v2(145.58,183.51)
FBA_CMD0: length 26.5
  IN1 w0.127: v1(161.4,182.02) 161,182.42 161,184.19 157,188.19 146.69,188.19 145.43,186.93 v1(145.43,186.75)
  BOTTOM w0.127: 143.08,183.99 142.95,183.86 142.29,183.86 142.1,184.05 U8.C27 ; VRAM1.G12 161,181.62 v1(161.4,182.02)
  BOTTOM w0.178: 143.08,183.99 143.83,183.99 145.43,185.59 v1(145.43,186.75)
FBA_CMD1: length 31.4
  IN1 w0.127: v1(160.6,179.62) 160.99,180.02 160.99,180.66 161.15,180.82 161.66,180.82 161.8,180.96 161.8,184.07 157.19,188.68 146.42,188.68 144.8,187.06 v1(144.8,186.75)
  BOTTOM w0.127: 143.15,184.43 143.08,184.43 142.93,184.27 142.31,184.27 142.16,184.42 141.3,184.42 U8.C26 ; v1(160.6,179.62) 160.21,180.02 VRAM1.H10
  BOTTOM w0.178: 143.15,184.43 143.51,184.43 144.8,185.71 v1(144.8,186.75)
FBA_CMD2: length 28.9
  IN1 w0.127: v1(138.96,185.29) 139.38,185.71 139.85,185.71 139.89,185.67 140.95,185.67 141.61,186.33 146.33,186.33 147.7,187.71 156.8,187.71 160.14,184.36 160.14,180.88 v1(160.6,180.42)
  BOTTOM w0.127: v1(138.96,185.29) 139.32,185.65 U8.E24 ; VRAM1.H11 160.21,180.82 v1(160.6,180.42)
FBA_CMD3: length 28.2
  IN3 w0.127: v1(159,180.42) 159.52,180.94 159.52,183.57 154.77,188.32 148.02,188.32 147.3,189.05 145.47,189.05 145.27,188.84 143.27,188.84 142.63,188.2 141.49,188.2 140.65,187.36 139.31,187.36 v1(138.92,186.97)
  BOTTOM w0.127: v1(138.92,186.97) 139.32,186.57 U8.F24 ; VRAM1.K11 158.61,180.82 v1(159,180.42)
FBA_CMD4: length 22.6
  IN1 w0.127: v1(143.32,184.91) 143.42,184.81 150.41,184.81 150.65,184.58 157.82,184.58 158.61,183.79 158.61,180.02 v1(159,179.62)
  BOTTOM w0.127: VRAM1.K10 158.61,180.02 v1(159,179.62) ; 143.15,184.85 142.8,184.5 142.41,184.5 142.06,184.85 U8.D27
  BOTTOM w0.14: v1(143.32,184.91) 143.2,184.91 143.15,184.85
FBA_CMD5: length 22.5
  IN1 w0.127: v1(158.2,182.02) 157.8,182.42 157.8,183.84 157.56,184.08 151.65,184.08 151.53,183.96 151.53,183.5 151.43,183.4 151.12,183.4 150.99,183.54 146.48,183.54 145.71,184.3 142.91,184.3 142.64,184.57 v1(142.64,184.91)
  BOTTOM w0.127: v1(158.2,182.02) 157.8,181.62 VRAM1.L12 ; U8.D26 140.92,185.19 141.29,185.57 142.86,185.57 142.99,185.44 142.99,185.26 v1(142.64,184.91)
FBA_CMD6: length 26.4
  IN3 w0.127: v1(158.2,175.62) 157.81,176.02 157.81,176.59 157.03,177.36 156.3,177.36 155.38,178.28 153.88,178.28 151.45,180.71 151.45,183.75 150.26,184.95 145.25,184.95 143.53,186.67 v1(143.53,186.75)
  BOTTOM w0.102: 141.33,186.7 141.09,186.95 140.52,186.95 U8.F25
  BOTTOM w0.127: 143.15,186.32 142.94,186.11 141.59,186.11 141.33,186.38 141.33,186.7 ; v1(158.2,175.62) 158.6,175.23 VRAM1.K4
  BOTTOM w0.14: v1(143.53,186.75) 143.53,186.67 143.18,186.32 143.15,186.32
FBA_CMD7: length 26
  IN3 w0.127: v1(158.2,176.42) 158.2,176.65 157.03,177.82 156.58,177.82 155.64,178.76 154.37,178.76 153.8,179.33 153.8,183.96 152.33,185.43 145.48,185.43 v1(144.16,186.75)
  BOTTOM w0.127: v1(158.2,176.42) 158.6,176.03 VRAM1.K5 ; 143.15,185.8 141.37,185.8 140.92,186.24 U8.F26
  BOTTOM w0.178: 143.15,185.8 143.43,185.8 144.16,186.53 v1(144.16,186.75)
FBA_CMD8: length 31.6
  IN3 w0.127: v1(159,175.62) 159.4,176.02 159.4,177.39 157.6,179.19 157.22,179.19 157,179.41 157,183.75 153.88,186.88 147.42,186.88 146.65,187.65 143.35,187.65 143.13,187.43 142.02,187.43 141.52,186.93 141.52,186.54 140.68,185.69 139.39,185.69 v1(138.93,186.15)
  BOTTOM w0.127: U8.F23 138.53,186.55 v1(138.93,186.15) ; VRAM1.J4 159.4,175.23 v1(159,175.62)
FBA_CMD9: length 33.4
  IN3 w0.127: v1(137.31,186.97) 137.73,186.55 137.73,185.91 137.98,185.67 138.38,185.67 138.51,185.54 138.51,185.1 138.75,184.86 140.68,184.86 141.75,185.92 141.75,186.84 142.12,187.21 146.41,187.21 147.22,186.39 153.68,186.39 156.21,183.86 156.21,179.82 156.15,179.76 156.15,179.44 156.86,178.74 157.41,178.74 159,177.14 v1(159,176.42)
  BOTTOM w0.127: v1(137.31,186.97) 137.68,187.34 U8.G22 ; VRAM1.J5 159.4,176.03 v1(159,176.42)
FBA_CMD10: length 32.8
  IN3 w0.127: v1(138.1,186.97) 138.16,186.97 138.57,186.56 140.82,186.56 141.93,187.66 142.98,187.66 143.43,188.11 146.87,188.11 147.62,187.36 154.28,187.36 157.8,183.84 157.8,181 158.13,180.67 158.13,179.31 160.2,177.24 160.2,176.02 v1(159.8,175.62)
  BOTTOM w0.127: VRAM1.H4 160.2,175.23 v1(159.8,175.62) ; U8.G23 138.48,187.35 v1(138.1,186.97)
FBA_CMD11: length 30.9
  IN3 w0.127: v1(160.6,176.42) 160.6,177.46 158.61,179.45 158.61,183.8 154.57,187.84 147.82,187.84 147.1,188.57 143.37,188.57 142.7,187.89 141.83,187.89 140.91,186.97 v1(139.72,186.97)
  BOTTOM w0.102: U8.G24 139.34,187.35 v1(139.72,186.97)
  BOTTOM w0.127: v1(160.6,176.42) 160.2,176.02 VRAM1.H5
FBA_CMD12: length 28.7
  IN3 w0.127: v1(142.89,186.75) 142.89,186.62 145.05,184.46 150.06,184.46 150.97,183.55 150.97,180.51 153.68,177.8 155.24,177.8 156,177.03 156.61,177.03 156.74,176.91 156.74,175.51 157.01,175.23 158.36,175.23 158.6,174.99 158.6,174.56 158.75,174.42 160.99,174.42 v1(161.4,174.82)
  BOTTOM w0.127: v1(161.4,174.82) 161,174.42 VRAM1.G3 ; 142.84,186.7 142.48,186.34 141.93,186.34 U8.F27
  BOTTOM w0.14: 142.84,186.7 v1(142.89,186.75)
FBA_CMD13: length 35.3
  IN3 w0.127: v2(145.94,189.48) 146.41,189.96 147.07,189.96 148.22,188.81 154.97,188.81 160.04,183.73 160.04,180.84 160.18,180.7 160.18,179.18 161,178.35 161,175.46 160.77,175.23 160.21,175.23 v1(159.8,174.82)
  BOTTOM w0.127: 142.64,188.12 142.55,188.12 142.26,187.83 140.61,187.83 140.13,187.35 U8.G25 ; VRAM1.J2 159.8,174.02 v1(159.8,174.82)
  BOTTOM w0.178: v2(145.94,189.48) 145.94,189.39 145.36,188.81 R315.2 144.39,188.49 144.02,188.12 142.64,188.12
FBA_CMD14: length 27
  IN3 w0.127: v1(146.08,186.78) 146.08,186.75 146.91,185.91 153.31,185.91 155.4,183.82 155.4,180.17 155.52,180.05 155.52,179.53 156.77,178.28 157.22,178.28 158.6,176.9 158.6,175.43 159,175.02 v1(159,174.82)
  BOTTOM w0.127: v1(159,174.82) 159.4,174.43 VRAM1.J3 ; U8.G27 141.82,187.45 142.64,187.45
  BOTTOM w0.178: v1(146.08,186.78) 146,186.86 R316.2 145.23,187.47 145.21,187.45 142.64,187.45
FBA_CMD15: length 25.7
  IN3 w0.127: v1(142.26,186.75) 142.26,186.58 145.46,183.37 149.63,183.37 150.49,182.52 150.49,180.31 153.48,177.31 154.99,177.31 155.59,176.71 155.59,175.64 156.2,175.03 156.2,174.54 156.32,174.42 157.8,174.42 v1(158.2,174.82)
  BOTTOM w0.102: U8.G26 141.23,187.35 141.64,186.94
  BOTTOM w0.127: VRAM1.L3 157.8,174.42 v1(158.2,174.82) ; v1(142.26,186.75) 142.07,186.94 141.64,186.94
FBA_CMD16: length 26.4
  IN1 w0.127: v1(139.72,191.91) 140.17,191.46 142.6,191.46 142.72,191.58 143.3,191.58 143.45,191.43 146.73,191.43 148.07,192.77 148.07,193.86 153.56,199.35 158.42,199.35 158.6,199.17 158.6,197.65 v1(158.17,197.23)
  BOTTOM w0.127: v1(139.72,191.91) 139.69,191.91 139.32,191.54 U8.M24 ; VRAM2.G12 157.8,196.85 v1(158.17,197.23)
FBA_CMD17: length 24.8
  IN1 w0.127: v1(158.2,198.88) 157.78,198.46 153.35,198.46 148.57,193.67 148.57,192.57 146.93,190.94 143.13,190.94 142.88,191.19 139.62,191.19 v1(138.91,191.9)
  BOTTOM w0.127: U8.M23 138.52,191.51 v1(138.91,191.9) ; v1(158.2,198.88) 158.2,198.82 158.6,198.43 VRAM2.H10
FBA_CMD18: length 26
  IN3 w0.127: v1(158.2,198.04) 158.61,197.63 158.61,194.53 157.88,193.8 155.66,193.8 154.06,192.2 146.98,192.2 146.19,191.41 145.81,191.41 144.27,189.87 142.91,189.87 142.66,189.62 141.16,189.62 v1(140.52,190.26)
  BOTTOM w0.102: v1(140.52,190.26) 140.49,190.24 140.05,190.24 139.63,189.83 U8.K24
  BOTTOM w0.127: VRAM2.H11 158.6,197.63 158.2,198.02 v1(158.2,198.04)
FBA_CMD19: length 29.7
  IN3 w0.127: v1(159.76,198.04) 159.47,197.74 159.47,196.77 159.1,196.4 159.1,193.37 158.22,192.49 155.04,192.49 154.26,191.71 147.18,191.71 146.39,190.93 146.01,190.93 144.62,189.53 142.96,189.53 142.8,189.37 140.5,189.37 140.13,189 140.13,188.37 139.97,188.21 139.49,188.21 139.34,188.37 139.34,188.84 138.92,189.26 v1(138.92,189.43)
  BOTTOM w0.102: U8.K23 v1(138.92,189.43)
  BOTTOM w0.127: v1(159.76,198.04) 159.76,198.02 160.17,197.62 VRAM2.K11
FBA_CMD20: length 23.6
  IN1 w0.127: v1(159.8,198.88) 159.75,198.88 158.79,199.83 153.36,199.83 147.57,194.05 147.57,192.98 146.62,192.02 144.05,192.02 143.57,192.49 142.63,192.49 142.24,192.11 v1(142.24,192.03)
  BOTTOM w0.127: VRAM2.K10 160.2,198.43 159.8,198.82 v1(159.8,198.88) ; v1(142.24,192.03) U8.M27
FBA_CMD21: length 27.2
  IN1 w0.127: v1(161.44,197.22) 160.58,198.08 160.58,199.25 159.52,200.32 153.16,200.32 146.54,193.7 146.14,193.7 144.95,192.51 144.24,192.51 143.78,192.98 142.3,192.98 141.88,192.56 141.88,192.53 v1(141.32,191.97)
  BOTTOM w0.127: U8.M26 140.92,191.57 v1(141.32,191.97) ; VRAM2.L12 161.04,196.82 v1(161.44,197.22)
FBA_CMD22: length 27.9
  IN3 w0.127: v1(160.6,202.81) 160.6,202.82 160.21,203.21 158.78,203.21 158.26,202.69 158.26,201.67 157.75,201.16 156.17,201.16 156.14,201.14 151.54,201.14 144.21,193.81 144.21,193.69 143.91,193.39 143.91,191.94 143.4,191.44 140.95,191.44 v1(140.5,191.88)
  BOTTOM w0.127: VRAM2.K4 160.21,203.22 160.6,202.82 v1(160.6,202.81)
  BOTTOM w0.14: U8.M25 140.49,191.88 v1(140.5,191.88)
FBA_CMD23: length 26.2
  IN3 w0.127: v1(160.6,202.03) 160.6,201.09 158.81,199.3 157.03,199.3 156.19,198.46 154.51,198.46 154.49,198.48 152.49,198.48 145.9,191.89 145.7,191.89 144.11,190.3 142.91,190.3 142.5,189.9 141.9,189.9 v1(141.5,190.3)
  BOTTOM w0.127: U8.K26 140.98,189.83 141.45,190.3 v1(141.5,190.3) ; v1(160.6,202.03) 160.6,202.03 160.21,202.42 VRAM2.K5
FBA_CMD24: length 30.5
  IN3 w0.127: v1(159,203.63) 158.62,204.01 157.04,204.01 156.19,203.16 156.19,202.52 155.84,202.18 151.22,202.18 143.69,194.65 141.97,194.65 141.3,193.99 141.3,193.35 140.3,192.35 139.54,192.35 139.3,192.11 139.3,191.61 138.36,190.66 137.92,190.66 137.69,190.42 137.69,189.84 v1(138.1,189.43)
  BOTTOM w0.127: VRAM2.J4 159.4,203.23 v1(159,203.63) ; U8.K22 137.7,189.83 v1(138.1,189.43)
FBA_CMD25: length 30.9
  IN3 w0.127: v1(138.92,188.61) 138.5,189.03 138.5,190.42 139.29,191.21 143.59,191.21 144.3,191.92 144.3,192.09 144.85,192.64 144.85,193.22 144.76,193.31 144.76,193.67 151.74,200.66 156.34,200.66 156.39,200.71 157.93,200.71 158.58,201.35 158.58,202.24 158.75,202.42 159.41,202.42 159.8,202.03 v1(159.8,202.03)
  BOTTOM w0.127: v1(138.92,188.61) 138.52,189.01 U8.J23 ; v1(159.8,202.03) 159.8,202.03 159.41,202.42 VRAM2.J5
FBA_CMD26: length 29.8
  IN3 w0.127: v1(159,202.81) 159.01,202.82 159.65,202.82 160.2,202.27 160.2,201.46 158.53,199.78 156.83,199.78 156.39,199.34 151.79,199.34 145.72,193.27 145.72,192.51 143.9,190.69 140.11,190.69 139.72,190.3 v1(139.72,189.43)
  BOTTOM w0.102: U8.J25 v1(139.72,189.43)
  BOTTOM w0.127: v1(159,202.81) 159,202.82 158.61,203.22 VRAM2.H4
FBA_CMD27: length 28.8
  IN3 w0.127: v1(159,201.99) 159,200.9 158.34,200.25 156.62,200.25 156.24,199.87 151.64,199.87 145.24,193.47 145.24,192.54 143.64,190.94 139.87,190.94 139.32,190.4 139.32,189.24 139.74,188.82 v1(139.74,188.61)
  BOTTOM w0.127: VRAM2.H5 158.6,202.39 158.99,201.99 v1(159,201.99) ; U8.J24 v1(139.74,188.61)
FBA_CMD28: length 25.1
  IN3 w0.127: v1(143.43,192.02) 143.43,193.59 143.73,193.89 143.73,194.01 151.34,201.62 155.94,201.62 157.57,201.62 157.8,201.85 157.8,203.02 157.4,203.42 v1(157.4,203.61)
  BOTTOM w0.127: 142.64,190.24 142.22,189.83 U8.K27 ; v1(157.4,203.61) 157.41,203.61 157.8,204.01 VRAM2.G3
  BOTTOM w0.178: v1(143.43,192.02) 143.43,191.03 142.64,190.24
FBA_CMD29: length 28.5
  TOP w0.178: v1(159,204.41) 159.09,204.49 R317.1
  IN1 w0.127: v1(144.42,193.04) 145.68,194.3 146.46,194.3 152.96,200.8 157.05,200.8 158.56,202.31 158.56,203.78 159,204.22 v1(159,204.41)
  BOTTOM w0.127: VRAM2.J2 159.4,204.82 159,204.42 v1(159,204.41) ; 142.62,189.71 142.36,189.45 140.49,189.45 U8.K25
  BOTTOM w0.178: 142.62,189.71 142.99,189.71 143.97,190.7 143.97,192.59 v1(144.42,193.04)
FBA_CMD30: length 34.6
  IN3 w0.127: v1(159.8,203.63) 159.96,203.63 160.37,204.03 161.61,204.03 161.81,203.84 161.81,200.77 160.98,199.95 160.98,193.6 158.8,191.42 155.33,191.42 154.66,190.75 v1(147.75,190.75)
  BOTTOM w0.127: U8.J27 141.85,189.15 142.64,189.15 ; VRAM2.J3 159.79,203.63 v1(159.8,203.63)
  BOTTOM w0.178: 142.64,189.15 144.37,189.15 144.75,189.54 R314.1 145.36,189.54 145.75,189.93 146.16,189.93 146.73,190.5 147.49,190.5 v1(147.75,190.75)
FBA_CMD31: length 32.9
  IN3 w0.127: v1(160.6,203.63) 160.6,203.62 161,203.22 161,201.72 161.31,201.42 161.31,201.02 160.2,199.92 160.2,197.69 160.1,197.59 160.1,196.01 160.2,195.91 160.2,193.71 158.5,192.01 155.24,192.01 154.46,191.23 147.38,191.23 146.59,190.44 146.21,190.44 145.72,189.95 145.44,189.95 144.69,189.2 143.02,189.2 142.89,189.06 141.73,189.06 v1(141.29,188.63)
  BOTTOM w0.127: U8.J26 141.29,188.65 v1(141.29,188.63) ; VRAM2.L3 160.99,204.02 160.6,203.63 v1(160.6,203.63)
FBA_DBI0: length 37
  IN1 w0.127: v1(135.49,185.24) 135.66,185.06 135.66,182.92 136.38,182.2 136.38,181.44 138.41,179.41 149.34,179.41 152.7,176.04 152.7,174.52 153.06,174.16 155.72,174.16 156.01,173.88 162.49,173.88 163.14,173.22 v1(163.8,173.22)
  BOTTOM w0.165: v1(135.49,185.24) 135.46,185.24 135.14,184.91 U8.D19 ; VRAM1.D2 163.41,173.62 v1(163.8,173.22)
FBA_DBI1: length 38.3
  IN4 w0.127: v1(163,182.82) 163.4,183.22 163.4,184.4 162.16,185.63 160.77,185.63 160.45,185.95 160.45,186.84 159.94,187.35 157.91,187.35 157.36,187.9 150.46,187.9 149.73,187.17 145.74,187.17 145.72,187.15 141.2,187.15 140.61,186.56 135.93,186.56 135.85,186.47 135.2,186.47 135.15,186.53 132.76,186.53 132.66,186.43 132.66,185.85 132.46,185.65 131.8,185.65 v1(131.44,185.29)
  BOTTOM w0.165: VRAM1.D13 163.4,182.42 v1(163,182.82) ; U8.D14 131.02,184.87 v1(131.44,185.29)
FBA_DBI2: length 28.1
  IN4 w0.127: v1(155,182.02) 154.8,181.83 154.07,181.83 153.22,180.97 152.35,180.97 150.57,179.19 135.55,179.19 135.15,179.6 133.78,179.6 133,180.38 v1(133,180.99)
  BOTTOM w0.102: v1(133,180.99) 133.21,181.2 133.21,183.06 133.16,183.11 133.16,183.39 133.5,183.73 U8.C17
  BOTTOM w0.165: v1(155,182.02) 155.4,182.42 VRAM1.P13
FBA_DBI3: length 23.9
  BOTTOM w0.079: VRAM1.P2 155.03,173.99 154.45,173.99 154.33,174.1 152.81,174.1 152.67,174.24
  BOTTOM w0.165: 138,181.32 138,181.92 138.26,182.18 138.26,182.88 138.07,183.08 138.07,183.51 137.62,183.96 U8.C22
  BOTTOM w0.178: 152.67,174.24 152.19,174.72 152.19,175.14 147.97,179.36 139.96,179.36 138,181.32
FBA_DBI4: length 27.8
  IN4 w0.127: v1(139.72,193.48) 140.52,192.68 140.89,192.68 141.01,192.56 144.12,192.56 144.12,192.57 145.31,192.57 146.08,193.34 146.83,193.34 147.24,192.94 152.7,192.94 153.08,193.32 156.76,193.32 157.27,193.82 163.11,193.82 163.39,194.11 163.39,194.99 163.75,195.35 163.75,195.57 v1(163.8,195.62)
  BOTTOM w0.165: v1(163.8,195.62) 163.41,196.02 VRAM2.P13 ; v1(139.72,193.48) 139.38,193.15 U8.P24
FBA_DBI5: length 28
  IN4 w0.127: v1(163.8,204.42) 163.4,204.02 162.64,204.02 161.84,203.22 154.55,203.22 154.53,203.24 150.81,203.24 147.1,199.54 144.57,199.54 143.94,198.9 142.16,198.9 140.96,197.71 v1(140.5,197.71)
  BOTTOM w0.165: v1(163.8,204.42) 163.79,204.42 VRAM2.P2 ; v1(140.5,197.71) 139.76,197.71 U8.W24
FBA_DBI6: length 18.1
  IN1 w0.127: v1(155,204.41) 154.85,204.41 154.27,203.83 152.06,203.83 148.38,200.15 144.6,200.15 144.26,200.49 144.06,200.57 142.3,200.57 141.07,199.35 v1(140.52,199.35)
  BOTTOM w0.165: v1(155,204.41) 155,204.42 155.4,204.82 VRAM2.D2 ; U8.AA25 v1(140.52,199.35)
FBA_DBI7: length 16.7
  BOTTOM w0.079: VRAM2.D13 155.33,196.02 154.96,196.39 154.45,196.39 154.33,196.51 152.73,196.51 152.62,196.62
  BOTTOM w0.165: 142.41,195.72 141.48,195.72 141.14,196.06 140.55,196.06 U8.U25
  BOTTOM w0.178: 152.62,196.62 152.06,197.18 145.02,197.18 143.56,195.72 142.41,195.72
FBA_EDC0: length 36.7
  IN1 w0.127: v1(163.8,174.02) 163.4,174.43 157.14,174.43 157.01,174.56 157.01,175.16 156.76,175.41 156.38,175.41 155.49,176.3 155.49,176.55 154.6,177.44 152.19,177.44 149.69,179.94 138.63,179.94 136.91,181.66 136.91,182.05 135.94,183.02 135.94,185.66 v1(135.53,186.07)
  BOTTOM w0.165: v1(163.8,174.02) 164.2,173.62 VRAM1.C2 ; v1(135.53,186.07) 135.14,185.67 U8.E19
FBA_EDC1: length 38.6
  IN4 w0.127: v1(131.45,184.49) 132.08,184.49 132.43,184.84 133.68,184.84 133.7,184.82 136,184.82 136,184.81 136.68,184.81 136.71,184.84 140.93,184.84 141.62,185.54 141.9,185.54 142.03,185.42 142.03,184.62 142.16,184.49 143.49,184.49 143.89,184.88 145.9,184.88 146.84,185.82 150,185.82 151.01,186.83 156.92,186.83 157.76,185.99 158.83,185.99 160.26,184.55 161.08,184.55 161.8,183.83 161.8,182.65 162.03,182.42 163.4,182.42 v1(163.8,182.82)
  BOTTOM w0.165: v1(131.45,184.49) 131.86,184.07 U8.C15 ; VRAM1.C13 164.2,182.42 v1(163.8,182.82)
FBA_EDC2: length 28.1
  IN4 w0.127: v1(155,182.82) 154.6,182.42 153.74,182.42 153.21,181.89 152.1,181.89 149.94,179.73 135.81,179.73 135.35,180.18 134.22,180.18 133.65,180.75 133.65,181.25 133.4,181.51 132.66,181.51 v1(132.38,181.22)
  BOTTOM w0.102: v1(132.38,181.22) 133,181.85 133,182.6 132.66,182.95 U8.B16
  BOTTOM w0.165: v1(155,182.82) 154.6,182.42 VRAM1.R13
FBA_EDC3: length 23.8
  BOTTOM w0.079: VRAM1.R2 154.44,173.62 154.12,173.94 152.66,173.94
  BOTTOM w0.165: U8.B22 137.62,183.07 137.99,182.69 137.99,182.29 137.71,182.01 137.71,180.95
  BOTTOM w0.178: 137.71,180.95 140.03,178.62 140.71,178.62 140.85,178.49 140.85,178.26 141,178.11 141.41,178.11 141.58,178.29 141.58,178.51 141.7,178.62 142.22,178.62 142.36,178.49 142.36,178.29 142.53,178.11 142.92,178.11 143.1,178.29 143.1,178.48 143.24,178.62 147.66,178.62 152.34,173.94 152.66,173.94
FBA_EDC4: length 27.8
  IN4 w0.127: v1(140.56,193.57) 141.03,193.1 143.72,193.1 144.06,193.44 145.33,193.44 145.77,193.88 147.19,193.88 147.59,193.47 148.15,193.47 148.51,193.82 149.02,193.82 149.37,193.47 149.91,193.47 150.26,193.82 150.79,193.82 151.15,193.47 152.09,193.47 152.24,193.62 152.24,193.95 152.5,194.21 153.13,194.21 153.46,193.88 156.44,193.88 156.92,194.36 161.74,194.36 162.49,195.11 163.12,195.11 163.39,195.38 163.39,196.02 v1(163.8,196.42)
  BOTTOM w0.165: VRAM2.R13 164.2,196.02 v1(163.8,196.42) ; v1(140.56,193.57) 140.49,193.57 140.12,193.94 U8.R25
FBA_EDC5: length 29.6
  IN4 w0.127: v1(138.91,197.76) 138.91,197.77 139.16,197.77 139.52,198.12 140.87,198.12 142.03,199.29 142.03,199.72 142.4,200.09 146.89,200.09 151.62,204.81 159.4,204.81 159.6,204.62 162.5,204.62 162.7,204.82 163.4,204.82 v1(163.8,205.22)
  BOTTOM w0.165: v1(163.8,205.22) 164.2,204.82 VRAM2.R2 ; v1(138.91,197.76) 138.52,197.37 U8.W23
FBA_EDC6: length 16.5
  IN1 w0.127: v1(144.26,201.06) 144.45,201.06 144.83,200.68 148.13,200.68 152.22,204.78 153.08,204.78 153.18,204.87 153.85,204.87 v1(154.2,205.22)
  BOTTOM w0.165: VRAM2.C2 154.2,205.21 v1(154.2,205.22) ; U8.AB26 141.1,199.75 141.5,200.15 143.4,200.15
  BOTTOM w0.178: v1(144.26,201.06) 144.26,200.91 143.5,200.15 143.4,200.15
