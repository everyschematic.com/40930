# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO_OUT: length 71.4
  TOP w0.203: R68299.1 128.57,162.46 128.82,162.71 v2(128.82,162.91) 128.97,163.06 R68310.1 ; R68299.1 R68304.1 ; R68299.1 R68297.1 R68301.1 R68294.1 R68295.1 R68298.1 R68293.1 R68292.1 128.16,169.19 127.96,169.39 125.6,169.39 125.37,169.16 R68296.1 123.72,169.16 123.49,168.93 v2(123.49,168.42) 122.76,169.16 R68303.1 122.12,169.16 121.49,169.79 v2(120.82,169.79) R68307.1 R68306.1 R68302.1 R68300.1
  IN3 w0.203: 118.6,157.94 v1(118.03,157.38) 118.38,157.03 123.07,157.03 123.55,157.5 123.11,157.94 118.6,157.94
  IN3 w0.381: 123.55,157.5 124.12,157.5 124.51,157.88 124.51,159.33 125.22,160.04 128.57,160.04 129.08,160.55 129.08,162.66 v2(128.82,162.91) 127.86,161.95 126.16,161.95 124.63,163.47 124.63,167.28 v2(123.49,168.42)
  IN4 w0.203: v1(128.06,155.72) 126.54,155.72 124.89,154.07 120.19,154.07 119.04,155.22 118.28,155.22 117.52,155.98 117.52,157.12 117.77,157.38 v1(118.03,157.38)
  BOTTOM w0.203: R68291.1 123.74,168.68 v2(123.49,168.42) ; R68308.1 R68311.1 R68309.1 127.93,155.85 v1(128.06,155.72) ; U6539.V15 117.56,157.38 v1(118.03,157.38)
+VCCLDOSTD_OUT_0P85: length 18.6
  TOP w0.203: C96764.2 v2(92.37,115.85) 92.37,116.35 95.55,119.53 102.03,119.53 102.89,118.67 103.63,118.67 103.93,118.97 103.93,120.25 103.8,120.37 v1(103.42,120.37)
  BOTTOM w0.2: U6539.DV46 103.64,121.58 103.64,120.95 103.42,120.74 v1(103.42,120.37)
+VCCPFUSE_3P3: length 23.8
  TOP w0.305: v1(113,116.46) 112.92,116.38 112.92,115.19 v2(112.82,115.08) 112.51,114.77 112.51,114.09 112.48,114.07 R68507.1 R68508.1
  IN2 w0.254: v1(113,116.46) 112.97,116.48 110.03,116.48 108.25,118.26 108.25,122.7 108.85,123.3 109.23,123.3 109.48,123.56 109.48,127.21 109.52,127.24 109.52,128.04 109.26,128.3 109.26,129.88 v1(109.72,130.34)
  BOTTOM w0.254: U6539.CY33 109.65,130.34 v1(109.72,130.34) 109.72,130.28 110.06,129.94 U6539.CY31
+VCCPRIM_3P3: length 34.8
  TOP w0.203: R68496.1 114.6,108.35 114.09,108.86 114.09,109.88 114.31,110.1 R68495.1 114.31,111.11 114.6,111.4 114.6,113.31 v2(114.35,113.56) 114.35,113.66 113.49,114.52 C96758.2 C96761.2 113.49,115.99 113.46,116.02 v1(113.46,116.05)
  IN1 w0.254: v1(111.34,128.95) 110.64,128.95 110.35,129.24 110.35,130.51 110.03,130.83 109.52,130.83 109.25,130.56 109.25,130.06 108.81,129.63 v1(108.81,129.61)
  IN2 w0.254: v1(113.46,116.05) 113.51,116.1 113.51,116.72 113.24,116.99 110.28,116.99 109.39,117.88 109.39,122.42 110.38,123.42 110.38,127.73 110.03,128.09 110.03,128.55 110.43,128.95 v1(111.34,128.95) 111.35,128.96 v1(112.15,128.96)
  BOTTOM w0.2: U6539.DD30 110.96,127.98 v1(111.33,128.27) ; v1(111.34,128.95) 110.93,128.63 U6539.DC30 ; v1(112.15,128.96) U6539.DC28
  BOTTOM w0.254: v1(108.81,129.61) 108.74,129.61 U6539.DA35
+VCCRTC: length 22
  TOP w0.203: v1(108.81,128.96) 108.8,128.95 108.8,128.33 107.67,127.2 107.67,123.47 107.28,123.09 107.28,121.56 107.36,121.48 107.36,118.89 106.01,117.55 106.01,115.93 106.73,115.22 106.73,113.31 106.6,113.18 106.34,113.18 v2(106.09,112.93) 106.09,112.54 105.94,112.39 C96770.2 C96769.2 C96771.2 105.94,110.18 105.7,109.94 R68500.1
  BOTTOM w0.254: U6539.DC35 108.72,128.94 108.77,128.94 108.8,128.96 v1(108.81,128.96)
+VCCST: length 281.6
  TOP w0.203: v1(158.59,138.81) 158.47,138.68 158.47,138.14 158.65,137.95 R68847.1 157.65,137.18 156.76,138.07 156.76,138.58 156.51,138.83 155.67,138.83 155.61,138.9 v2(155.58,138.9) 156.24,139.55 R68842.1 ; R68283.2 119.3,170.33 ; 119.3,170.33 121.71,170.33 122.19,169.85 128.29,169.85 129.71,168.42 v2(129.84,168.42) 130.22,168.04 R68257.1 ; 119.3,170.33 118.41,170.33 117.77,170.96 R68284.2 ; R68487.1 88.03,104.42 87.9,104.29 v1(87.45,104.29) ; Q85.3 110.28,107.1 110.28,106.7 108.5,104.92 108.5,103.78 108.09,103.37 R822.2 107.49,103.65 107.21,103.93 v1(107.21,104.11) ; v2(160.45,150.77) 160.93,151.25 v2(161.21,151.25) 161.36,151.1 PR7001.1
  IN1 w0.203: v2(164.05,118.84) 164.05,117.45 166.44,115.06 169.44,115.06 169.83,115.45 170.98,115.45 171.24,115.72 175.08,115.72 175.59,115.21 v1(175.59,114.68)
  IN2 w0.203: v1(87.45,104.29) 87.96,103.78 100.48,103.78 101.19,104.49 105.89,104.49 106.27,104.11 v1(107.21,104.11) 107.21,104.39 107.39,104.57 108.81,104.57 109.67,105.43 112.85,105.43 113.15,105.13 115.16,105.13 115.41,104.87 121.48,104.87 123.06,106.45 128.42,106.45 129.94,104.92 130.37,104.92 131.72,103.58 138.63,103.58 139.03,103.98 148.53,103.98 148.61,104.06 151.1,104.06 152.8,105.76 154.3,105.76 154.63,106.09 160.37,106.09 161.36,107.08 163.37,107.08 164.1,107.82 166.57,107.82 167.56,108.81 167.56,109.14 168.45,110.03 169.49,110.03 171.11,111.66 171.27,111.66 172.92,113.31 174.21,113.31 v1(175.59,114.68)
  IN2 w0.381: v2(126.11,141.5) v2(126.79,141.5) 127.05,141.5 127.68,140.87 130.04,140.87 130.47,141.3 135.28,141.3 135.38,141.2 138.04,141.2 138.98,142.14 138.98,146.45 139.36,146.83 139.36,151.91 141.12,153.67 141.12,165.91 138.09,168.93 130.09,168.93 129.84,168.68 v2(129.84,168.42)
  IN3 w0.203: v1(158.59,138.81) 158.59,138.88 158.8,139.09 158.8,139.47 159.18,139.85 160.45,139.85 160.95,140.36 160.95,143.91 162.1,145.06 162.1,146.58 160.45,148.23 v2(160.45,150.77)
  IN4 w0.381: v2(155.58,138.9) 155.58,137.4 151.3,133.12 151.3,125.75 152.7,124.36 156.64,124.36 158.67,122.32 160.32,122.32 161.21,121.43 162.22,121.43 163.24,120.42 163.24,119.65 v2(164.05,118.84)
  IN4 w0.508: v2(155.58,138.9) 154.92,138.9 154.53,138.5 152.12,138.5 150.95,137.33 143.94,137.33 143.4,136.8 139.14,136.8 138.6,137.33 135.15,137.33 134.92,137.56 134.92,138.33 134.35,138.9 133.15,138.9 131.57,140.48 127.81,140.48 v2(126.79,141.5) v2(126.11,141.5)
  BOTTOM w0.102: U6539.BT4 U6539.BT2
  BOTTOM w0.203: PC756.1 164.05,118.09 163.47,118.67 PR22.2
  BOTTOM w0.254: PC756.1 164.34,118.52 164.05,118.82 v2(164.05,118.84)
+VCCST_EN: length 2.6
  TOP w0.114: U6560.4 169.73,139.07 169.88,138.93 170.68,138.93 v2(170.71,138.96) 170.73,138.99 R68840.1
+VCCST_S2: length 16.5
  TOP w0.114: R68842.2 v2(158,139.34) 158,138.49 v1(157.53,138.02)
  IN3 w0.102: v1(157.53,138.02) 158.16,137.39 160.02,137.39 161.89,139.26 162.66,139.26 164.49,141.09 165.81,141.09 v2(166.21,141.5)
  BOTTOM w0.203: v2(166.21,141.5) 165.91,141.2 C96896.1 166.3,140.75 166.51,140.96 C96895.1 167.21,140.96 167.37,140.8 Q6609.1
+VCCSTG: length 154.1
  TOP w0.508: v2(206.04,125.09) 205.63,125.5 205.28,125.5 205.27,125.49 R68830.1 R68833.1
  IN2 w0.508: v2(128.95,168.17) 128.95,168.04 129.28,167.71 136.39,167.71 140.38,163.73 140.38,154.07 138.65,152.35 138.65,147.77 137.97,147.09 137.21,147.09 136.32,146.2 136.32,143.79 134.54,142.01 131.24,142.01 129.59,143.66 126.54,143.66 v2(125.65,142.77) v2(124.89,142.77) ; v2(206.04,125.09) 205.51,125.63 199.31,125.63 198.17,124.48 194.99,124.48 194.48,124.99 192.07,124.99 190.16,123.09 188.39,123.09 187.75,123.72 187.75,123.97 186.48,125.24 180.13,125.24 179.24,126.13 175.43,126.13 172.89,128.67 169.46,128.67 168.7,127.91 159.43,127.91 156.64,130.71 156.64,132.1 155.11,133.63 152.62,133.63 151,135.25 145.36,135.25 144.7,135.91 v2(144.7,138.66)
  IN4 w0.508: v2(124.89,142.77) v2(125.65,142.77) 126.28,143.41 128.47,143.41 130.63,141.25 131.9,141.25 133.42,139.72 134.67,139.72 135.17,139.21 138.96,139.21 140.1,138.07 143.02,138.07 143.61,138.66 v2(144.7,138.66)
  BOTTOM w0.203: v2(128.95,168.17) 128.47,168.17 128.34,168.3 R68277.2
  BOTTOM w0.508: v2(127.18,172.74) R69058.2 127.81,171.85 128.95,170.71 v2(128.95,168.17)
+VCCSTG_FUSE: length 17.8
  TOP w0.203: v1(118.55,154.74) 119.54,153.75 122.57,153.75 122.78,153.54 130.39,153.54 131.28,154.43 C96592.1 132.2,154.43 C96589.2 C96643.2 133.52,154.12 v2(134.09,154.7) 133.78,155.01 R68282.2
+VCCSTG_OUT_FUSE: length 18.2
  TOP w0.203: R68281.2 134.97,154.91 134.54,155.34 133.95,155.34 133.69,155.6 132.81,155.6 v2(132.51,155.9) 132.43,155.83 132.43,155.02 R68282.1 131.93,155.01 131.75,154.84 131.16,154.84 130.22,153.9 122.94,153.9 122.73,154.1 120.41,154.1 120.24,154.28 v1(120.24,154.74)
  BOTTOM w0.2: U6539.AF9 119.94,154.46 120.22,154.74 v1(120.24,154.74)
+VCCSTG_OUT_LGC: length 10.4
  TOP w0.203: R68280.1 120.84,166.8 120.24,166.8 120.18,166.75 120.16,166.75 v2(119.43,166.01) 118.54,165.12 118.54,162.84 119.08,162.3 119.08,161.9 119.39,161.59 120.42,161.59 v1(120.87,161.14)
  BOTTOM w0.203: v1(120.87,161.14) 120.53,161.14 120.07,160.69 U6539.M9
+VCCSTG_S2: length 5.7
  TOP w0.381: R68830.2 204.62,122.6 v2(205.4,121.82) 205.8,121.82 v2(207.31,120.31)
  BOTTOM w0.381: v2(207.31,120.31) Q6607.1
+VCCSTG_TERM: length 122.2
  TOP w0.203: Q6654.2 87.05,127.29 86.28,126.51 v1(86.28,125.9) ; v1(121.58,168.75) 121.33,168.5 R68280.2
  IN2 w0.203: v1(102.15,173.63) 102.15,176.81 99.36,179.6 96.06,179.6 95.3,178.84 94.41,178.84 93.64,179.6 90.47,179.6 89.96,179.09 88.69,179.09 86.79,177.19 79.8,177.19 79.61,177 v1(79.61,174.96) ; v1(121.58,168.75) 120.49,168.75 119.93,169.31 118.03,169.31 117.14,170.2 117.14,171.6 116.76,171.98 116.56,171.98 116.53,171.95 v1(116.5,171.95)
  IN4 w0.203: v1(116.5,171.95) 116.28,171.73 111.93,171.73 111.81,171.85 103.42,171.85 102.15,173.12 v1(102.15,173.63)
  BOTTOM w0.203: v2(117.9,173.38) 118.92,173.38 119.3,173 R68270.2 R68261.2 120.06,173 120.31,173.25 123.49,173.25 124.03,172.71 R68259.2 125.92,172.71 126.4,172.23 R69058.1 ; v2(117.9,173.38) 117.93,173.35 R68266.2 ; v2(117.9,173.38) 117.39,173.38 116.86,172.84 116.86,172.31 v1(116.5,171.95) 116.53,171.95 116.53,171.95 R68263.2 ; v1(79.61,174.96) 79.61,174.08 80.56,173.12 80.56,131.59 86.25,125.9 v1(86.28,125.9)
+VDD_IO: length 16.1
  TOP w0.114: 69.42,97.43 v2(68.37,97.43)
  TOP w0.508: v2(59.81,98.07) 59.81,98.65 60.5,99.34 61.77,99.34 61.9,99.21 R67562.1
  IN4 w0.508: v2(59.81,98.07) 60.44,97.43 67.51,97.43 v2(68.27,98.19) 68.3,98.22 v2(68.93,98.22)
  BOTTOM w0.305: CN58.15 60.7,98.96 v2(59.81,98.07)
+VDD_SIM: length 3.7
  TOP w0.114: v2(63.05,100.09) R67562.2
  TOP w0.508: v2(63.05,98.07) 63.05,98.22 63.05,98.22 R67562.2
  BOTTOM w0.114: CN58.10 63.2,98.22 v2(63.05,98.07)
+VDDQ: length 101.3
  TOP w0.508: v2(46.96,172.44) 47.01,172.49 v2(47.76,172.49) ; PC5013.1 88.65,171.56 88.44,171.35 v2(88.44,171.01) ; v2(43.84,124.1) 43.99,124.1 44.35,124.46 R67574.2 44.62,125.42 R67575.2
  IN4 w0.508: v2(47.76,172.49) 46.41,172.49 44.64,170.72 44.64,124.5 44.24,124.1 v2(43.84,124.1) ; v2(64.94,176.43) 67.61,176.43 69.74,174.29 80.03,174.29 83.06,171.26 88.14,171.26 88.39,171.01 v2(88.44,171.01)
  BOTTOM w0.508: v2(47.76,172.49) 47.76,174.77 48.42,175.44 64.72,175.44 64.94,175.66 v2(64.94,176.43)
+VDDQ_VTT: length 100.8
  BOTTOM w1.524: 55.73,102.26 59.46,102.26 60.06,101.65 67.56,101.65 69.26,103.35 69.26,107.49 70.66,108.89 70.66,126.82 72.64,128.8 72.64,166.06 69.77,168.93 69.77,175.28 70.73,176.25 81.2,176.25
  vias: v2(46.5,104.44) v2(47.24,104.44) v2(54.97,105.03) v2(55.76,105.37) v2(56.43,105.81) v2(83.54,176.43) v2(83.61,174.96)
+VIN: length 3.5
  TOP w0.114: PR2.2 77.39,201.03 77.39,203.45 77.54,203.6 PR3.2
  vias: v2(60.12,183.54) v2(79.17,201.47) v2(79.17,200.81) v2(79.93,201.47) v2(79.93,200.81) v2(151.3,122.51) v2(151.89,122.09) v2(152.1,122.73) v3(54.05,186.92) v3(54.05,186.15) v3(54.81,186.94) v3(54.81,186.18) v3(55.65,186.94) v3(55.65,186.15) v3(150.5,122.18) v3(152.09,120.76) v3(152.3,121.5) v3(152.59,122.21) v3(153.36,122.34) v3(171.85,127.91) v3(171.85,127.15) v3(171.85,126.39) v3(172.61,127.91) v3(172.61,127.15) v3(172.64,126.39) v3(173.38,127.15) v3(173.36,126.09) v3(173.93,126.62)
+VIN_BLIGHT:
  vias: v2(77.26,192.3)
+VIN_VCCIN_AUX:
  vias: v2(157.53,131.72)
+VIN_VCORE:
  vias: v2(153.33,142.9) v2(154.22,151.28) v3(157.02,156.49) v3(157.02,155.6) v3(157.02,154.71) v3(157.73,156.11) v3(157.73,155.11) v3(158.36,156.61) v3(158.41,155.62) v3(158.41,154.71)
+VIN_VGPU_CORE1: length 8.1
  TOP w0.254: PJ9008.1 93.38,196.08 92.6,195.3 92.6,194.86 93.49,193.97 94.24,193.97 94.31,194.03 94.92,194.03 PR9000.1
  vias: v2(94.91,201.19) v3(96.31,203.48) v3(96.31,202.71) v3(96.31,201.95) v3(96.31,201.19) v3(97.07,203.48) v3(97.07,202.71) v3(97.07,201.95) v3(97.07,201.19)
+VIN_VGPU_CORE2:
  vias: v2(108.48,189.38) v2(108.91,189.89) v2(109.01,188.69) v2(109.34,189.38) v2(109.77,189.89) v2(110.21,189.38) v2(110.66,189.89)
AVDD2: length 5.8
  BOTTOM w0.203: U20.40 19.11,36.14 18.87,36.39 18.87,37.46 18.71,37.61 17.06,37.61 C845.1
  BOTTOM w0.508: C845.1 15.82,38.01 L28.2
DVDD_IO: length 8.7
  BOTTOM w0.203: R462.1 28.81,28.66 28.76,28.61 R460.1 28.11,28.98 28.21,29.08 C584.1 28.21,30.09 28.23,30.11 C585.1 27.98,30.88 26.18,30.88 26.08,30.78 25.42,30.78 25.24,30.96 24.48,30.96 24.03,31.41 U20.9
GND: length 1820.4
  TOP w0.079: v2(156.74,214.4) 155.36,214.4 U6516.C3
  TOP w0.114: 162.61,152.04 162.58,152.02 ; 15.4,131.45 C614.2
  TOP w0.178: v5(23.67,61.24) 23.67,61.36 23.22,61.81 U6549.B1 U6549.B2 ; v5(23.79,66.08) 23.21,65.49 U6549.K1 U6549.K2 ; v5(17.66,64.57) 17.66,64.57 U6549.H12 U6549.H11 ; U6549.F2 U6549.F1 23.58,63.65 23.66,63.58 v5(23.82,63.58) ; v5(23.82,62.43) 23.52,62.73 U6549.D1 U6549.D2 ; U6549.B12 18.02,61.81 17.66,61.45 v5(17.66,61.3) 17.66,61.27 17.84,61.09 18.45,61.09 18.57,61.22 U6549.A11 U6549.B11 ; U6549.M3 22.25,66.86 v5(22.3,66.9) 22.45,66.9 22.71,66.64 U6549.M2 ; PR7034.2 167.68,147.19 PR7033.2
  TOP w0.203: U6549.F3 21.64,64.19 v5(21.6,64.19) U6549.F5 ; v2(18.87,72.03) v2(19.53,72.03) 21.54,72.03 21.92,71.65 v1(21.92,69.34) 21.92,68.74 21.53,68.35 21.45,68.35 20.61,67.51 20.16,67.51 20.11,67.46 v1(20.09,67.46) ; v2(18.87,72.03) 18.87,71.24 Y8.2 18.64,71.02 17.67,71.02 ; v2(18.87,72.03) v2(18.21,72.03) 17.98,72.03 17.67,71.73 17.67,71.02 ; C96670.2 88.03,129.46 v1(88.06,129.44) ; C96680.2 91.24,160.71 v1(91.21,160.68) ; v2(150.36,103.58) 150.06,103.58 149.88,103.75 C6610.1 ; v1(202.48,117.63) 201.88,118.23 R68836.2 201.88,119.12 201.71,119.29 Q6608.4 ; v5(19.03,65.5) U6549.J9 ; U37.27 v2(153.14,99.14) ; v2(24.68,130.71) 24.86,130.53 C96568.1 ; C96725.2 138.54,152.83 PR7058.1 ; C633.2 21.66,172.47 v2(21.59,172.39) ; C6568.1 167.79,96.42 v2(167.18,95.81) ; v1(124.02,186.06) 124.02,187.12 124.28,187.38 R398.1 ; R68498.2 124.48,128.65 124.61,128.78 v1(124.61,128.88) ; U6562.3 168.56,143.93 169.08,143.41 169.08,141.91 168.93,141.75 C96891.2 C96897.2 ; R68613.2 15.7,59.87 15.41,59.59 15.41,58.95 v1(15.67,58.7) 16.17,59.2 R68597.2 ; 89.33,110.11 90.32,110.11 90.47,110.26 v2(90.47,110.89) 90.4,110.96 Y7.2 89.33,110.11 ; 89.33,110.11 86.3,110.11 86.2,110.21 C96784.1 85.49,110.54 85.39,110.64 C96778.2 85.93,110.85 v2(86.02,110.94) ; v1(124.65,160.82) 124.63,160.82 124.52,160.93 R68321.2 ; v2(112.69,169.95) C96645.2 ; v1(10.7,64.09) 10.64,64.03 10.64,63.42 R68673.1 ; C20121.2 66.81,161.6 66.68,161.47 v2(66.68,161.25) ; 15.4,131.45 D13089.1 13.89,131.45 v2(13.82,131.52) ; C96837.2 33.8,70.42 C96901.1 ; v2(120.4,165.85) 120.68,166.14 122.09,166.14 122.35,166.39 R68320.2 R68312.1 ; C457.1 116.09,196.13 v2(116.26,196.3) ; R68412.2 128.22,127.81 v1(127.93,127.53) ; C96657.2 93.51,137.92 v1(93.59,137.99) ; C96567.1 22.93,130.42 22.65,130.71 v2(22.65,131.09) ; v1(109.51,110.51) 109.52,110.52 109.52,110.77 109.8,111.05 R68471.1 ; v2(152.7,214.27) 151.68,214.27 151.53,214.12 C842.2 ; C96828.1 v2(26.28,75.46) ; C20047.1 210.77,99.12 C20046.2 ; C459.1 126.31,193.35 v2(126.35,193.38) ; C641.2 19.63,172.49 v2(19.73,172.39) ; v1(92.21,153.54) 92.21,153.56 92.5,153.85 C96654.2 C96651.2 C96692.2 90.85,153.64 v1(91,153.5) ; v2(55.16,125.43) 55.19,125.39 C256.2 ; C483.1 154.08,175.69 v1(154.19,175.58) ; v1(92.54,152.46) 92.5,152.41 C96677.2 ; v2(126.92,167.89) 126.89,167.92 R68325.2 R68331.2 ; v1(133.39,196.54) 133.65,196.8 C410.1 ; R68375.2 117.65,114.7 117.72,114.63 v1(117.72,112.16) ; v2(54.63,121.73) 55.02,121.35 55.11,121.35 55.4,121.07 R25614.1 ; v2(156.26,210.74) 155.98,210.46 C20141.2 ; v1(22.98,97.46) 23.29,97.46 23.31,97.43 23.74,97.43 23.9,97.59 R414.1 ; v2(118.02,166.03) 117.65,166.4 117.65,166.87 117.52,167 R68432.1 R68322.2 R68317.2 ; C698.2 128.77,98.76 C699.2 127.8,98.46 128.06,98.19 v2(128.06,97.94) ; v2(55.79,159.85) 55.79,159.55 55.95,159.38 C20104.2 ; 162.58,152.02 PC7001.1 ; v2(28.24,131.34) 28.34,131.24 R68199.2 ; v1(92.24,143.95) 92.25,143.96 C96696.2 ; v1(129.68,197.76) 129.53,197.92 C402.2 128.77,197.92 C395.2 ; v5(17.66,63.64) 17.67,63.65 U6549.F12 U6549.F11 ; D13154.2 13.19,69.1 v1(13.43,68.86) ; D13154.2 12.87,68.55 v1(12.9,68.53) ; D13154.2 12.4,69.1 v1(12.29,68.98) ; R68773.1 109.27,115.69 v1(109.27,115.8) ; C354.2 143.05,208.2 v2(143.48,207.77) ; v1(159,206.02) 159.14,205.89 C481.1 ; C20050.1 215.59,102.28 215.72,102.41 C20051.2 ; v2(23.54,76.6) 23.89,76.96 C96930.1 ; v2(54.66,145.31) 54.78,145.31 55.04,145.06 C20103.2 ; C20041.2 224.43,97.84 225.22,97.05 v2(225.22,96.92) ; v2(89.05,174.55) 89.1,174.49 PU5001.1 ; v1(120.87,126.43) 121.42,125.88 121.97,125.88 122.2,126.11 R68443.1 ; v2(115.36,186.79) 115.33,186.82 R394.2 ; v2(13.66,148.2) C900.1 ; v2(116.58,167.32) 116.1,167.32 115.97,167.44 C96629.2 ; v1(11.12,61.59) 10.79,61.93 R68672.1 ; R416.2 18.05,101.19 v2(17.72,100.85) ; C494.1 157.33,181.15 v1(157.4,181.22) ; v1(90.03,129.4) 90.09,129.33 C96668.2 C96691.2 ; v1(129.47,194.65) 129.69,194.87 C351.1 ; Q6509.1 141.34,97.21 141.46,97.08 R25298.1 ; v1(11.15,70.86) 10.89,70.61 R68666.1 10.56,70.63 v1(10.56,71.14) ; v1(91.38,138.78) 91.36,138.76 C96686.2 ; v2(159.71,96.69) 159.86,96.55 U37.49 ; R68395.2 R68540.2 v1(119.17,113.35) ; D13153.2 12.61,70.62 v1(12.34,70.89) ; D13153.2 v1(12.87,71.19) ; D13153.2 13.14,70.62 v1(13.41,70.89) ; R68672.1 10.39,61.93 10.08,61.62 v1(10.08,60.86) ; R68672.1 v1(10.59,61.29) ; v1(98.6,108.38) 98.6,107.97 R68474.1 ; C96890.2 209.69,113.9 209.85,114.06 v2(209.85,114.98) ; v1(11.17,68.86) 11.15,68.86 10.86,69.14 R68667.1 ; v1(135.57,197.6) 135.2,197.6 135,197.81 C362.2 ; v1(129.56,190.71) 129.83,190.98 C365.1 ; v2(79.67,95.4) 80.15,95.88 C212.2 ; C6569.2 C6565.2 169.11,107.92 168.68,107.49 v2(168.68,107.44) 168.58,107.54 U37.91 ; v2(126.79,166.04) 126.77,166.01 R68326.2 R68327.2 ; 17.67,71.02 17.67,68.5 17.85,68.33 R68611.2 18.11,68.09 v1(18.33,68.32) 18.33,68.22 18.46,68.09 C96815.1 18.77,67.8 v1(19.05,67.52) ; C20044.2 224.43,101.61 v2(224.59,101.77) ; v1(131.36,135.28) 131.36,135.53 131.11,135.79 R68264.1 ; C96562.1 20.74,121.17 20.9,121.34 C96563.1 ; R68211.2 27.32,130.27 v2(26.97,129.92) ; v1(104.24,128.47) 104.34,128.58 R68483.2 ; C398.2 125.52,189.61 125.65,189.73 v1(126.13,189.73) ; v2(30.4,62) 30.27,62.13 29.89,62.13 29.74,61.97 R68876.1 ; v2(190.62,119.4) 190.45,119.23 R676.2 ; v2(123.83,166.23) 123.86,166.25 124.1,166.25 124.23,166.38 R68333.2 ; v1(122.3,120.39) 121.87,119.96 R68937.1 ; C20053.2 224.91,95.12 225.22,95.43 v2(225.22,96.16) ; v1(119.04,167.28) R68329.2 R68330.2 ; R68256.1 92.45,167.79 v1(92.83,167.41) ; v2(83.43,95.53) 83.65,95.74 C744.2 C741.2 ; v1(90.16,138.79) 90.09,138.73 C96653.2 ; C254.2 47.54,130.83 v2(48.05,130.32) ; v1(80.56,107.9) 80.56,107.72 80.77,107.51 C96780.1 C96783.1 ; C478.1 165.37,175.65 v1(165.4,175.62) ; R338.2 R68934.1 93.39,122 93.47,122.07 v1(93.75,122.07) ; v1(17.11,69.97) 17.16,69.93 R68612.2 ; C96919.1 232.61,121.41 232.33,121.69 v2(231.95,121.69) ; v2(55.78,114.01) 55.78,114.17 56.13,114.53 C20120.2 ; v1(91.23,147.85) 91.2,147.88 C96664.2 C96683.2 ; v1(10.59,68.65) R68667.1 ; R68667.1 10.29,69.14 10.03,68.88 v1(10,68.88) ; R68332.2 R68328.2 126.66,164.11 126.69,164.13 v2(126.79,164.13) ; C96655.2 88.69,130.6 v1(88.72,130.58) ; C96814.1 20.54,68.09 v1(20.77,68.32) ; R68990.2 158.16,216.56 158.45,216.84 v2(158.45,217.07) ; v2(140.46,211.7) 140.49,211.73 R25624.2 ; v1(161.4,198.88) 161.4,198.88 C482.1 ; R69072.2 78.64,116.21 v1(78.4,115.97) ; v2(116.62,192.99) 115.82,193.79 C456.2 ; C697.2 129.72,97.82 129.76,97.86 v2(129.76,97.94) ; v1(11.12,63.65) 10.84,63.37 R68673.1 ; R68374.2 113.69,117.14 113.94,116.89 113.94,116.68 v1(114.01,116.61) 113.94,116.53 C96761.1 C96758.1 ; C6562.1 147.52,105.41 147.16,105.05 v1(147.16,104.8) 147.09,104.72 C6571.2 ; PR5014.2 88.97,173.2 v2(88.84,173.33) ; v1(157.4,202.03) 157.51,202.13 C480.1 ; v2(26.84,171.98) 26.43,171.57 R4009.2 ; C96682.2 90.34,144.03 v1(90.4,143.97) ; U6515.8 141.65,216.3 141.78,216.43 C20133.2 141.4,216.84 141.27,216.96 v2(141.27,217.18) ; C96884.2 205.6,108.51 205.8,108.71 205.8,109.23 v2(205.79,109.24) ; R243.2 46.84,126.05 v2(47.11,125.78) ; C6580.1 v2(169.31,112.57) ; U6515.9 141.15,216.55 v2(140.51,217.18) ; v2(23.44,162.17) R510.1 ; C96574.1 92.76,117.37 93.14,117.75 93.14,118.26 93.7,118.82 v2(93.7,119.4) ; v2(146.25,98.24) 146.25,97.79 147.75,96.29 148.64,96.29 148.89,96.03 R890.2 ; v5(19.65,64.87) U6549.G7 ; R68492.2 91.1,104.92 90.98,105.05 v1(90.98,105.48) ; v1(122.4,130.29) 122.4,130.29 122.4,129.23 122.83,128.8 R68422.1 ; v1(104.82,112.8) 104.79,112.77 C96772.1 105.36,112.16 C96770.1 C96769.1 C96771.1 ; D13163.2 19.06,89.27 v2(19.45,88.87) ; R68515.1 R68521.1 125.24,117.65 v1(125.6,118.01) ; v2(222.96,103.28) 222.41,102.74 C20048.2 221.57,102.74 C20049.1 ; U6549.L12 17.8,65.95 17.68,66.08 17.68,66.09 v5(17.65,66.11) 17.68,66.14 17.68,66.16 17.92,66.41 U6549.M12 ; v2(30.53,120.16) R68202.2 ; v1(130.98,125.57) 131.21,125.8 R68385.2 ; C96571.1 32.38,127.39 32.19,127.39 31.89,127.69 C96570.1 C96569.1 ; R68561.1 83.99,108.35 83.74,108.1 v2(83.74,106.24) ; R68470.1 85.04,121.02 84.78,121.28 R68482.2 83.46,121.28 83.26,121.08 82.7,121.08 82.61,121.17 v1(82.58,121.17) 82.57,121.17 82.53,121.21 C96905.2 ; C353.1 134.94,191.76 v1(134.81,191.64) ; v2(27.74,170.99) 27.51,170.76 R67477.1 ; v1(122.32,118.01) 122.32,117.98 122.35,117.95 R68517.1 R68528.1 ; C20043.2 v2(209.9,97.94) ; v1(10.16,63.8) 10.16,63.55 10.34,63.37 R68673.1 ; R678.2 186.13,120.25 v1(185.73,120.65) ; R68918.1 110.66,109.11 v1(110.44,108.89) 110.5,108.83 R825.1 ; v2(203.63,114.75) 204.04,114.34 C96883.2 ; v1(89.63,104.37) 89.56,104.44 C96719.2 R68494.2 ; C441.1 165.99,194.62 v1(166.2,194.82) ; C96694.2 90.47,132.41 v1(90.52,132.37) ; C263.2 44.02,145.03 43.8,145.25 v2(43.8,145.48) ; v1(154.2,194.82) 154.25,194.87 C477.1 ; U6549.H2 U6549.H1 23.57,64.57 v5(23.8,64.79) ; v2(153.21,209.24) 153.24,209.27 C20140.1 ; C399.2 145.08,208.53 145.21,208.65 v2(145.21,208.68) ; v2(64.14,103.66) 64.39,103.91 C20106.1 C20109.1 ; v2(29.13,147.6) 29.41,147.88 C20011.1 ; v2(17.8,159.38) 17.22,159.38 16.68,159.92 C96305.2 ; C631.2 27.1,168.93 v2(27.22,168.81) ; v2(66.67,185.44) 66.97,185.75 C6616.1 ; v1(120.92,142.84) 120.9,142.87 R68480.1 ; C1217.2 80.56,104.26 80.31,104.51 v1(80.31,104.87) C1211.2 79.83,105.59 79.62,105.38 Q6520.1 79.29,104.44 R409.1 ; C96777.2 85.82,113.1 v2(86,112.93) ; U37.1 150.86,109.54 150.54,109.22 v2(150.54,108.91) ; C371.2 126.54,185.34 v1(126.46,185.27) ; v2(61.13,98.07) 61.13,97.81 60.32,97 59.38,97 59,96.62 R67555.2 ; U6549.D11 U6549.D12 v5(17.66,62.73) ; PR5019.2 v2(91.26,173.33) ; R68989.2 155.08,216.78 v2(154.73,216.43) ; C695.2 133.57,98.68 133.62,98.62 133.62,97.99 v2(133.68,97.94) 133.68,97.71 133.64,97.68 C696.2 ; C96557.1 C96556.1 18,124.64 v2(17.7,124.36) ; PC5019.2 89.48,179.76 89.32,179.59 PR5005.1 ; R68620.2 21.99,59.2 v2(21.99,58.44) 22.27,58.44 22.53,58.7 R68877.1 ; R68855.2 166.39,139.31 v1(166.26,139.19) ; C96301.2 23.77,173.6 24.02,173.86 v2(24.02,174.23) ; v2(145.84,212.24) 146.35,212.75 146.98,212.75 147.24,212.49 147.24,211.35 147.39,211.19 C841.2 ; C20006.1 14.27,161.19 15.08,162 v2(15.29,162) ; v5(19.03,64.2) U6549.F9 ; C460.1 126.31,191.15 v1(126.43,191.03) ; v1(157.4,198.06) 157.32,198.14 C495.1 ; R25316.2 R25303.2 166.06,113.66 v2(166.34,113.94) ; v1(91.78,150.62) 91.78,150.53 91.38,150.14 C96688.2 ; C559.1 70.12,193.95 70.05,194.03 v1(70.02,194.03) ; R69096.2 26.94,84.45 27.35,84.86 v2(27.6,84.86) ; C96625.1 133.72,152.3 133.4,152.63 v2(133.4,152.8) ; 45.74,118.26 46.37,118.26 v2(46.43,118.32) ; v1(157.4,176.42) 157.38,176.4 C496.1 ; v1(162.99,194.59) 162.89,194.49 C442.1 ; R68626.2 22.24,72.82 C96829.2 ; C271.2 C269.2 52.4,102.84 v2(52.52,102.72) ; C20135.2 135.46,211.89 135.2,211.63 v2(134.52,211.63) ; v1(211.78,103.15) 211.5,103.43 R69049.2 ; v1(131.44,186.07) 131.74,186.37 131.74,186.58 131.87,186.71 C455.1 ; C96796.1 169.38,98.07 168.98,98.47 v2(168.98,98.68) ; R68458.2 108.58,131.72 107.95,131.09 C96768.1 108.2,130.83 108.7,130.34 v1(108.8,130.34) ; v2(168.27,148.61) 168.11,148.77 R68851.1 ; R68473.1 91.26,120.45 v1(90.85,120.04) 90.6,120.29 R68933.1 ; v2(166.67,147.85) 166.75,147.93 C96894.2 ; v2(131.36,163.73) 131.11,163.47 R68246.2 ; v2(55.43,109.98) 55.39,110.02 C260.2 ; v1(135.4,194.69) 135.88,194.2 C439.1 ; U67.24 27.85,151.28 v2(27.65,151.08) 27.48,150.91 C20022.1 26.99,150.28 26.94,150.23 C20021.1 25.65,150.23 ; R68499.2 125.11,130.12 v1(125.19,130.2) ; C96665.2 C96674.2 92.65,142.24 92.79,142.1 v1(92.79,141.77) ; C638.1 28.41,168.17 v2(28.28,168.04) ; v1(13.41,63.65) 13.14,63.38 D13156.2 ; R68557.2 80.56,117.37 80.7,117.51 81.45,117.51 ; v2(112.69,172.23) 112.54,172.23 112.42,172.11 C96635.2 ; C252.2 43.87,138.74 v2(43.85,138.76) ; v1(88.68,132.37) 88.69,132.39 C96693.2 ; R68227.1 91.64,124.2 v1(91.66,124.18) 91.87,123.97 R68427.2 ; v1(90.62,130.58) 90.5,130.71 C96648.2 ; R25534.2 34.24,146.1 34.01,145.87 v2(34.01,145.56) ; v2(89.25,169.06) 89.15,168.96 R68255.1 ; v1(92.76,161.82) 92.73,161.85 C96679.2 ; v1(166.2,183.62) 166.1,183.52 C491.1 ; R68376.2 v1(123.49,114.2) 123.49,114.32 123.72,114.55 R68543.2 ; C96776.1 76.62,117.6 v1(76.37,117.34) ; C20039.2 225.09,93.24 v2(225.47,92.86) ; C20002.1 68.27,186.23 68.5,186.46 v1(68.5,187.47) ; v1(18.71,58.57) 18.69,58.57 18.57,58.7 R68603.2 ; v1(91.71,129.56) 91.62,129.46 C96673.2 ; v2(26.59,168.3) 26.46,168.3 26.18,168.01 C20000.2 ; v2(66.61,110.28) 66.82,110.5 C20113.2 ; C96695.2 90.1,140.64 v1(90.12,140.62) ; v2(125.75,196.39) 125.75,196.72 125.85,196.82 C425.1 ; C479.1 157.54,179.76 v1(157.4,179.62) ; C20020.1 36.75,152.3 v2(36.88,152.42) ; C96558.1 26.09,119.83 25.29,120.63 C96559.1 ; C20003.1 v2(14.88,160.17) 14.98,160.07 C96304.2 ; C493.1 158.77,205.46 v1(158.2,206.02) ; C96716.2 R68406.2 106.95,110.84 v1(107.28,110.51) 107.87,111.1 R68771.1 ; v1(163.82,202.85) 163.82,202.64 164.16,202.3 C498.1 ; C632.2 26.94,170.05 v2(27.1,170.2) ; C96656.2 92.5,133.12 92.73,132.89 93.37,132.89 93.56,132.69 v1(93.56,132.41) ; v1(91.21,152.45) 91.23,152.43 C96685.2 ; v2(47.59,169.62) 47.29,169.31 C262.2 ; v2(112.69,171.24) 112.67,171.24 112.64,171.27 112.57,171.27 112.49,171.35 C96638.2 ; v5(19.67,64.21) U6549.F7 ; v2(14.14,168.3) 14.4,168.04 C642.2 ; C96782.1 87.21,114.45 87.45,114.69 v1(87.45,114.7) ; PR5017.1 91.13,180.59 91.05,180.67 PC9054.2 ; v2(152.65,111.15) 150.42,111.15 C6563.2 150.41,111.4 150.67,111.66 150.67,112.29 150.77,112.4 C6573.2 ; R68610.2 23.95,69.21 23.79,69.36 23.79,70.25 24.1,70.56 v1(24.1,70.58) ; v2(170.48,149.12) 170.48,148.99 170.85,148.63 U6561.3 ; v1(92.12,139.74) 92.12,139.76 91.79,140.09 C96671.2 C96689.2 ; C20132.1 27,172.84 v2(27.22,172.62) ; D13155.2 13.06,61.86 v1(13.38,61.54) ; D13155.2 v1(12.87,61.19) ; D13155.2 12.68,61.86 v1(12.36,61.54) ; v2(23.88,22.84) 23.71,23.01 C586.2 ; v1(134.79,195.63) 134.46,195.95 C352.1 ; C588.2 14.2,13.86 v2(14.2,13.11) ; C96789.1 225.09,92.1 v2(224.84,92.35) ; v2(29.61,172.63) 29.72,172.74 C20131.1 ; R68779.1 103.2,128.58 v1(103.34,128.44) ; D13156.2 v1(12.87,63.95) ; D13156.2 12.61,63.38 v1(12.34,63.65) ; R68352.1 122.31,125.24 v1(122.41,125.34) ; C6574.2 R25320.2 155.17,113.31 v1(155.17,113.79) ; v1(11.22,64.41) 10.97,64.67 C96857.1 C96859.1 ; v5(21.61,64.85) U6549.G5 ; v2(66.92,189.62) 66.92,189.1 66.79,188.97 C20001.1 ; C492.1 155.93,205.89 v1(155.81,206) ; R68335.2 126.92,162.71 v2(126.79,162.84) 126.66,162.96 R68334.2 R68275.2 ; 78.56,101.37 C96903.2 C1214.2 ; v2(227.76,127.78) 228.26,127.78 228.39,127.66 R69042.2 ; R68373.2 126,127.5 v1(126.03,127.53) ; v1(149.4,100.99) 149.42,100.99 149.78,100.63 C2374.2 R68864.2 ; v2(148.28,98.24) 148.56,97.97 C6577.2 C6578.2 ; U37.104 163.06,109.44 162.56,108.94 v2(162.56,108.35) ; J9007.2 82.37,105.42 82.37,104.49 81.44,103.57 v1(81.44,102.89) ; C1189.2 C1190.2 149.15,105.73 149.15,105.44 v2(148.89,105.18) ; C96889.2 207.41,114.04 207.56,114.2 207.56,115.27 v2(207.11,115.73) ; C639.1 29.16,171.5 v2(29.61,171.95) ; R317.2 160.04,204.99 v1(159.8,205.22) ; R68524.1 R68526.1 123.44,117.88 123.49,117.93 v1(123.49,118.01) ; C96554.1 29.86,121.34 v2(29.38,121.82) ; C96659.2 v1(91.13,146.2) ; v1(87.01,101.62) 86.87,101.62 86.44,101.19 U33.16 ; v2(13.89,167.66) 13.79,167.56 R4008.2 ; R68243.1 123.72,121.84 124.12,121.43 v1(124.48,121.43) ; v2(32.18,157.25) R25527.2 ; C96676.2 91.9,159.06 v1(91.87,159.03) ; v2(22.65,119.91) R68215.2 ; v1(111.55,115.97) 111.68,115.97 111.81,116.1 R68935.1 ; v1(25.45,68.35) 25.41,68.39 25.41,68.57 25.42,68.57 R68874.2 ; v1(93.14,157.63) 93.14,157.38 92.85,157.09 C96650.2 C96690.2 91.13,157.09 v1(91.1,157.12) 91.1,157.38 90.95,157.53 C96661.2 ; PU5001.14 89.99,178.27 89.79,178.48 89.79,178.5 v1(89.71,178.58) ; C96662.2 v1(92.37,146.2) ; v5(17.66,65.53) 17.68,65.53 17.72,65.49 U6549.K12 U6549.K11 ; v1(130.62,193.54) 131,193.92 C411.1 ; R68519.1 v1(120.82,118.08) ; C20008.1 v2(12.87,159.03) ESD4.3 ; C454.1 137.43,192.53 137.63,192.73 v1(138.1,192.73) ; v2(68.91,189.58) 68.91,189.73 68.5,190.14 68.18,190.14 67.94,190.38 R25270.2 ; v1(127.05,118.01) R68484.2 ; v2(67.43,120.95) 67.43,121.1 67.11,121.43 C20110.2 ; v1(81.91,119.15) R68481.2 ; v2(68.31,99.28) 67.8,99.28 67.43,98.9 67.43,97.1 67.89,96.64 R67569.2 ; v2(130.85,152.9) 130.85,153.05 131.49,153.69 C96592.2 131.97,153.98 132.27,153.67 C96589.1 C96643.1 ; C96667.2 88.31,138.72 v1(88.24,138.78) ; v2(35.23,147.47) 35.1,147.6 C20023.1 ; C96781.1 C96786.1 76.24,110.03 75.28,110.99 v1(75.28,111.5) ; C613.2 15.4,129.83 D13090.1 14.18,129.83 13.86,129.51 v2(13.58,129.51) ; v2(142.39,212.87) 142.26,213 C96907.2 142.26,213.92 142.15,214.03 U6515.4
  TOP w0.254: D13084.1 15.13,124.4 v2(14.7,124.4) ; C380.1 132.35,188.47 v1(132.35,188.26) ; U42.18 v2(233.34,115.72) ; v2(33.48,113.38) 33.5,113.36 PC8011.2 ; U6560.3 169.73,136.44 v1(169.72,136.42) ; D13086.1 14.77,120.17 14.85,120.09 v2(14.85,120.04) ; v2(17.76,105.38) 18.21,104.94 D13164.2 ; v2(14.72,127.83) 14.79,127.75 D13088.1 ; U6558.3 208.09,109.27 v2(208.11,109.24) ; R25311.2 170.99,97.66 v2(171.06,97.59) ; v2(26.46,113.19) 26.39,113.26 26.39,113.8 PR8042.2 ; v2(55.88,193.11) 56.26,192.74 PR8029.2 ; v2(30.63,142.2) 30.94,142.2 31.27,141.87 PU9005.3 ; U42.13 v2(229.92,112.49) ; C96856.1 11.37,67.69 11.73,67.33 v1(11.73,67.21) ; U6562.3 168.56,145.44 168.43,145.56 v2(167.97,145.56) ; v1(96.64,127.5) 96.6,127.47 95.99,127.47 94.76,126.23 R68477.2 ; v2(14.07,122.11) 14.26,121.92 D13085.1 ; Y7.4 87.13,113.65 87.29,113.81 90.22,113.81 90.34,113.69 90.34,111.66 90.47,111.53 v2(90.47,110.89) ; v2(97.33,192.17) 97.33,192.78 97.58,193.04 PC9029.2 ; R68595.2 26.26,61.97 26.11,61.82 v1(26.11,61.79) ; C20107.2 59.17,139.24 v2(59.3,139.11) ; v2(170.48,104.21) 170.48,103.68 C1210.2 ; D13083.1 14.59,125.54 v2(14.53,125.59) ; U36.3 187,114.43 v2(187.12,114.32) ; v2(25.58,150.31) 25.65,150.23 ; U6525.2 140.21,211.95 v2(140.46,211.7) ; v2(22.4,114.68) 22.83,115.11 PR8044.2 ; v1(20.77,68.32) 20.79,68.35 20.79,68.38 20.84,68.43 Y8.4 21.9,69.32 v1(21.92,69.34) ; v1(172.51,102.61) 172.92,102.61 173.28,102.25 L11.2 ; C96344.2 194.74,123.11 v1(194.89,123.26) ; 35.51,160.41 v2(35.51,161.49) ; 35.51,160.41 35.14,160.03 PC6057.2 ; 35.51,160.41 35.87,160.05 PC6056.2 ; v1(160.52,113.61) 160.52,113.38 160.19,113.05 C6575.2 ; v2(37.63,144.83) PR567.1 ; v2(25.78,106.6) 25.76,106.58 25.28,106.58 C526.1 ; C20122.2 62.86,140.76 v2(62.71,140.61) ; Q6651.1 138.98,100.72 139.34,101.09 v2(139.34,101.11) ; C20116.2 55.69,169.2 v2(55.81,169.32) ; PC581.2 38.88,138.67 v2(38.61,138.4) ; v2(17.76,107.48) 18.11,107.48 18.33,107.26 U6531.3 20.29,107.26 20.39,107.36 v2(21.23,107.36) ; v2(171.37,96.29) 171.24,96.29 170.83,95.88 C6570.2 ; v2(31.9,118.36) 31.77,118.23 PR8043.2 ; R68384.2 R68336.2 121.58,109.88 120.65,108.94 120.27,108.94 119.91,109.3 R68386.2 118.92,109.3 118.79,109.17 v2(118.79,108.73) ; v1(9.88,66.24) 9.48,65.85 D13143.2 ; C274.2 47.03,159.2 v2(47.54,159.71) ; R1236.1 v2(225.93,116.68) ; v2(16.96,103.35) 17.15,103.16 D13165.2 ; v2(59.09,142.83) 59.03,142.77 59.03,141.9 C272.2 ; v1(24.68,79.14) 24.93,78.89 U6565.3 ; C443.1 134.67,189.86 v1(134.38,189.57) ; D13087.1 15.28,128.93 15.05,129.16 v2(14.27,129.16) ; C20126.2 59.15,131.21 v2(59.27,131.09) ; Q6597.4 161.73,140.72 161.97,140.48 162.51,140.48 162.9,140.1 Q6598.1 162.9,138.62 162.74,138.46 v1(162.74,137.79) ; R1235.1 v2(225.93,114.8) ; R68560.1 76.45,114.12 v1(76.25,114.32) 76.45,114.53 R69003.1 ; v2(46.48,145.52) 46.4,145.43 C249.1 ; D13142.2 9.6,67.45 v1(9.7,67.35) 10.04,67.69 C96858.1 ; v1(170.15,105.71) 170.15,105.2 169.82,104.87 C1208.1 ; U14.14 21.69,96.72 21.79,96.83 R415.1 22.68,96.83 22.98,97.13 v1(22.98,97.46) ; v2(55.79,152.45) 55.67,152.56 C20118.2 ; PR8028.2 50.64,191.59 50.52,191.72 v2(50.52,192.71) ; R504.1 v2(225.93,115.74) ; PR8059.2 27.93,108.33 v2(28.14,108.54) ; v1(104.96,199.43) 104.67,199.43 PC9000.2 ; v2(203.75,93.49) 203.9,93.64 CN66.1 ; PR8057.2 35.09,114.45 34.46,115.08 v2(34.46,115.21) ; v2(19.86,110.23) PR8064.2 ; PR8008.2 55.48,196.91 v2(55.48,197.59) ; U6557.3 205.8,109.51 205.79,109.5 v2(205.79,109.24) ; v2(209.47,109.12) 210.1,109.12 210.37,109.38 U6559.3 ; R68558.1 C96779.2 82.39,117.34 82.29,117.45 v1(82.29,117.51) R68559.2 81.45,117.51 ; U35.3 v2(189.54,114.32) ; v1(137.08,98.96) 137.08,98.7 137.5,98.28 Q6651.4 ; R1234.1 v2(234.61,116.35) ; R506.1 v2(225.93,117.67) ; v2(209.9,97.94) 209.9,97.51 209.72,97.34 C6615.1 ; R497.1 v2(234.61,115.08) ; D13162.2 v2(17.24,87.64) ; U42.21 U42.3 ; PR8040.1 23.18,117.97 v2(23.18,117.35) 23.9,117.35 PC8005.2 ; v2(69.41,203.2) PC5.2 ; v2(24.36,111.78) PR8056.2 ; R499.1 v2(234.61,114.27)
  TOP w0.305: C366.2 137.22,198.53 v1(138.1,198.53) ; C429.1 123.82,199.24 v1(123.11,198.52) ; R229.2 45.66,105.31 46.76,105.31 47.09,105.65 v2(47.09,105.93) ; v1(131.52,196.65) 131.98,197.11 C428.1 ; v2(15.78,197.31) 15.16,197.93 PC8001.2 ; PC8002.2 15.37,196.62 v2(15.79,196.62) ; v2(19.53,91.41) 19.32,91.62 U6530.3 17.2,91.62 v2(17.11,91.52)
  TOP w0.356: v1(128.57,189.7) 129.04,190.17 C407.1 ; C501.2 161.48,179.7 v1(161.4,179.62) ; C367.1 134.05,191.38 v1(133.51,190.84) ; v1(127.22,190.65) 127.49,190.38 C406.1 ; v1(127.41,194.55) 127.41,194.35 C409.1 ; C475.2 152.2,194.42 v1(152.62,194.84) ; C408.1 128.03,195.28 v1(128.41,195.66) ; v1(135.48,193.7) 135.91,193.27 C444.1 ; v1(134.38,196.72) 134.51,196.72 134.87,196.36 C445.1 ; v1(130.62,191.76) 131,191.38 C421.1 ; Q20.1 v2(162.2,191) ; C430.1 130.22,193.93 v1(130.62,193.54) ; C357.1 134.53,193.93 v1(134.81,193.65) ; C369.1 131.98,190.44 v1(131.56,190.85) ; v1(132.35,193.67) 132.61,193.93 C418.1 132.99,193.96 C374.1 ; C424.1 131.5,194.93 v1(131.77,194.66) ; v1(132.35,191.64) 132.61,191.38 C412.1 ; v1(135.4,194.69) 135.88,195.17 C448.1 ; C373.1 128,191.38 v1(128.39,191.77)
  TOP w0.381: v2(20.62,120.04) 20.74,120.16 C96562.1 ; R228.2 44.03,107.21 v2(43.85,107.39) ; v2(21.38,20.09) 21.78,20.49 R465.2 ; v2(18.84,117.73) 18.59,117.48 PC8006.2 ; v2(165.96,201.59) 165.96,201.15 C485.2 ; PQ8015.1 31.03,118.36 v2(31.9,118.36) ; v2(59.93,103.69) 59.77,103.53 R25600.2 ; PC9056.2 97.39,186.9 96.81,187.48 v2(96.35,187.48) ; v2(29.89,145.31) C20010.1 ; Q6605.1 233.84,97.45 v2(233.41,97.88) ; C415.1 126.35,196.22 126.18,196.39 v2(125.75,196.39) ; PR5005.1 89.32,178.97 v1(89.71,178.58) ; v2(116.53,171.32) 116.5,171.35 116.25,171.35 115.8,171.79 C96608.2 ; v2(93.06,172.64) 92.71,172.29 PC5001.2 PC5000.2 ; C96566.1 24.68,131.27 v2(24.68,130.71) ; v2(84.82,168.93) 84.8,168.95 Q6582.1 ; Q6588.1 91.27,106.23 90.98,105.94 v1(90.98,105.48) ; Q16.1 111.42,188.29 111.15,188.29 110.74,187.88 v2(110.74,187.76) 110.69,187.71 110.69,187.5 110.37,187.18 Q14.1 ; Y7.4 86.16,112.76 v2(86,112.93) ; C96637.2 115.98,170.66 v2(116.53,170.66) ; PR8016.2 36.42,97.1 v2(36.49,97.18) ; v1(81.91,119.15) 81.91,119.86 82.09,120.04 C96717.2 ; v1(112.39,156.13) 112.36,156.09 C96646.2 ; v2(116.26,196.3) 115.42,197.14 C461.2 ; v2(116.48,169.77) 116.43,169.82 C96605.2 ; v2(37.19,167.69) 37.26,167.62 PC6052.2 ; v2(112.69,172.23) 113.08,171.85 C96600.2 ; v2(67.36,145.95) 67.36,145.19 67.38,145.17 C20127.2 ; D13095.2 10.42,13.95 v2(10.33,13.87) ; PR8055.2 33.14,109.73 v2(33.17,109.76) PC8009.2 ; v2(68.02,131.42) 68.13,131.53 C20128.2 ; PQ8005.1 38.76,98.82 v2(38.78,98.79) 38.78,99.21 38.99,99.42 PR8017.1 ; PC168.2 113.34,103.41 113.81,103.88 v1(113.81,104.16) 113.81,105.42 C749.1 ; v2(167.8,191.3) 167.61,191.49 C471.2 ; v2(43.84,140.23) 43.95,140.35 C270.2 ; v2(90.53,185.1) 90.62,185.19 PC9064.2 ; PC9023.2 96.25,194.54 96.41,194.7 96.41,195.19 PC9026.2 ; C532.2 v2(21.23,107.36) ; v2(35.2,167.69) 35.2,167.66 35.22,167.64 PC6053.2 ; v2(54.8,118.52) 54.81,118.53 EC6.1 ; v2(94.08,94.59) 93.62,95.04 C743.1 ; v1(125.82,191.03) 125.49,190.7 C458.1 ; v1(163.8,206.02) 163.73,206.09 C500.2 ; v1(155.02,179.64) 154.99,179.61 C502.2 ; PC5020.2 72.83,185.33 v2(72.72,185.44) ; PC572.2 36.49,144.83 v2(36.36,144.96) ; C96687.2 91.83,133.11 92.34,132.59 v1(92.34,132.4) ; v1(118.48,145.81) 118.45,145.84 118.18,145.84 118.06,145.72 C96618.2 117.56,145.73 C96615.2 ; v2(68.02,136.34) 68.13,136.23 C20125.2 ; C265.2 46.41,127.77 v2(46.5,127.86) ; CN66.8 v2(206.67,92.1) ; PC5006.2 86.41,173.63 86,174.04 ; v2(43.74,134.64) 44.09,135 EC5.1 ; v2(46.41,115.39) 46.53,115.51 C267.2 ; D13092.1 150.21,211.16 HE1.3 148.8,211.89 149.65,212.75 v2(150.92,212.75) ; PC9059.2 90.75,184.17 90.33,183.75 v2(90.33,183.75) 90.87,183.21 PC9060.2 ; v2(21.24,108.56) C533.2 ; Q6611.1 171.13,150.53 171.37,150.77 v2(171.75,150.77) ; v1(92.36,112.77) 92.36,112.81 92.37,112.82 C96764.1 ; C96581.2 116.51,168.04 v2(116.58,168.04) ; v2(227.88,127.02) 228.41,126.5 Q6643.1 ; Q22.1 78.22,102.06 78.56,101.72 v1(78.56,100.48) ; v2(36.21,167.69) 36.24,167.66 PC6051.2 ; C20129.2 58.26,135.33 v2(58.97,136.04) ; v1(91.69,181.3) 91.24,181.3 PC9054.2 ; Q6592.1 80.15,188.2 v2(80.18,188.24) ; C513.1 22.34,89.04 v2(22.52,89.23) ; C522.2 20.12,93.61 v2(20.09,93.65) ; v2(126.35,193.38) 126.64,193.67 C368.1 ; C508.2 23.2,100.74 v2(23.34,100.61) ; PC5017.2 85.63,176.38 v2(85.67,176.43) ; PR9098.2 170.67,153.5 170.92,153.75 v2(171.34,153.75) ; v2(43.74,143.45) 43.78,143.41 C279.2 ; v2(89.63,170.18) 89.48,170.18 89.25,170.41 PC5013.2 89.3,170.83 PC5014.2 ; v2(47.44,129.36) 47.44,129.29 C264.2 ; v2(54.66,145.31) 54.28,144.94 C277.2 ; C96788.1 224.59,92.11 v2(224.84,92.35) ; PQ19.1 19.58,146.48 v2(19.35,146.71) ; PC6037.2 33.46,167.04 v2(33.32,166.9) ; PR8000.1 v2(37.18,115.57) ; PQ8005.4 36.17,100.28 36.64,100.75 v2(36.66,100.75) 36.66,100.78 37.22,101.34 PR8009.2 ; C20123.2 68.13,129.45 v2(68.04,129.54) ; Q6509.1 141.34,98.2 140.73,98.8 v2(140.73,98.96) ; C96790.1 227.47,91.94 v2(227.76,92.22) ; v2(80.94,188.24) 80.97,188.21 PR8023.1 ; 26.13,119.1 26.09,119.14 C96558.1 ; C419.2 129.97,198.05 v1(129.68,197.76) ; CN66.7 v2(203.63,92.1) ; v2(59.1,194.95) 59.05,195 PR8027.2 ; v1(101.95,192.68) 102.34,192.29 PC9027.2 ; C268.2 44.25,134.22 43.91,133.88 v2(43.8,133.88) ; v1(118.51,119.1) 118.4,119.21 C96766.1 ; v2(27.35,167.66) R67513.1 R67476.2 ; v2(22.52,91.34) 22.26,91.6 C518.1 ; R68201.1 R68200.1 28.62,120.03 v2(28.62,119.4) ; Q6608.1 204.1,121.6 v2(204.26,121.43) ; C431.1 124.73,196.92 123.11,195.3 v1(123.11,195.22) ; U6509.12 v2(219.4,98.83) ; v2(34.34,127.02) 34,127.36 33.46,127.36 C96572.2 C96571.1 ; v1(164.6,198.82) 164.66,198.89 C484.2 ; v2(85.77,168.93) 85.85,169.01 87.47,169.01 87.67,168.81 Q6583.1 ; v2(74.62,184.3) 77.78,184.3 PC5023.2 ; R470.1 19.83,18.54 20.11,18.82 v2(20.24,18.82) ; R25282.2 158.25,193.68 v2(158.25,193.19) C506.2 ; v2(200.99,127.09) 200.99,127.56 PC6026.2 ; v2(34.89,145.13) 34.89,145.06 34.91,145.05 34.91,144.75 PC571.2 ; v2(23.54,142.39) 24.05,142.39 24.24,142.58 PQ9088.1 ; v1(126.26,189.1) 126.61,188.74 C376.2 ; C523.1 25.1,105.04 24.35,104.29 v2(23.57,104.29) ; v1(124.73,195.22) 125.22,195.71 C432.1 ; v2(17.57,127.05) 17.57,127.4 18.08,127.91 C96555.1 ; R589.2 v2(18.64,17.09) ; PC167.1 110.79,104.07 110.84,104.12 v1(110.84,104.15) ; C20045.1 C20042.2 ; v2(138.37,213.15) 138.37,213.17 138.35,213.2 138.35,213.63 C20134.1 ; R230.2 v2(46.53,129.87) ; v2(215.31,103.91) 214.95,103.54 Q6645.1 ; v2(162.37,119.66) 163.07,119.66 163.93,120.52 PR211.1 ; PR8030.1 83.29,190.49 v2(83.12,190.32) ; D13091.1 148.01,209.28 147.42,208.68 v2(147.24,208.68) ; C96785.1 86.79,115.34 87.42,114.7 v1(87.45,114.7) ; C96586.2 113.1,170.84 v2(112.69,171.24)
  TOP w0.508: v2(38.09,177.88) 37.51,178.46 C96313.2 ; EC17.2 206.29,99.4 v2(206.69,99.79) ; CN62.4 34.3,41.38 v2(33.92,41.38) ; v2(19.53,91.41) 19.91,91.79 C521.2 ; Q6508.2 15.65,135.13 v2(15.03,134.52) ; PC9023.2 96.2,194.54 95.88,194.54 95.63,194.79 93.57,194.79 93.28,195.08 v2(93.13,195.08) ; v2(157.88,168.35) 157.88,168.63 PQ9084.1 ; PR9104.2 155.78,171.08 v1(155.78,171.89) ; PU8000.2 21.25,117.7 v2(21.07,117.88) ; PQ8019.1 21.02,110.05 v2(21.64,110.68) ; v2(36.17,110.86) 35.94,110.86 35.4,111.4 PU8001.2 35.4,112.59 35.85,113.04 PC8008.1 ; v1(99.64,95.91) 100.5,95.91 100.79,95.62 PQ12.1 ; v2(209.72,94.26) 210.19,94.73 R25556.1 C20040.2 ; C392.2 v2(164.76,207.98) ; C416.2 107.03,202.41 107.82,201.62 107.82,200.76 107.5,200.44 v3(107.1,200.44) ; v1(86.41,106.3) 86.75,106.64 Q6589.1 ; v2(215.59,101.11) C20050.1 ; PR9101.2 160.56,166.71 160.29,166.44 PQ9086.1 159.81,166.52 v2(159.81,167.15) ; v2(76.88,198.6) 75.1,196.82 75.1,195.48 75.61,194.97 U19.2 ; PQ9085.1 162.38,166.8 v2(162.38,167.41) ; v2(3.35,14.02) 3.35,14.48 D10.2 ; v2(8.94,56.66) 10.59,56.66 11.62,57.7 CN62.12 ; PR120.2 56.28,175.84 56.74,175.38 57.96,175.38 Q6646.1 ; v2(34.34,170.84) 34.17,170.67 Y4.2 ; PQ9083.1 v2(161.46,209.17) ; Y4.4 v2(31.25,167.28) ; PC9021.2 111.45,197.74 112,197.18 C462.2 ; D33.1 194.31,97.26 v2(194.79,96.78) ; C96835.2 33.19,64.28 v2(33.95,63.52) ; PC9025.2 94.46,197.56 93.95,197.05 v1(93.95,196.95) PR9030.1 ; v2(24.17,171.56) 24.02,171.71 C96303.1 ; PC8007.2 26.13,119.1 v2(26.21,119.02) ; PC9004.2 97.24,192.08 v2(97.33,192.17) ; C96827.2 C96829.2 22.25,72.06 v2(22.78,71.52) ; U6551.4 29,77.37 30.91,75.46 ; v2(208.67,99.79) 209,99.47 EC16.1 ; v2(29.75,111.36) 30.46,111.36 30.53,111.29 PC8010.2 ; C96901.1 34.31,69.91 v2(34.31,69.01) ; CN62.7 34.34,49.68 34.11,49.91 v2(33.95,49.91) ; v2(159.75,209.82) 159.45,209.82 PR9105.2 ; Q6656.1 23.48,81.71 v2(23.35,81.58) ; v2(209.9,98.96) C20047.1 ; PR230.2 56.84,204.6 v2(56.02,205.42) ; v2(39.16,121.69) 38.95,121.48 PQ9050.1 ; PC5016.2 63.5,178.13 64.18,177.44 v2(64.18,176.43) ; v2(17.32,119.23) PR8039.2 ; C20042.2 v2(225.55,99.08) ; R588.2 23.83,24.59 v2(24.26,24.16) ; v2(39.37,177.89) 39.54,178.07 C645.2
  IN1 w0.089: v2(30.65,56.41) 31.19,55.88 31.19,52.45 32.18,51.46 32.18,44.98 32.68,44.47 33.19,44.47 33.45,44.73 33.45,45.74 33.7,46 34.11,46 34.23,46.12 34.23,46.61 33.85,46.99 v1(33.83,46.99) 33.83,47.01 34.21,47.39 34.21,47.9 33.88,48.23 v1(33.83,48.23)
  IN1 w0.102: v1(33.83,48.23) 33.83,48.41 33.19,49.04 33.19,53.74 33.07,53.87 31.77,53.87 31.67,53.97 31.67,58.02 30.36,59.34 ; 30.14,59.46 29.97,59.28 29.97,57.1 v2(30.65,56.41)
  IN1 w0.254: v1(117.2,125.04) 117.34,125.04 117.65,124.74 117.65,123.46 117.52,123.34 117.52,120.7 v1(117.52,120.7) 117.52,120.42 117.27,120.16 116.63,120.16 116.38,120.42 116.38,121.31 116.69,121.62 v1(116.69,122.78)
  IN2 w0.203: v2(86,112.93) 86.66,112.93 ; v2(90.47,110.89) 89.96,110.89 ; 86.66,111.02 86.58,110.94 v2(86.02,110.94)
  BOTTOM w0.079: v1(102.81,119.66) 102.81,119.25 103.35,118.72 103.42,118.72 103.55,118.59
  BOTTOM w0.102: U6539.AK12 119.51,152.45 119.96,152.91 v1(120.3,152.91) ; U6539.DD15 117.65,128.09 117.65,128.28 117.88,128.51 117.88,128.78 117.7,128.96 117.11,128.96 116.79,128.64 U6539.DC17 ; 117.52,120.67 117.65,120.54 117.65,120.16 ; 117.52,120.67 117.01,120.16 116.63,120.16 116.38,120.42 116.38,121.18 116.49,121.3 116.49,121.98 U6539.DU16 117.15,121.92 117.15,121.04 117.5,120.7 v1(117.52,120.7) 117.52,120.67 ; U6539.AV12 119.02,148.36 119.5,147.88 U6539.AY9 ; v1(105.35,167.38) 105.35,167.13 105.43,167.06 U6539.B42 ; U6539.DT4 122.92,122.27 123.41,122.27 U6539.DV1
  BOTTOM w0.114: C1651.2 33.8,63.68 v2(33.95,63.52) ; Q6522.1 80.78,189.29 80.62,189.12 80.62,188.56 v2(80.94,188.24) ; PC5011.2 v2(70.78,177.87) ; PC5012.2 v2(72.82,177.87)
  BOTTOM w0.127: U6539.DE5 121.66,127.85 121.66,128.11 121.46,128.32 121,128.32 v1(120.87,128.19) ; U6539.B52 101.11,165.2 101.77,165.2 101.77,164.49 102.14,164.12 U6539.D49
  BOTTOM w0.15: v1(99.6,123.48) 99.72,123.59 100.15,123.59 U6539.DP53
  BOTTOM w0.152: C96713.1 128.41,122.48 128.39,122.5 127.37,122.5 127.02,122.86 126.64,122.86 126.16,123.34 125.17,123.34 124.56,123.95 U6539.DN1 ; v1(129.23,121.82) v2(130.99,121.82) 131.62,121.82 131.74,121.94 131.74,124.74 131.62,124.86 130.86,124.86 130.17,125.55 129.13,125.55 128.77,125.19 128.77,124.81 128.16,124.2 125.55,124.2 125.17,124.58 v1(125.17,124.76) 125.14,124.79 125.14,124.89 124.76,125.27 124.61,125.27 124.25,125.63 124.11,125.63 U6539.DJ1 ; 101.77,165.2 101.77,165.36 U6539.A49 ; U6539.DL3 123.19,124.9 123.19,124.02 U6539.DN2
  BOTTOM w0.178: U6539.AN53 100.47,151.23 97.33,151.23 v1(97.29,151.2) ; v1(142,193.54) 142,193.45 141.83,193.27 141.04,193.27 U8.P26 ; U6539.BG53 99.71,144.75 v1(99.55,144.58)
  BOTTOM w0.2: U6539.DU16 116.79,122.67 v1(116.69,122.78) 116.79,122.88 U6539.DR16 ; U6539.CR53 99.68,131.99 99.63,132.04 v1(99.51,132.04) ; U6539.DR46 103.54,123.12 v1(103.54,122.78) 103.54,122.43 U6539.DU46 ; v1(108.8,130.34) 108.8,130.32 U6539.CY35 ; U6539.DR28 111.55,122.87 v1(111.47,122.79) 111.47,122.78 111.55,122.7 U6539.DU28 ; v1(113.47,157.94) U6539.U25 ; v1(96.08,146.5) 96.19,146.61 97.74,146.61 98.47,147.34 100.47,147.34 U6539.BA53 ; U6539.DU11 119.38,122.31 119.38,122.74 v1(119.33,122.79) 119.38,122.84 119.38,123.25 U6539.DR11 ; U6539.DU22 114.17,122.72 v1(114.09,122.79) 114.17,122.87 U6539.DR22 ; U6539.DV1 124.25,121.43 v1(124.48,121.43) ; v1(111.64,158.59) 111.63,158.6 111.21,158.89 U6539.T29 ; U6539.DR34 109.07,123.13 v1(109.07,122.8) 108.93,122.66 U6539.DU34 ; U6539.CN51 U6539.CN52 ; v1(118.03,156.74) 117.65,156.74 117.24,157.15 U6539.W16 ; v1(99.52,134.54) U6539.CK53 ; U6539.DA30 v1(111.33,129.62)
  BOTTOM w0.203: v1(13.61,53.72) 13.61,53.77 13.89,54.05 13.89,54.51 14.22,54.84 C96861.2 C96863.2 ; v2(146.62,189.48) 146.62,188.89 146.22,188.49 R315.1 ; U6517.5 194.44,123.89 194.28,124.05 C804.2 ; v2(122.6,208.02) 122.47,208.15 122.47,208.81 122.25,209.04 R311.2 ; C433.1 110.43,183.69 110.41,183.66 v1(110.41,183.03) ; R69064.2 100.78,119.15 v1(100.91,119.02) 100.53,118.64 R68475.1 ; v2(19.1,39.24) 19.23,39.11 C575.2 ; U6539.AG53 100.48,153.78 99.86,153.78 99.2,154.44 95.5,154.44 v1(95.26,154.19) ; C1645.2 33.49,36.44 v2(33.56,36.51) ; v1(12.36,66.95) 12.24,67.08 R68956.2 ; v1(10.08,60.86) 10.08,61.62 10.39,61.93 R68672.1 ; C2616.1 16.91,70.18 v1(17.11,69.97) ; R68775.1 106.75,111.69 C96931.1 106.75,111.04 v1(107.28,110.51) 107.28,110.82 107.51,111.05 107.51,111.22 107.77,111.48 R68793.1 ; v1(25.34,57.48) 25.29,57.53 R68878.2 ; C583.1 28.49,35.07 v2(28.62,35.2) ; R68546.2 116.91,119.43 117.65,120.16 ; R68387.2 96.82,128.8 96.95,128.67 v1(97.02,128.67) ; 103.55,118.59 103.88,118.26 103.88,116.46 104.06,116.28 104.82,116.28 ; R356.1 115.51,186.59 115.36,186.74 v2(115.36,186.79) 115.36,186.84 115.85,187.33 R313.2 ; U6539.W1 124.56,157.45 124.58,157.43 v1(125.01,157.43) ; R354.1 117.21,184.43 117.26,184.37 v1(119.47,184.37) ; v1(12.87,63.95) D13156.2 ; D13156.2 12.61,63.38 v1(12.34,63.65) ; D13156.2 13.14,63.38 v1(13.41,63.65) ; Q81.1 15.32,146.39 C1044.2 ; C96908.2 3.47,53.11 3.27,52.9 v1(3.27,52.73) ; 128.69,180.13 128.64,180.13 v1(128.55,180.22) ; 128.69,180.13 128.9,180.13 129.36,179.68 129.36,179.1 129.21,178.95 R352.1 ; 128.69,180.13 128.67,180.16 ; D13155.2 12.68,61.86 v1(12.36,61.54) ; D13155.2 v1(12.87,61.19) ; D13155.2 13.06,61.86 v1(13.38,61.54) ; C96700.1 96.46,122.6 96.62,122.75 98.24,122.75 v1(98.42,122.94) ; C96870.1 C96878.1 v2(203.63,116.13) ; v2(156.26,210.74) 156.64,211.13 C20138.2 ; R68807.2 v1(139.72,123.67) R68806.2 ; R68405.2 R68423.1 128.11,125.88 128.27,125.73 v1(128.27,125.7) ; Y6.2 v2(130.99,121.82) ; v1(127.93,127.53) 128.03,127.43 R68424.2 ; v2(162.48,134.77) 162.42,134.71 PU7001.14 ; v2(110.74,187.76) 110.74,187.7 110.29,187.25 R306.1 ; v1(11.12,61.59) 10.79,61.93 R68672.1 ; v2(176.51,130.63) 176.51,130.12 176.36,129.98 PU6000.8 ; v2(115.59,185.72) 115.74,185.57 R353.1 ; C844.1 R734.1 26.94,28.47 v2(27.1,28.32) ; PR205.1 161.46,116.25 v2(161.44,116.23) ; R68858.1 108.15,115.67 v1(108.1,115.72) ; U6539.DD52 U6539.DD51 101.63,128.09 v1(101.82,128.28) ; v1(71.83,189.25) 71.8,189.28 71.78,189.28 71.65,189.41 C546.1 ; v2(11.69,156.92) 11.7,156.93 C20009.2 ; v2(19.98,53.92) 20.32,54.25 R68700.2 ; v1(112.39,156.13) 112.55,156.29 U6539.W26 ; C497.1 158.13,168.6 v2(157.88,168.35) ; v1(118.51,119.1) 118.21,118.79 R68530.1 R68547.2 ; v1(115.21,182.39) 115.3,182.29 115.59,182.29 116,181.89 R357.1 R355.1 ; U6539.AM2 U6539.AM1 124.36,151.68 124.56,151.48 124.99,151.48 125.42,151.91 v1(125.78,151.91) ; v2(123.83,166.23) 123.83,166.2 123.73,166.1 123.73,165.28 U6539.B2 ; U6539.BD12 118.49,145.84 v1(118.48,145.81) ; R68371.2 95.15,125.86 95.42,126.13 R68486.2 95.8,126.1 96.57,126.1 96.79,125.88 96.79,125.85 v1(96.82,125.83) ; C96711.1 128.82,124.36 129.2,124.74 v2(129.2,124.99) ; v1(98.09,167.41) 98.22,167.28 98.22,166.9 99.11,166.01 101.39,166.01 101.87,165.54 U6539.A49 102.59,164.89 U6539.B48 ; v1(13.28,72.26) 13.19,72.17 D13146.2 12.25,72.17 12.22,72.14 R68955.2 ; U6539.W30 110.72,156.45 110.42,156.15 110.31,156.15 v1(110.25,156.09) ; PR9289.2 166.01,149.88 v2(166.06,149.82) ; D13112.1 59.75,191.91 59.55,192.11 v1(59.29,192.11) 59.04,192.11 58.83,191.91 D13114.1 ; C96887.2 207.54,119.08 207.02,118.55 C96888.2 ; R68290.2 94.31,119.69 94.03,119.4 v2(93.7,119.4) ; v1(15.29,45.11) 15.14,44.96 C96865.2 C96862.2 ; CN29.3 57.65,192.25 57.31,191.91 D13113.1 ; PU9006.3 166.1,147.28 v2(166.67,147.85) ; v2(7.16,54.63) R69004.2 ; v1(122.77,148.33) 122.86,148.43 U6539.AW2 U6539.AW1 124.2,148.43 v1(124.51,148.74) ; D13153.2 12.61,70.62 v1(12.34,70.89) ; D13153.2 13.14,70.62 v1(13.41,70.89) ; D13153.2 v1(12.87,71.19) ; v2(68.91,189.58) 68.91,189.4 68.37,188.87 C558.2 ; v1(104.92,116.74) 104.82,116.63 104.82,116.28 ; R68542.2 109.45,115.97 v1(109.27,115.8) ; C96913.1 135.05,130.32 134.92,130.2 v1(134.87,130.2) 134.67,130.2 133.52,129.05 133.52,128.04 133.68,127.88 C96879.1 ; v1(115.15,183.27) 115.42,183.54 R358.1 ; C96911.1 3.6,51.58 3.27,51.91 v1(3.27,51.97) 3.65,52.35 R69005.2 ; PR7091.2 129.97,151.15 v2(129.59,151.53) ; R68372.2 122.32,113.28 122.73,113.69 122.98,113.69 v1(123.49,114.2) ; v1(96.64,127.5) 96.57,127.43 R68383.2 ; v1(126.66,139.85) 127.34,140.52 C96601.1 127.34,141.31 127.63,141.61 C96602.2 ; v2(26.46,32.15) 26.43,32.18 C587.1 ; R68279.1 128.16,166.87 128.06,166.77 128.06,166.48 C96599.2 ; v1(11.73,66.52) 11.27,66.06 10.9,66.06 10.84,66.13 D13144.2 10.14,66.13 10.03,66.24 v1(9.88,66.24) ; U6539.CP42 105.16,132.77 v1(104.92,133.01) ; C96718.1 126.64,145.33 v1(126.41,145.56) ; v1(11.22,64.41) 10.57,65.06 D13119.2 ; U6539.CP45 103.86,132.58 v1(104.29,133.01) 104.51,132.8 U6539.CP44 ; v1(124.51,144.59) 124.46,144.53 U6539.BH1 U6539.BH2 ; CN11.20 v2(234.64,104.21) ; v1(100.08,157.35) 100.21,157.23 101.19,157.23 U6539.Y50 ; v1(108.35,166.09) 108.25,165.99 108.25,165.88 108.19,165.83 108.19,165.18 U6539.B36 ; R68755.2 202.51,117.65 v1(202.48,117.63) ; U6539.B8 120.4,165.31 v2(120.4,165.85) ; C96774.1 104.28,112.13 104.31,112.16 R68411.2 104.72,112.7 v1(104.82,112.8) ; C96795.1 120.67,106.67 v1(120.95,106.96) ; C96912.1 138.38,126.8 137.84,126.26 v1(137.71,126.26) ; PC7045.1 165.74,136.5 165.54,136.29 165.15,136.29 v2(164.76,135.91) ; v2(66.92,189.62) 66.92,189.06 67.26,188.72 R442.2 ; v1(103.2,116.71) C96710.1 ; v1(57.96,183.75) PU6003.8 ; v1(107.13,115.73) 107.23,115.62 R68777.1 ; C96909.2 3.59,54.39 v1(3.28,54.7) ; R25369.2 83.43,190.01 v2(83.12,190.32) ; R68673.1 10.84,63.37 v1(11.12,63.65) ; R68673.1 10.34,63.37 10.16,63.55 v1(10.16,63.8) ; R68673.1 10.64,63.42 10.64,64.03 v1(10.7,64.09) ; C96794.2 130.88,103.43 130.22,102.77 v1(130.22,102.46) ; C96910.1 3.32,48.59 v1(3.27,48.54) ; v5(23.79,66.08) 23.82,66.08 23.99,65.91 C1649.1 ; v2(4.11,42.82) 3.98,42.95 R68680.2 ; v2(31.8,34.57) 31.03,34.57 30.75,34.28 R479.2 ; v2(12.49,34.44) 12.21,34.16 C596.2 ; C452.1 129.3,208.71 128.82,209.19 v2(128.75,209.19) 128.57,209.01 128.57,208.68 128.34,208.46 R325.1 ; U6539.H8 120.59,162.73 v1(120.89,163.03) ; v1(10.56,71.14) 10.56,70.63 R68666.1 10.89,70.61 v1(11.15,70.86) ; v2(154.44,169.46) 154.46,169.44 C499.1 ; R68936.1 118.82,114.86 118.64,114.67 R68396.2 118.28,114.96 119.3,115.97 v1(119.3,116.06) ; C1646.2 33.22,37.01 33.32,37.11 33.83,37.11 34.11,37.39 v2(34.11,38.12) ; D13154.2 12.87,68.55 v1(12.9,68.53) ; D13154.2 13.19,69.1 v1(13.43,68.86) ; D13154.2 12.4,69.1 v1(12.29,68.98) ; C96773.1 103.88,110.56 v1(103.8,110.64) ; R68672.1 v1(10.59,61.29) ; U6539.CP41 105.81,132.73 v1(105.53,133.01) ; v2(119.17,208.94) 118.79,208.56 C364.2 ; v2(12.87,158.06) 12.7,158.06 12.11,158.65 C20005.1 ; PR10.2 104.87,104.67 ; v2(14.53,125.59) 14.63,125.69 D13082.1 ; D13111.1 61.27,191.78 60.65,192.4 CN29.9 ; C96895.2 C96893.2 166.32,139.95 166.3,139.97 C96896.2 165.91,139.52 v1(165.6,139.21) 165.15,139.67 164.71,139.67 164.41,139.37 164.41,138.82 PC7066.1 163.48,138.88 PR7067.2 ; PR7053.2 166.3,144.03 166.01,144.32 PC7042.1 ; C96713.1 128.92,122.48 129.23,122.17 v1(129.23,121.82) ; U6539.D5 121.96,164.24 122.26,163.94 v1(122.26,163.85) ; U6539.A45 104.04,166.03 103.07,167 102.79,167 102.64,167.15 102.64,167.31 v1(102.56,167.38) ; v1(124.76,154.64) 124.7,154.59 122.85,154.59 U6539.AF4 ; C890.1 12.24,159.41 12.62,159.03 v2(12.87,159.03) ; R68276.2 R68274.2 R68305.2 122.76,172.71 122.93,172.54 122.93,172.16 123.39,171.7 R68324.2 123.39,171.12 123.06,170.79 v1(122.78,170.79) ; R68354.1 R68353.2 93.59,122.23 v1(93.75,122.07) 93.97,121.84 R68472.1 ; CN11.14 v2(231.64,104.21) ; v2(27.35,28.98) 27.6,28.98 27.76,29.13 C584.2 ; U8.E17 133.58,185.65 v1(133.99,185.24) ; C1643.2 C1644.2 33.6,51.74 v2(33.95,52.09) ; v1(94.97,106.24) 94.97,106.99 95.09,107.11 R68684.2 ; v1(11.17,68.86) 11.15,68.86 10.86,69.14 R68667.1 ; v1(10.59,68.65) R68667.1 ; R68667.1 10.29,69.14 10.03,68.88 v1(10,68.88) ; C20142.2 156.51,214.62 v2(156.74,214.4) ; R68455.2 104.21,118.95 v1(104.41,119.15) ; C96881.2 v1(139.72,121.38) R68808.2 ; R350.1 132.64,179.19 R351.1 ; v2(27.35,35.2) 27.19,35.04 C580.2 ; v2(22.52,91.34) 22.65,91.46 C512.2 ; C96898.2 171.21,145.41 v2(171.62,145.82) 171.24,146.2 C96904.2 ; v2(154.68,142.19) 154.71,142.21 PC7038.1 ; C1647.2 33.29,40.51 33.92,41.14 v2(33.92,41.38) 33.87,41.33 C96319.2 ; U6556.17 135.44,122.95 U6556.21 ; C96868.1 23.04,46.89 22.91,46.76 C96869.2 ; v1(11.73,67.21) 11.73,67.6 11.6,67.73 D13147.2 ; R69009.2 R69008.2 v1(3.27,49.3) ; v2(118.79,108.73) 118.94,108.73 119.5,109.29 119.89,109.29 119.96,109.21 C96793.1 120.92,109.21 121.33,109.62 123.87,109.62 124.12,109.37 ; CN11.17 v2(233.14,104.21) ; C96885.2 209.02,118.08 209.34,117.75 v2(209.34,117.42) ; v2(168.27,148.61) 168.09,148.79 PC9099.2 ; U6539.BC1 U6539.BC2 122.8,146.48 v1(122.78,146.5) ; D13145.2 10.14,67.65 9.84,67.35 v1(9.7,67.35) ; R68313.1 126.87,149.02 126.86,149.01 126.68,149.01 v1(126.41,148.74) ; C548.2 v2(54.27,193.19) ; C96880.1 136.07,117.67 137.28,117.67 137.56,117.95 v1(137.56,118.13) ; C547.2 54.27,190.01 53.89,189.63 51.23,189.63 50.72,190.14 v2(50.72,190.24) ; U6539.DA53 99.68,129.29 v1(99.62,129.23) ; U6539.DJ2 U6539.DJ1 ; R68541.2 109.19,109.78 109.51,110.11 v1(109.51,110.51) ; 104.82,116.28 105.02,116.28 105.18,116.13 105.18,115.9 105.33,115.75 R68938.2 R68939.1 106.34,115.59 106.6,115.34 106.6,113.43 106.47,113.31 102.79,113.31 102.62,113.48 102.62,115.25 102.53,115.34 102.53,116.1 102.31,116.33 C96709.1 102.1,116.58 101.6,117.09 101.6,117.7 101.97,118.08 R68413.2 v1(101.97,118.9) ; C96823.1 18.84,67.27 19.05,67.47 v1(19.05,67.52) ; C1648.2 33.42,48 33.65,48.23 v1(33.83,48.23) ; PR7068.2 v1(161.29,136.5) ; 64.31,114.07 JDIM02.223 ; U6539.BK12 v1(118.57,143.57)
  BOTTOM w0.229: v5(7.92,69.59) 7.97,69.54 CN10.A12
  BOTTOM w0.254: v1(120.51,182.12) 120.88,182.12 121.12,182.36 U8.A2 ; U6539.V19 U6539.U19 U6539.T19 115.76,159.07 U6539.P20 115.28,159.59 ; U6539.DM39 106.43,124.42 v1(106.29,124.42) ; v1(109.02,126.37) 109.03,126.38 109.17,126.38 U6539.DG33 ; v1(122.84,145.59) 122.84,145.43 U6539.BF4 122.79,144.88 v1(122.79,144.67) ; U8.U23 138.58,195.63 138.97,196.01 v1(138.97,196.01) ; U6539.CK39 107.14,134.8 v1(107.22,134.8) ; U6539.Y8 120.59,157.03 120.85,157.28 120.85,157.46 v1(120.82,157.48) ; U6539.AV5 122.17,149.07 v1(122.17,149.25) ; U6539.BB8 120.92,146.64 v1(120.92,146.5) 120.92,146.37 U6539.BD8 ; CN33.4 130.1,98.71 129.76,98.37 v2(129.76,97.94) ; v1(96.69,101.85) 96.57,101.97 EC7.1 ; v1(118.97,159.31) 118.97,159.45 U6539.P11 ; v1(121.54,149.25) 121.54,149.09 U6539.AV7 ; v1(160.52,113.61) 161.41,113.61 161.62,113.4 C96346.2 ; JDIM1.22 v2(43.83,166.32) ; v2(65.15,192.02) CN29.18 ; U8.B20 135.98,182.08 v1(135.88,181.99) ; U6539.BH2 122.93,144.53 v1(122.79,144.67) ; v1(99.56,126.62) 99.61,126.62 99.64,126.64 99.77,126.64 99.8,126.68 U6539.DG53 ; U6539.V4 122.83,157.66 v1(122.83,157.48) ; U6563.3 168.56,143.42 168.07,143.91 168.07,145.46 v2(167.97,145.56) ; v1(194.89,123.26) 194.74,123.11 C96344.2 ; U6539.DD15 117.2,127.64 v1(117.2,127.63) ; U6539.AK7 121.58,152.79 v1(121.58,152.91) ; PR9274.2 107.1,201.68 v3(107.1,201.2) ; CN17.33 183.54,115.65 183.21,115.98 v2(183.21,116.76) ; v1(122.8,149.25) 122.8,149.05 U6539.AV4 ; CN16.27 27.85,79.2 v1(28.04,79.02) ; U6539.DM10 119.23,124.99 v1(119.03,124.99) ; v1(128.66,182.72) 128.66,183.13 U8.B11 ; v1(120.94,159.31) 120.91,159.29 120.91,159.21 120.59,158.89 U6539.T8 ; U6539.AD4 122.22,155.52 v1(122.22,155.65) 122.22,155.78 U6539.AB5 ; v1(120.87,126.43) 121.06,126.43 U6539.DG6 121.57,126.94 U6539.DG5 122.01,126.94 122.45,127.38 122.76,127.38 U6539.DE3 ; v1(124.02,186.06) 123.66,185.7 U8.E5 ; CN17.18 v2(190.62,119.4) ; U6539.AY8 120.89,148.18 v1(120.89,148.33) ; v2(66.45,191.91) 66.65,192.11 CN29.21 ; v1(111.75,124.41) 111.87,124.41 U6539.DM27 ; v3(162.64,154.82) 162.8,154.66 PU9004.15 ; v2(138.45,181.73) 138.63,181.92 138.63,183.08 U8.B23 ; C801.2 195.5,123.14 v1(195.63,123.26) ; PQ9009.1 95.19,188.35 95.18,188.34 95.12,188.34 94.32,187.54 C96269.2 ; U6539.AK8 120.92,152.78 v1(120.92,152.91) ; U6539.AB8 120.95,155.75 ; 120.95,155.75 120.95,155.82 U6539.AB7 ; 120.95,155.75 v1(120.95,155.67) ; v1(122.83,156.57) 122.83,156.74 U6539.Y4 ; CN29.12 62.15,193.82 61.96,194.01 v2(61.96,194.63) 62.92,194.63 63.65,193.9 CN29.15 ; U8.E2 121.07,185.64 119.5,185.64 v1(119.47,185.67) ; CN10.A1 8.44,64.04 8.12,63.73 v5(7.92,63.73) 7.85,63.79 CN10.B12 ; U6539.AV8 120.27,148.47 v1(120.27,148.33) 120.27,148.2 U6539.AY9 ; CN17.75 185.21,105.15 185.47,104.9 185.47,104.37 CN17.77 ; CN17.7 183.35,122.15 183.18,122.32 v2(183.18,123.19) ; v1(26.08,64.87) 26.1,64.89 R752.1 ; U6539.AP4 122.79,150.38 122.79,150.19 v1(122.81,150.16) 122.79,150.14 122.79,149.95 U6539.AT4 ; v1(120.27,134.61) 120.27,134.48 U6539.CL9 ; CN52.9 206.85,100.04 206.69,99.88 v2(206.69,99.79) ; 45.13,171.32 JDIM1.2 ; v2(183.18,114.15) CN17.39 ; U6539.DM15 117.4,124.99 117.25,124.99 v1(117.2,125.04) ; v2(28.49,43.08) 28.49,43.2 28,43.7 U6564.3 ; U6539.DK51 101.75,125.48 v1(101.9,125.63) ; R406.1 157.5,192.43 v2(157.5,193.19) ; v1(122.43,134.99) U6539.CJ5 ; v1(126.46,185.27) 126.46,185.29 126.45,185.31 126.4,185.31 U8.E8 ; CN49.24 v2(223.4,116.25) ; U6539.AK5 122.22,152.78 v1(122.22,152.91) 122.22,153.04 U6539.AH4 ; EC11.2 26.24,68.89 25.7,68.35 v1(25.45,68.35) ; CN48.11 207.45,112.19 207.54,112.1 v2(207.54,111.57) 206.95,112.16 CN48.12 ; U6539.P4 122.75,159.56 122.75,159.34 v1(122.78,159.31) ; U6539.BK4 122.54,143.18 v1(122.98,142.75) ; U6539.CU9 119.94,131.61 120.2,131.86 v1(120.2,131.86) ; CN48.16 204.95,112.79 205.08,112.66 205.32,112.66 205.45,112.79 CN48.15 205.45,115.57 v2(205.4,115.62) ; U6539.BM1 123.07,142.66 v1(122.98,142.75) ; U6539.DM45 104.28,124.99 104.48,124.99 104.49,124.97 v1(104.5,124.97) ; v2(23.35,81.58) CN16.45 ; v1(122.83,158.4) 122.8,158.42 122.8,158.6 U6539.T4 ; U8.Y26 141.11,197.92 142.53,197.92 142.84,198.22 v1(142.84,198.37) ; QG17.4 113.53,176.64 113.18,176.98 112.65,176.98 112.53,177.11 QG17.1 ; CN49.21 v2(223.4,117.75) ; JDIM1.202 46.58,119.32 46.65,119.4 ; v1(120.29,160.23) 120.31,160.2 120.31,160.09 120.59,159.82 U6539.P8 ; v1(122.98,142.75) 122.62,142.39 U6539.BM4 ; v2(22.27,79.19) 22.09,79.19 21.85,79.44 CN16.51 ; v1(121.47,137.35) 121.47,137.12 U6539.CD7 ; U6539.CG9 120.27,136.31 v1(120.27,136.44) ; v1(116.38,130.38) 116.72,130.04 U6539.CY17 ; CN58.1 67.7,99.4 67.82,99.28 v2(68.31,99.28) ; U6539.BP5 121.64,141.41 121.64,141.16 v1(121.49,141.02) ; U6539.DV40 U6539.DU40 106.31,122.72 v1(106.24,122.79) 106.31,122.86 U6539.DR40 ; v1(122.32,118.01) 121.96,117.65 R69104.1 ; v1(111.75,126.39) 111.9,126.39 U6539.DG27 ; v2(93.67,98.45) 93.67,99.01 EC8.2 ; v2(221.18,119.45) 221.38,119.25 CN49.18 ; U6539.B39 106.73,165.85 106.86,165.98 v1(106.86,166.08) ; U6539.BB4 122.78,146.73 v1(122.78,146.5) 122.78,146.28 U6539.BD4 122.22,145.72 v1(122.22,145.59) 121.89,145.26 U6539.BF5 ; v1(123.6,182.29) 123.6,183.22 U8.B5 ; v1(104.53,126.31) 104.5,126.34 104.37,126.34 U6539.DG45 ; CN58.14 61.2,98.13 v2(61.13,98.07) ; CN17.51 185.21,111.15 v1(185.59,110.77) 185.72,110.89 185.72,112.42 185.49,112.65 CN17.45 ; JDIM1.64 44.09,155.82 v2(43.78,155.52) ; v2(60.76,194.1) 60.65,194 CN29.9 ; v1(120.3,152.91) 120.31,152.92 120.31,153.09 U6539.AH8 ; v1(120.88,141.02) 120.95,141.09 120.95,141.18 U6539.BP7 ; CN53.1 v2(226.9,99.63) ; v1(122.15,161.14) 121.89,161.41 U6539.K5 ; v1(122.79,144.67) 122.54,144.43 U6539.BH4 ; U6539.DA33 109.57,129.61 v1(109.7,129.61) ; CN17.57 183.55,109.65 183.07,109.17 v2(183,109.17) 183.18,108.99 183.18,108.48 183.51,108.15 CN17.63 ; PU9004.14 162.74,154.16 v3(162.64,154.06) 162.64,153.79 162.77,153.66 PU9004.13 ; JDIM1.78 v2(43.83,152.32) ; v1(120.25,132.73) 120.22,132.7 120.17,132.7 119.94,132.47 U6539.CR9 ; U6539.CN12 119.94,133.24 U6539.CN9 119.94,133.48 120.24,133.78 v1(120.26,133.78) ; C805.1 197.2,122.52 196.65,123.06 196.29,123.06 v1(196.26,123.09) ; v1(98.6,108.38) 98.57,108.38 98.19,108.76 U6554.3 ; U6539.BW10 120.22,139.19 v1(120.22,139.18) 120.22,139 U6539.BY9 ; v2(26.35,81.58) CN16.33 ; U8.E11 v1(128.91,185.28) ; U8.B27 142.13,182.84 v1(142.13,182.49) ; v1(138.1,190.25) U8.L23 138.94,191.09 139.7,191.09 U8.L25 ; U6539.G52 101.35,162.67 U6539.G51 ; v2(203.63,114.75) 203.63,114.73 203.45,114.55 CN48.19 ; v2(224.28,116.23) 224.28,115.29 223.74,114.75 CN49.27 ; CN17.19 183.25,119.15 183.21,119.2 v1(183.18,119.2) ; v1(122.21,151.08) 122.22,151.08 122.54,151.4 U6539.AM4 ; U6539.CJ9 120.24,135.37 v1(120.24,135.52) ; JDIM1.44 v2(43.82,160.82) ; v2(24.85,81.58) CN16.39 ; CN17.13 v1(185.73,120.65) ; U8.H23 v1(138.92,187.79) ; v1(128.55,180.22) 128.47,180.13 128.24,180.13 v2(127.58,179.47) ; JDIM1.14 44.18,168.32 v2(43.84,167.97) ; U8.B17 133.62,183.13 v1(133.62,182.62) ; JDIM1.72 v2(43.76,153.82) ; v1(120.95,158.4) 120.95,158.3 U6539.V8 ; PU9004.12 162.77,153.16 v3(162.64,153.3) ; JDIM1.60 44.17,156.82 v2(43.8,157.19) ; v1(123.96,190.25) 123.94,190.25 U8.L5 ; v1(139.73,186.15) 139.73,186.09 U8.E25 ; v1(114.65,130.26) U6539.CY22 ; v2(20.49,81.68) 20.35,81.54 CN16.57 ; U6539.BF7 121.24,145.26 v1(121.57,145.59) ; v1(120.19,130.97) 120.19,130.97 120.16,130.95 U6539.CV10 ; U6539.P18 116.13,159.55 v1(115.74,159.93) ; v2(43.8,126.67) 43.96,126.82 JDIM1.172 ; v2(64.92,98.19) 64.7,98.41 CN58.7 ; v1(120.72,187.73) 121.12,188.13 U8.H2 ; U6539.DD45 103.86,128.09 103.53,128.42 103.38,128.42 103.36,128.44 v1(103.34,128.44) ; v2(219.43,99.5) 219.04,99.5 218.9,99.65 CN53.9 ; v2(59.05,194.23) 59.15,194.13 CN29.6 ; v2(231.26,120.8) 231.1,120.96 CN55.9 ; v1(125.64,201.1) 126.06,200.68 U8.AC8 ; CN55.6 230.16,122.46 v2(230.3,122.32) ; v3(164.42,157.29) 164.78,156.93 PU9004.19 ; U8.H5 123.11,187.78 v1(123.11,187.78) ; U6539.DM21 114.57,124.38 v1(114.47,124.38) ; U6539.CY5 122.12,130.02 122.39,130.29 v1(122.4,130.29) 121.98,130.72 U6539.CV5 122.29,131.04 U6539.CU4 121.96,131.61 U6539.CT5 121.96,132.49 U6539.CP5 v1(122.46,132.52) U6539.CP3 ; U6539.DN2 U6539.DN1 ; v1(119.54,183.25) U8.B1 ; v1(120.92,145.59) 120.59,145.26 U6539.BF8 120.59,145 v1(120.92,144.67) 120.59,144.35 U6539.BH8 ; C463.2 128.76,177.84 128.76,174.18 128.56,173.97 124.55,173.97 123.83,174.68 123.83,175.5 124.39,176.06 v2(124.39,177.38) ; U8.AC26 141.15,200.83 142.2,200.83 v1(142.39,201.01) ; U6539.BM8 120.92,142.71 v1(120.92,142.84) 120.92,142.98 U6539.BK8 ; PC6055.1 59.11,180.94 59.55,180.5 59.55,180.49 59.9,180.14 PC6058.2 60.12,179.96 v1(60.55,179.52) ; U6539.DM4 122.2,124.63 121.93,124.9 U6539.DL5 122.23,125.17 v1(122.41,125.34) 122.61,125.55 U6539.DJ4 ; 45.13,149.32 v2(43.84,149.32) ; v2(43.78,159.87) 43.82,159.82 JDIM1.48 ; v1(105.43,163.86) 105.43,163.86 U6539.D42 ; CN52.16 v2(203.35,102.13) ; U6539.DM33 109.12,124.39 v1(109.02,124.39) ; U6539.M2 U6539.M1 124.45,160.62 v1(124.65,160.82) ; v1(118.83,137.36) U6539.CC10 ; v1(76.93,100.73) 75.74,100.73 75.45,100.45 CN14.5 ; v2(87.55,96.92) 87.55,98.75 87.15,99.15 CN4.1 ; v1(122.22,151.99) 122.54,152.32 U6539.AK4 ; U6539.CC5 122.43,137.47 v1(122.44,137.46) 122.94,137.46 U6539.CC3 ; U6539.AD8 120.59,155.06 v1(120.92,154.74) 120.59,154.41 U6539.AF8 ; v2(59.1,194.95) 58.78,194.95 57.65,193.82 CN29.3 ; U9.3 105.8,185.84 105.56,186.08 105.26,186.08 PC9072.2 ; v2(43.8,154.82) 45.13,154.82 ; v1(122.77,148.33) 122.77,148.1 U6539.AY4 ; JDIM1.30 v2(43.83,164.32) ; U8.E14 v1(131.44,186.07) ; JDIM1.86 v2(43.83,150.32)
  BOTTOM w0.3: U6539.D27 U6539.B27 U6539.A27 111.88,166.14 v1(111.97,166.22) ; v1(112.07,160.6) 111.63,160.91 U6539.L28 ; U6539.K28 111.63,161.56 v1(112.07,161.25) ; v1(112.07,159.95) 111.63,160.26 U6539.N28 ; v1(112.07,161.9) 111.63,162.21 U6539.H28 ; v1(112.07,162.55) 111.63,162.86 U6539.G28 ; U6539.DC17 116.39,128.97 v1(116.27,128.97) ; U6539.D32 U6539.B32 U6539.A32 v1(109.94,166.06)
  BOTTOM w0.305: v1(141.33,204.28) 140.92,203.87 U8.AG26 ; U8.AB17 133.86,200.16 v1(133.86,200.19) ; v2(123.54,204.49) 123.54,204.47 123.49,204.42 123.49,203.41 123.57,203.33 U8.AF5 ; v1(132.27,201.86) U8.AD15 ; U8.AE17 133.1,201.85 v1(133.08,201.85) ; U8.T17 134.02,195.15 133.52,194.65 U8.R16 133.02,194.15 132.54,193.67 v1(132.35,193.67) 132.35,193.48 132.02,193.15 U8.P15 131.59,192.72 v1(131.59,192.65) 131.56,192.65 131.05,192.15 U8.N14 130.64,191.76 v1(130.62,191.76) 130.59,191.76 130.57,191.74 130.54,191.74 130.02,191.22 U8.M13 129.58,190.71 v1(129.56,190.71) 129.56,190.69 U8.L12 v1(128.57,189.7) U8.K11 128.02,188.6 v1(128.16,188.46) ; U11.3 127.82,211.65 v2(128.3,212.13) ; U8.L18 135,190.15 134.43,189.57 v1(134.38,189.57) 134.38,189.51 U8.K17 133.76,188.89 v1(133.76,188.64) ; v1(129.79,201.84) 129.77,201.84 U8.AD12 ; U8.L2 121.15,190.67 121.56,190.26 v1(121.56,190.25) ; v1(135.56,201.05) 135.16,201.45 U8.AD19 ; v1(134.79,195.63) 135.02,195.86 U8.U18 ; v1(139.72,200.2) 139.32,199.8 U8.AB24 ; v1(16.43,55.27) 16.3,55.14 C96866.2 C96864.2 ; U6553.6 5.44,48.85 v2(5.25,48.66) ; U8.B8 125.95,183.14 125.95,181.71 v1(126.05,181.61) ; Q6521.1 87.88,189.87 88.01,189.99 88.01,190.27 87.8,190.48 v2(86.52,190.48) 86.53,190.47 86.53,188.74 86.36,188.57 Q6521.4 ; U8.AG2 120.7,204.26 v1(119.93,204.26) ; v1(117.2,126.97) 117.37,126.97 U6539.DG15 ; v1(142.13,182.49) 141.37,182.49 141.32,182.45 U8.A26 ; U8.AE20 136.38,201.85 v1(136.4,201.85) ; U8.AF14 131.4,202.67 v1(131.4,202.65) ; U8.V13 v1(129.47,196.6) U8.U12 128.89,196.15 v1(128.41,195.66) 128.02,195.27 U8.T11 128.01,195.15 v1(127.41,194.55) 127.02,194.16 U8.R10 ; U8.Y23 v1(138.1,198.53) ; VRAM1.B10 165,180.02 v1(164.6,179.62) ; U8.AC5 v1(123.17,201) ; U8.K15 132.21,189.34 132.49,189.34 v1(132.51,189.37) 132.51,189.54 133.02,190.05 U8.L16 133.02,190.15 133.48,190.61 133.48,190.81 v1(133.51,190.84) 133.71,190.84 134.02,191.15 U8.M17 134.51,191.64 v1(134.81,191.64) 135.02,191.84 U8.N18 ; v1(123.11,195.22) 123.51,195.63 U8.U5 ; v1(135.56,200.23) U8.AB20 ; v1(130.64,182.88) 131.01,183.25 U8.B14 ; v1(128.96,200.23) U8.AB11 ; U8.AD13 130.2,201.45 130.6,201.05 v1(130.63,201.05) ; U6539.CJ3 v1(122.43,134.99) ; VRAM1.C3 164.59,174.02 v1(164.6,174.02) ; U8.P23 v1(138.1,192.73) ; v1(110.84,104.15) 110.84,104.29 111.2,104.64 PC10.2 ; v1(126.38,190.37) 126.6,190.15 U8.L10 127.02,190.37 127.22,190.57 v1(127.22,190.65) 127.25,190.65 127.27,190.67 127.3,190.67 127.35,190.72 127.37,190.72 127.8,191.15 U8.M11 128.02,191.24 128.39,191.61 v1(128.39,191.77) 128.41,191.77 128.8,192.15 U8.N12 129.52,192.65 v1(129.52,192.65) 130.02,193.15 U8.P13 130.02,193.17 130.39,193.54 v1(130.62,193.54) 130.62,193.74 U8.R14 131.02,194.15 131.53,194.66 v1(131.77,194.66) 131.77,194.89 132.02,195.15 U8.T15 132.35,195.48 v1(132.35,195.7) 132.58,195.7 U8.U16 133.37,196.49 133.37,196.52 v1(133.39,196.54) 133.44,196.59 133.46,196.59 U8.V17 ; U8.AF8 125.92,203.19 125.92,203.62 125.97,203.67 v1(125.97,203.85) ; v1(128.95,203.44) 128.93,203.44 U8.AF11 ; VRAM2.R4 164.19,203.22 v1(163.82,202.85) ; U8.P5 v1(123.93,193.56) ; CN17.69 185.43,106.65 v2(185.58,106.5) ; U8.AB7 125.33,199.81 v1(125.65,200.12) 126.06,200.54 U8.AC8 ; v1(136.38,202.65) U8.AF20 ; v1(140.52,195.23) 140.52,195.25 140.9,195.63 U8.U26 ; CN55.14 227.81,118.46 227.76,118.51 v2(227.63,118.51) ; v1(133.92,201.05) 134.32,201.45 U8.AD18 ; v1(131.4,201.85) 131.4,201.87 U8.AE14 ; v2(209.85,114.98) 209.29,114.98 208.95,114.64 CN48.8 ; U8.K13 130.02,189.18 v1(130.57,189.73) 130.99,190.15 U8.L14 131.02,190.18 131.54,190.7 131.54,190.83 v1(131.56,190.85) 131.69,190.85 131.99,191.15 U8.M15 132.1,191.15 132.35,191.4 v1(132.35,191.64) 132.64,191.64 133.02,192.02 U8.N16 v1(133.58,192.71) U8.P17 134.32,193.45 134.44,193.45 134.64,193.65 v1(134.81,193.65) 134.81,193.94 U8.R18 ; v1(164.6,202.82) 164.6,202.82 VRAM2.T5 ; U8.AC2 121.08,200.56 v1(120.19,200.56) ; QG17.4 114.05,176.16 v1(114.07,176.17) ; v1(120.49,195.32) 120.81,195.32 U8.U2 ; v1(124.86,198.5) 124.86,198.59 U8.AA7 ; U8.V15 v1(131.52,196.65) U8.U14 130.95,196.15 130.52,195.72 130.52,195.72 130.52,195.72 130.02,195.22 U8.T13 129.52,194.65 v1(129.47,194.65) 129.47,194.6 U8.R12 128.44,193.57 v1(128.39,193.57) 128.02,193.2 U8.P11 127.55,192.68 v1(127.3,192.68) 127.02,192.4 U8.N10 ; VRAM1.E1 162.21,172.42 v1(162.2,172.42) ; U8.P2 v2(120.51,193.15) ; v1(119.91,203.46) U8.AF1 ; v1(140.55,188.62) 140.55,188.62 U8.H25 ; U8.AC22 v1(137.25,201.02) ; v1(138.86,203.44) U8.AF23 ; U8.U10 127.49,196.62 v1(127.49,196.65) 127.52,196.65 U8.V11 ; VRAM2.U1 165.8,206.89 v1(165.7,206.99) ; U8.AE11 128.93,202.64 v1(128.94,202.64) ; U8.AD21 v1(137.22,201.85) U8.AD22 ; U8.Y5 v1(123.11,198.52) ; U6539.G52 99.91,162.67 v1(99.87,162.71) ; v1(130.55,200.22) 130.96,199.81 U8.AB14 ; U8.Y2 120.17,198.11 119.6,197.54 v1(119.47,197.54) ; U6539.BV3 v1(122.46,139.94) U6539.BV5 ; v1(133.08,202.65) 133.08,202.65 133.09,202.65 133.49,203.05 U8.AF17 ; U8.AD16 v1(132.26,201.05)
  BOTTOM w0.33: VRAM2.R11 164.21,197.62 v1(164.6,197.22) ; VRAM2.L10 161,198.42 161.4,198.82 ; VRAM1.D10 163.4,180.02 v1(163,180.42) ; VRAM2.T10 165,198.43 v1(164.6,198.82) ; VRAM2.G10 157.34,198.88 v1(157.25,198.88) ; VRAM1.E3 162.61,174.42 v1(163,174.02) ; v1(152.59,172.41) VRAM1.U1 ; v1(157.4,198.06) 157.05,198.42 VRAM2.F10 ; v1(154.2,194.82) 154.6,195.22 VRAM2.C14 ; VRAM1.H14 160.2,183.22 v1(160.6,183.62) ; v1(163.8,182.02) 164.2,181.62 VRAM1.C12 ; v1(163.8,172.42) 164.2,172.82 VRAM1.C1 ; VRAM2.J10 159.4,198.43 159,198.82 v1(159,198.88) ; VRAM2.K2 159.8,205.22 v1(159.8,205.22) 159.81,205.22 VRAM2.K1 ; VRAM2.N1 162.6,205.62 162.25,205.97 v1(162.2,205.97) ; v1(165.4,172.42) 165.8,172.82 VRAM1.A1 ; VRAM2.A3 152.64,204.38 v1(152.61,204.38) ; VRAM1.N3 156.2,174.42 v1(156.6,174.82) ; VRAM2.J1 159.4,205.63 v1(159,206.02) ; VRAM2.P10 163.4,198.42 v1(163.8,198.82) ; VRAM1.R12 154.61,181.62 v1(155,181.22) 154.6,180.82 VRAM1.R11 ; VRAM2.N12 163,196.42 v1(163,196.39) ; v1(162.99,194.59) 162.99,194.83 VRAM2.N14 ; VRAM2.A1 v1(152.56,206.06) ; VRAM2.B5 153.81,202.42 v1(154.2,202.81) 154.6,203.21 VRAM2.C4 ; VRAM1.U12 152.56,181.62 v1(152.42,181.48) ; VRAM2.R1 164.2,205.62 v1(163.8,206.02) ; v1(163.8,181.22) 164.2,180.82 VRAM1.C11 ; v1(155,198.88) 155,198.82 155.4,198.43 VRAM2.D10 ; VRAM2.L5 161.01,202.42 v1(161.4,202.02) 161.8,202.42 VRAM2.M5 ; VRAM1.U3 v1(153.38,174.8) ; VRAM1.A12 165.81,181.62 v1(166.2,181.22) ; VRAM1.R4 154.6,175.18 v1(154.99,174.79) 154.63,174.42 VRAM1.R3 ; VRAM1.T10 153.8,180 v1(153.41,179.61) ; VRAM2.C1 154.97,205.24 v1(155,205.24) ; v1(152.65,197.2) 152.65,197.17 VRAM2.A12 ; VRAM1.K13 158.6,182.43 v1(158.2,182.82) ; VRAM2.U14 165.81,195.22 v1(166.2,194.82) ; VRAM2.C11 154.6,197.59 154.21,197.2 v1(154.2,197.2) 154.58,196.82 VRAM2.C12 ; v1(160.6,182.82) 160.2,182.42 VRAM1.H13 ; VRAM2.E14 v1(156.2,194.68) ; VRAM1.F5 161.8,176.02 v1(161.4,176.42) 161,176.02 VRAM1.G5 ; v1(166.2,183.62) 165.8,183.22 VRAM1.A14 ; VRAM2.H13 158.2,195.62 v1(158.2,195.57) 158.56,195.22 VRAM2.H14 ; v1(162.2,183.62) 162.6,183.22 VRAM1.E14 ; v1(164.58,204.4) VRAM2.R3 ; VRAM2.A14 153,195.22 v1(152.62,194.84) ; v1(165.4,175.62) 165.01,176.02 VRAM1.B5 ; v1(162.2,181.22) 162.6,181.62 VRAM1.E12 ; VRAM2.K13 160.2,195.97 v1(159.8,195.57) 159.84,195.57 VRAM2.K14 ; VRAM1.P10 v1(155.02,179.64) ; v1(166.2,174.02) 165.81,174.42 VRAM1.A3 ; VRAM1.H1 160.2,172.82 v1(159.8,172.42) 159.41,172.82 VRAM1.J1 ; 161.4,198.82 v1(161.4,198.88) ; 161.4,198.82 161.8,198.42 VRAM2.M10 ; VRAM1.R1 154.6,172.82 v1(154.2,172.42) ; VRAM1.U14 152.72,183.22 v1(152.49,182.99) ; VRAM1.H2 160.2,173.62 v1(159.8,173.22) ; v1(155.81,206) VRAM2.E1 ; VRAM1.N12 156.2,181.63 v1(155.8,182.02) ; v1(166.2,203.62) 165.81,204.02 VRAM2.U3 ; v1(164.6,196.42) 164.59,196.42 VRAM2.R12 ; VRAM1.N1 156.2,172.31 v1(155.78,171.89) ; VRAM2.C3 154.24,204.38 v1(154.2,204.38) ; VRAM1.M5 157,176.02 v1(157.4,176.42) 157.8,176.03 VRAM1.L5 ; v1(158.2,206.02) 158.6,205.63 VRAM2.H1 ; VRAM1.K2 158.6,173.62 v1(158.2,173.22) 158.6,172.83 VRAM1.K1 ; v1(154.19,175.58) 153.8,175.97 VRAM1.T5 ; v1(155.8,204.38) 155.85,204.38 156.2,204.03 VRAM2.E3 ; v1(166.2,197.22) 166.2,197.22 VRAM2.U12 ; v1(154.2,183.62) 154.6,183.23 VRAM1.R14 ; VRAM1.N14 v1(155.81,183.6) ; v1(163.8,194.82) 164.2,195.22 VRAM2.R14 ; VRAM2.G5 157.8,202.42 157.41,202.03 v1(157.4,202.03) 157.4,202.03 157.01,202.42 VRAM2.F5 ; v1(163.8,183.62) 164.2,183.22 VRAM1.C14 ; VRAM1.K14 158.6,183.23 v1(158.2,183.62) ; VRAM1.G10 161.01,180.02 v1(161.4,179.62) 161.8,180.02 VRAM1.F10 ; VRAM1.L10 157.8,180.02 v1(157.4,179.62) 157.01,180.02 VRAM1.M10
  BOTTOM w0.356: VRAM1.C4 164.21,175.22 v1(164.6,174.82) ; U8.E22 137.67,185.65 v1(138.06,185.26) ; R405.1 158.88,187.4 v2(158.88,188.11) ; v1(154.2,198.06) 154.19,198.06 153.83,198.42 VRAM2.B10 ; VRAM2.H2 VRAM2.H1
  BOTTOM w0.381: v2(28.49,53.87) 28.87,53.87 29.73,53.02 Q6565.1 ; v1(159.66,139.24) 159.63,139.24 159.61,139.21 159.19,139.21 PC7037.2 PC7035.2 ; C96868.1 23.41,47.65 23.46,47.6 v1(23.67,47.6) ; v2(206.8,119.15) 206.44,118.78 Q6601.4 ; PQ9010.1 105.03,189.08 104.57,188.62 v2(104.57,188.39) ; PC6013.2 v2(183.38,134.06) ; C737.1 v2(221.46,122.75) ; PR9077.2 103.71,191.95 103.35,191.59 v2(103.27,191.59) 102.48,191.59 PQ9011.1 ; C96888.2 207.02,118.01 v2(207.31,117.73) ; v2(29.71,31.37) 29.43,31.65 C578.2 C585.2 29.01,29.62 v2(29,29.61) ; v1(20.09,67.46) 20.09,67.43 19.72,67.07 C96825.1 ; PC73.1 165.99,120.72 v1(166.09,120.72) 166.09,120.68 PR23.2 ; PC9072.2 105.2,186.46 105.18,186.48 105.18,186.92 v2(105.28,187.02) ; v5(23.67,61.24) 23.31,61.61 C96830.1 ; PC37.1 167.82,122.72 v2(168.19,122.35) ; v1(129.56,181.05) 130.78,179.83 131.46,179.83 131.85,179.44 R350.1 ; PR6024.2 62.14,183.67 62.53,183.28 v2(62.53,182.65) ; v1(136.38,185.21) 135.98,185.61 U8.E20 ; v1(24.71,71.65) 24.71,71.12 25.7,70.13 EC10.2 ; v2(165.53,141.6) 165.41,141.6 PC7039.2 PC7044.2 ; v2(102.66,186.03) 102.71,186.08 102.97,186.08 103.23,186.34 PC9071.2 ; PU3002.2 131.33,118.58 131.98,119.23 PR3021.1 ; PC9012.2 104.95,199.44 v1(104.96,199.43) ; C752.1 C753.1 116.39,103.26 117.06,102.59 v1(117.67,102.59) ; PC6230.2 6.41,40.65 v2(6.27,40.79) ; C96816.2 19.6,64.13 v5(19.67,64.21) ; v1(113.81,104.16) 113.81,104.82 113.47,105.17 113.47,105.46 C750.1 ; Q6610.1 171.43,150.45 v2(171.75,150.77) ; C96631.2 C96584.2 v1(128.32,160.82) ; PC6231.2 12.23,35.07 v2(12.49,35.33) ; C96832.1 18.87,64.04 v5(19.03,64.2) ; v2(27.73,36.22) 27.18,36.22 C581.2 ; v2(221.59,103.97) 221.25,104.31 C528.1 ; R68681.2 5.51,53.74 v1(5,54.25) ; v2(6.27,40.03) 5.94,39.7 PC6229.1 ; v1(156.6,197.2) 156.22,196.82 VRAM2.E12 ; v1(159.78,180.46) 159.4,180.08 VRAM1.J10 ; v1(3.27,48.54) 3.27,48.04 R69006.2 ; PC9073.2 99.58,182.67 99.58,182.68 99.58,183.32 v2(99.49,183.41) ; v2(126.79,166.04) 126.86,166.1 C96599.2 ; PC11.2 107.45,105.34 106.62,106.17 PD4.2 105.88,105.69 105.63,105.43 105.2,105.43 104.87,105.1 v1(104.87,104.04) ; PC35.2 PC36.1 159.79,124.99 v2(160.45,124.99) ; v2(58.57,183.94) 59.07,183.44 PR6031.1 59.42,183.76 PQ6001.1 ; v2(173.15,133.17) 173.15,132.98 PC6023.2 ; C96826.1 18.44,68.22 v1(18.33,68.32) 17.85,67.84 C96821.1 C96822.1 ; v2(175.08,135.08) 175.08,135.05 175.66,134.47 PR6014.1 ; v1(163,204.42) 162.6,204.02 VRAM2.N3 ; v2(18.31,39.77) 18.31,39.32 R469.2 ; C96817.2 22.41,69.34 v1(21.92,69.34) ; PR7070.1 167.57,137.36 v2(167.47,137.46) ; v1(81.58,95.65) 81.58,96.54 81.84,96.8 CN4.8 ; PC6.1 155.7,112.98 155.18,113.49 155.18,113.78 v1(155.17,113.79) ; C463.2 128.3,178.48 127.58,179.19 v2(127.58,179.47) ; C96834.1 17.23,66.11 v5(17.65,66.11) ; C96833.1 18.15,61.3 v5(17.66,61.3) ; v2(30.65,31.65) 30.65,31.89 C595.2 ; C96624.2 126.91,161.56 126.49,161.14 126.49,160.82 v1(126.49,160.82) ; C96767.2 111.42,116.15 111.55,116.02 v1(111.55,115.97) ; PC6228.2 132.39,114.95 132.28,115.06 PU3002.4 ; v2(16.1,35.34) 15.95,35.19 C567.2 ; v1(110.92,106.45) 110.92,106.52 PD3.2 ; v2(55.48,197.59) 54.95,197.06 CN29.41 ; C96818.2 20.84,68.31 20.82,68.32 v1(20.77,68.32) ; C96596.2 v2(131.36,163.73) ; v5(19.03,65.5) 18.71,65.82 C96831.1 ; v5(23.8,64.79) 23.42,65.16 C96819.1 ; v2(213.41,123.85) 213.14,123.58 C734.1 ; PR5027.2 68.89,186.83 68.5,187.22 v1(68.5,187.47) ; v1(170.48,136.42) 170.74,136.42 PR6012.2 ; PC6039.1 56.04,187.86 v2(55.67,187.86) ; v1(160.52,113.61) 160.52,113.26 160.24,112.98 PC4.1 ; v2(19.1,17.8) 19.37,18.07 R470.1 ; v2(19.1,39.24) 18.96,39.38 C574.2 ; v2(79.67,95.4) 79.13,95.95 CN14.9 ; Q81.1 14.63,147.23 v2(14.46,147.41) ; C96320.2 31.67,39.77 v2(31.54,39.65) 31.41,39.65 C96906.1 ; Q6617.1 7.61,55.84 v2(7.16,55.39) ; Q31.1 213.52,119.13 213.79,119.4 v2(214.35,119.4) ; PR7053.2 166.54,143.66 166.26,143.38 v2(166.26,143.15) ; C96892.2 169.5,136.64 v1(169.72,136.42) ; v2(6.14,36.85) 5.59,36.85 PR283.2 ; Q6570.1 31.24,56.41 v2(30.65,56.41) ; v2(158.47,135.61) 158.47,136.6 158.85,136.98 PC7054.2 ; C446.1 146.41,192.75 v2(146.26,192.9) 146.11,192.75 C451.1 ; v2(115.11,190.01) 115.11,190.27 115.62,190.78 PR9031.1 ; C736.2 v2(219.89,122.07) ; v2(6.13,34.54) 6.23,34.44 PU3003.2 ; v5(23.82,63.58) 23.65,63.41 C96824.1 23.02,63.52 C96820.2 ; v2(126.79,162.84) 127.16,163.21 C96578.2 127.16,163.76 v2(126.79,164.13) ; C464.2 v2(125.74,179.47) ; C96867.1 23.04,48.53 23.36,48.21 v1(23.67,48.21) ; v2(29.66,32.66) R25495.1
  BOTTOM w0.457: S1.3 S1.2 S1.1 92.98,107.88 v1(92.69,108.16)
  BOTTOM w0.508: v2(76.88,198.6) 76.93,198.6 77.85,197.68 CN29.42 ; v2(69.26,99.34) 69.77,98.83 69.77,97.94 69.35,97.52 CN58.16 70.84,96.85 70.94,96.95 CN14.10 ; v2(200.45,100.23) 200.45,99.21 201.51,98.15 CN52.18 ; FAN3.5 175.35,113.08 174.04,111.76 v2(174.04,111.66) ; v2(88.95,198.24) 89.11,198.4 CN63.5 ; JDIM02.262 73.23,102.41 72.49,101.67 v2(72.49,101.39) ; v2(218.49,103.02) 218.23,103.02 217.79,103.46 C527.1 ; v2(233.34,115.72) 233.25,115.81 CN55.18 ; v2(167.08,111.22) 167.08,110.98 167.4,110.66 CN19.2 ; v2(145.21,208.68) 145.21,208.34 C383.1 ; PC6028.2 206.67,127.71 v2(206.37,128.01) 206.01,128.37 PC6029.2 ; PC18.1 165.6,118.64 v2(165.72,118.52) 165.28,118.09 PC756.2 ; v2(68.3,181.81) SW4.6 ; PJ1.10 97.02,99.28 97.33,99.59 v1(97.33,100.1) ; CN49.32 225.75,110.74 226.08,110.41 v2(226.77,110.41) ; v2(9.32,48.28) 9.2,48.16 C96854.1 ; CN48.24 200.25,110.71 199.31,111.66 v2(199.31,111.81) ; C96311.1 15.02,162.46 15.29,162.2 v2(15.29,162) ; CN1.2 4.28,10.21 4.9,10.83 v2(4.9,11.33) ; v2(40.94,185.7) 40.18,185.7 39.82,185.34 U25.25 ; v2(225.29,132.81) 224.85,132.37 CN13.6 ; v2(198.29,100.73) 198.52,100.51 CN18.29 ; CN33.10 124.86,97.96 125.39,97.96 v2(125.42,97.94) ; v1(115.23,97.46) 115.23,97.94 115.49,98.19 116.24,98.19 116.5,97.92 PJ1.9 ; v2(102.66,186.03) 102.66,185.06 103.15,184.57 PU9003.2 ; v2(132.48,116.71) 132.25,116.94 131.67,116.94 131.33,117.28 PU3002.2 ; PC242.2 4.97,32.38 v2(5,32.41) ; v2(35.78,174.21) 37.23,172.76 JDIM1.261 ; v2(231.57,110.77) 230.68,110.77 230.4,111.05 SW5.4 ; v2(180.89,120.55) 180.95,120.49 FAN3.4 ; v2(213.79,107.97) 214.15,108.34 CN48.23 ; SW4.2 63.95,177.85 63.5,177.39 v2(63.5,176.43) ; CN53.12 v2(215.75,96.77) ; CN67.1 48.5,197.25 49.01,196.75 v2(49.45,196.75) ; CN52.17 v2(212.5,96.96) ; C597.1 7.72,31.45 v2(7.54,31.26) ; v2(159.18,211.48) 158.95,211.25 C487.2 ; CN18.30 168.86,98.8 v2(168.98,98.68) ; v2(11.86,36.82) 12.21,36.47 R463.1 ; CN11.23 223.91,107.3 222.8,106.19 v2(222.8,105.38) ; v2(141.5,106.73) 140.23,108 CN19.30 ; v2(207.31,122.58) 207.73,122.99 C96882.2 ; SW5.3 v2(234.46,111.5) ; PC6046.2 43.89,178.46 43.77,178.33 43.73,178.33 v2(43.35,177.95) ; v2(99.49,183.41) 99.49,183.93 99.31,184.11 PR9082.1 ; v2(72.72,185.44) 72.69,185.47 72.69,186.2 73.1,186.61 PU5000.2 ; v2(58.52,177.57) 58.08,177.57 57.27,178.38 PC6054.2 ; v2(94.13,206.65) 92.74,206.65 CN63.6 ; PC229.2 6.69,36.09 v2(6.14,36.09) ; D13094.2 6.77,30.4 v2(6.28,30.89) ; PU3002.4 132.28,115.97 v2(132.1,116.15) ; CN64.6 37.07,96.6 v2(36.49,97.18) ; Y3.4 124.59,174.94 v2(124.38,175.16) ; v2(133.68,97.94) 133.68,97.41 134.03,97.05 CN33.9 ; v2(63.3,181.89) SW4.5 ; v2(96.35,187.48) 96.35,187.66 96.76,188.07 PQ9009.1 ; v2(12.01,33.55) R467.1 ; CN49.31 v2(225.75,130.32) ; CN13.1 221.62,136.93 v2(223.36,136.93) ; CN11.21 222.97,103.3 v2(222.96,103.28) ; C473.2 162.43,167.44 162.4,167.41 v2(162.38,167.41) ; CN17.77 185.15,103.34 185.44,103.04 v2(186.74,103.04) ; v2(153.75,121.72) 153.82,121.79 PC16.2 ; Y6.4 v2(129.89,124.99) ; v2(161.59,169.54) 161.21,169.16 C504.2 ; JDIM1.262 v2(37.23,108.15) ; U18.2 v2(217.85,107.24) ; v2(127.77,177.66) Y3.2 ; v2(62.42,186.9) 62.61,186.71 63.34,186.71 SW4.1 ; CN55.17 v2(233.09,126.61)
  vias: v1(11.22,49.3) v1(11.22,48.66) v1(11.5,49.86) v1(11.58,51.03) v1(12.11,52.55) v1(12.49,65.05) v1(14.65,51.97) v1(14.65,48.16) v1(14.93,66.21) v1(15.54,63.8) v1(15.54,61.96) v1(15.59,64.91) v1(18.46,51.97) v1(18.46,48.16) v1(21.51,104.31) v1(22.78,85.87) v1(23.39,87.12) v1(23.67,88.95) v1(23.92,84.48) v1(25.45,85.32) v1(26.03,86.18) v1(26.08,64.26) v1(26.08,63.22) v1(26.08,62.61) v1(26.06,60.72) v1(26.28,66.65) v1(27.43,65) v1(27.48,102.13) v1(29.38,102.13) v1(31.01,101.11) v1(31.03,99.97) v1(31.19,102.51) v1(31.41,83.77) v1(33.83,150.9) v1(33.95,155.85) v1(68.5,191.92) v1(84.09,98.93) v1(91.23,102.69) v1(92.85,149.2) v1(93.21,147.85) v1(93.62,153.56) v1(93.63,150.65) v1(93.99,154.16) v1(94.1,149.2) v1(94.07,144.07) v1(94.07,141.79) v1(94.25,146.2) v1(94.43,147.85) v1(94.52,153.56) v1(94.56,157.66) v1(94.63,139.75) v1(94.67,150.54) v1(94.76,151.43) v1(94.91,161.06) v1(95.09,143.63) v1(95.42,132.48) v1(95.46,149.2) v1(95.52,137.97) v1(95.88,140.33) v1(96.06,167.41) v1(96.13,139.54) v1(96.42,153.51) v1(96.44,132.99) v1(96.51,150.55) v1(96.82,148.74) v1(96.95,157.76) v1(97.07,159.92) v1(97.07,144.07) v1(97.51,161.04) v1(98.6,160.17) v1(100.53,167.41) v1(101.09,204.24) v1(101.09,203.6) v1(101.09,202.97) v1(101.09,202.33) v1(101.1,120.67) v1(101.72,204.24) v1(101.72,203.6) v1(101.72,202.97) v1(101.72,202.33) v1(101.86,160.15) v1(101.91,135.61) v1(101.99,133.12) v1(102.36,204.24) v1(102.36,203.6) v1(102.36,202.97) v1(102.36,202.33) v1(102.83,160.55) v1(102.76,123.72) v1(102.94,161.33) v1(102.94,142.21) v1(102.99,141.24) v1(103.54,155.95) v1(103.54,143.03) v1(103.54,130.28) v1(103.55,161.34) v1(103.55,160.55) v1(103.64,159.56) v1(103.55,148.61) v1(103.64,145.85) v1(103.55,142.24) v1(103.62,141.24) v1(103.61,138.5) v1(103.65,151.33) v1(104.21,163.25) v1(104.19,161.34) v1(104.19,160.55) v1(104.22,155.96) v1(104.22,154.13) v1(104.19,148.67) v1(104.19,143.03) v1(104.17,142.24) v1(104.18,137.58) v1(104.23,135.82) v1(104.16,130.28) v1(104.27,159.56) v1(104.29,151.33) v1(104.29,145.85) v1(104.27,141.22) v1(104.82,161.36) v1(104.85,160.55) v1(104.84,155.99) v1(104.84,148.67) v1(104.84,135.84) v1(104.95,157.72) v1(104.95,154.06) v1(104.95,151.33) v1(104.95,145.85) v1(104.86,142.25) v1(104.87,137.58) v1(104.96,143.08) v1(104.98,139.42) v1(104.96,130.28) v1(105.33,169.26) v1(105.38,119.15) v1(105.46,161.34) v1(105.48,160.55) v1(105.51,155.95) v1(105.45,148.64) v1(105.52,142.24) v1(105.52,135.84) v1(105.6,157.72) v1(105.6,156.8) v1(105.6,154.06) v1(105.6,151.31) v1(105.6,145.85) v1(105.57,143.05) v1(105.56,138.53) v1(105.58,137.61) v1(106.12,161.34) v1(106.12,160.55) v1(106.24,163.24) v1(106.2,159.53) v1(106.22,158.63) v1(106.25,157.72) v1(106.34,170.07) v1(106.32,168.17) v1(106.32,119.48) v1(106.7,160.5) v1(107.22,149.26) v1(107.22,148.68) v1(107.22,148.1) v1(107.22,147.51) v1(107.22,146.93) v1(107.24,144) v1(107.24,143.42) v1(107.22,141.04) v1(107.22,140.46) v1(107.22,138.54) v1(107.22,137.96) v1(107.22,133.04) v1(107.23,132.43) v1(107.2,127) v1(107.59,170.07) v1(107.56,168.25) v1(108,176.63) v1(108.63,168.42) v1(109.35,169.76) v1(109.35,168.9) v1(109.28,161.12) v1(109.28,160.47) v1(109.34,156.72) v1(109.33,156.09) v1(109.37,161.86) v1(110.51,128.29) v1(110.8,120.09) v1(113.73,165.75) v1(113.78,164.07) v1(114.47,126.39) v1(114.78,162.53) v1(114.78,161.88) v1(114.78,161.23) v1(114.78,160.58) v1(114.78,159.93) v1(115.29,156.05) v1(115.41,127.61) v1(115.41,126.99) v1(115.74,162.53) v1(115.74,161.88) v1(115.74,161.23) v1(115.92,156.03) v1(116.87,165.05) v1(116.87,163.35) v1(117.55,161.26) v1(118.03,158.4) v1(118.43,137.8) v1(118.41,136.91) v1(118.47,162.06) v1(118.92,158.4) v1(119.04,199.41) v1(119.04,129.12) v1(119.94,128.17) v1(120.32,151.08) v1(120.95,150.16) v1(121.51,111.27) v1(122.35,101.62) v1(122.3,99.46) v1(124.38,138.4) v1(124.47,147.55) v1(124.76,139.85) v1(125.14,206.18) v1(125.78,153.06) v1(126.21,138.4) v1(126.41,159.18) v1(126.42,147.56) v1(126.41,146.45) v1(126.48,201.82) v1(126.46,128.9) v1(126.56,205.43) v1(126.66,135.53) v1(126.66,132.48) v1(127.05,130.2) v1(127.68,153.06) v1(127.68,151.91) v1(128.16,187.83) v1(128.21,135.53) v1(128.19,129.26) v1(128.29,159.18) v1(128.57,132.48) v1(128.95,130.2) v1(128.95,139.34) v1(129.46,141.5) v1(129.59,153.06) v1(129.59,135.61) v1(130.35,139.34) v1(130.53,156.41) v1(130.83,130.2) v1(131.56,180.86) v1(131.87,162.61) v1(131.87,160.68) v1(131.87,156.36) v1(132.5,180.62) v1(132.48,159.94) v1(132.48,157.88) v1(136.82,123.34) v1(136.82,122.7) v1(136.82,122.07) v1(138.94,196.82) v1(142.84,192.02) v1(143.15,199.64) v1(143.54,203.22) v1(143.65,201.04) v1(145.33,145.31) v1(145.33,144.68) v1(145.33,144.04) v1(145.33,143.41) v1(146.48,145.31) v1(146.48,144.68) v1(146.48,144.04) v1(146.48,143.41) v1(147.75,145.31) v1(147.75,144.68) v1(147.75,144.04) v1(147.75,143.41) v1(149.02,144.29) v1(149.02,143.41) v1(153.59,105.31) v1(163.02,201.39) v1(186.23,109.39) v1(190.75,117.4) v1(196.57,109.39) v2(1.76,55.4) v2(1.76,54.13) v2(1.76,52.86) v2(1.76,51.59) v2(1.76,50.32) v2(1.76,49.05) v2(1.76,47.78) v2(1.76,46.51) v2(1.76,45.24) v2(1.76,43.97) v2(1.76,35.68) v2(1.76,34.41) v2(1.76,33.14) v2(1.76,31.87) v2(1.84,30.57) v2(1.76,13.38) v2(1.76,12.11) v2(1.76,10.84) v2(1.76,9.57) v2(1.76,8.3) v2(2.35,3.36) v2(2.68,56.28) v2(2.71,36.34) v2(2.76,41.75) v2(2.76,40.48) v2(2.76,39.21) v2(2.76,37.94) v2(3.03,30.51) v2(3.26,116.14) v2(3.26,114.87) v2(3.95,56.28) v2(4.07,138.75) v2(4.14,61.04) v2(4.3,30.48) v2(4.61,98.84) v2(4.86,147.36) v2(4.86,146.09) v2(4.86,144.82) v2(4.86,143.55) v2(4.86,142.28) v2(4.86,141.01) v2(4.86,139.74) v2(5.07,56.88) v2(5.13,30.58) v2(5.21,59.4) v2(5.28,193.19) v2(5.26,58.13) v2(5.35,203.37) v2(5.41,194.59) v2(5.43,148.5) v2(5.51,44.35) v2(5.58,99.66) v2(6.16,203.31) v2(6.22,44.35) v2(6.36,193.86) v2(6.36,164.57) v2(6.4,163.42) v2(6.4,150.59) v2(6.68,194.59) v2(6.94,135.94) v2(6.85,99.66) v2(6.9,44.35) v2(7.03,203.35) v2(7.03,119.02) v2(7.07,114.78) v2(7.45,97.19) v2(7.63,193.86) v2(7.67,44.37) v2(7.79,164.74) v2(7.91,194.89) v2(8.02,203.02) v2(8.05,59.76) v2(8.06,96.68) v2(8.2,136.11) v2(8.27,118.78) v2(8.34,114.78) v2(8.3,44.07) v2(8.56,192.99) v2(8.58,60.09) v2(8.58,11.81) v2(9.09,146.35) v2(9.09,9.45) v2(9.15,194.6) v2(9.3,156.26) v2(9.27,97.06) v2(9.5,118.45) v2(9.5,115.3) v2(9.98,155.19) v2(10.01,153.48) v2(10.16,195.36) v2(10.52,97.28) v2(10.56,121.81) v2(10.58,118.52) v2(10.58,99.06) v2(10.66,73.63) v2(10.77,115.38) v2(11.25,117.42) v2(11.3,6.82) v2(11.38,10.63) v2(11.38,9.36) v2(11.38,8.09) v2(11.84,98.94) v2(11.79,97.34) v2(12.01,115.64) v2(12.07,12.1) v2(12.31,146.48) v2(12.36,117.04) v2(12.74,155.49) v2(12.7,154.48) v2(12.8,174.39) v2(12.85,79.93) v2(12.93,13.04) v2(12.99,97.76) v2(13,78.86) v2(13,78.2) v2(13.13,192.54) v2(13.07,98.6) v2(13.16,177.73) v2(13.21,175.23) v2(13.27,115.77) v2(13.34,80.61) v2(13.67,190.92) v2(13.74,79.09) v2(13.71,78.43) v2(13.95,96.92) v2(14.01,102.03) v2(13.97,99.49) v2(14.22,175.89) v2(14.33,115.42) v2(14.27,98.57) v2(14.27,97.81) v2(14.85,97.46) v2(15.01,152.13) v2(15.24,79.8) v2(15.44,133.96) v2(15.47,13.11) v2(15.64,84.35) v2(15.66,155.48) v2(15.9,97.84) v2(16.12,128.19) v2(16.74,13.11) v2(16.94,128.93) v2(17.14,155.51) v2(17.62,169.57) v2(17.57,125.85) v2(17.62,97.96) v2(17.72,194.79) v2(17.74,194.07) v2(17.97,152) v2(18.01,13.11) v2(18.3,174.26) v2(18.48,33.73) v2(18.49,32.41) v2(18.51,31.01) v2(18.61,175.79) v2(18.56,167.94) v2(18.56,166.98) v2(18.56,166.01) v2(18.56,165.05) v2(18.56,164.08) v2(18.69,174.87) v2(18.91,14.01) v2(19.11,155.63) v2(19.07,109.62) v2(19.1,97.18) v2(19.1,96.42) v2(19.22,159.48) v2(19.16,86.01) v2(19.27,176.41) v2(19.4,174.86) v2(19.43,93.52) v2(19.53,167.94) v2(19.53,166.98) v2(19.53,166.01) v2(19.53,165.05) v2(19.53,164.08) v2(19.55,70.43) v2(19.83,109.54) v2(19.84,108.86) v2(19.76,97.18) v2(19.76,96.42) v2(19.81,14.91) v2(19.86,153.42) v2(20.04,176.4) v2(20.1,159.87) v2(20.11,32.41) v2(20.11,30.95) v2(20.15,33.75) v2(20.55,194.49) v2(20.49,167.94) v2(20.49,166.98) v2(20.49,166.01) v2(20.49,165.05) v2(20.49,164.08) v2(20.7,15.8) v2(20.81,154.21) v2(21.05,89.4) v2(21.13,85.37) v2(21.3,194.5) v2(21.38,152.96) v2(21.46,167.94) v2(21.46,166.98) v2(21.46,166.01) v2(21.46,165.05) v2(21.46,164.08) v2(21.51,86.71) v2(21.6,16.7) v2(21.78,33.75) v2(21.76,32.42) v2(21.76,30.97) v2(22.09,88.29) v2(22.19,75.61) v2(22.42,167.94) v2(22.42,166.98) v2(22.42,166.01) v2(22.42,165.05) v2(22.42,164.08) v2(22.37,155.85) v2(22.45,17.48) v2(23.16,157.38) v2(23.35,18.38) v2(23.4,197.22) v2(23.36,152.62) v2(23.72,151.09) v2(23.7,39.63) v2(23.92,127.53) v2(23.92,123.97) v2(24.25,19.27) v2(24.3,95.86) v2(24.25,38.93) v2(24.38,157.05) v2(24.39,156.39) v2(24.43,39.65) v2(24.67,197.22) v2(24.79,96.34) v2(25.08,157.07) v2(25.06,156.4) v2(25.06,95.02) v2(25.14,20.17) v2(25.17,154.12) v2(25.7,125.75) v2(25.94,197.22) v2(26.04,21.07) v2(26.38,152.3) v2(26.59,151.34) v2(26.94,21.97) v2(27.04,152.98) v2(27.21,197.22) v2(27.22,164.13) v2(27.48,127.53) v2(27.48,123.97) v2(27.84,22.87) v2(28.21,195.65) v2(28.19,165.27) v2(28.48,197.22) v2(28.74,23.76) v2(29.75,197.22) v2(29.91,153.44) v2(29.94,151.79) v2(30.02,158.77) v2(30.4,61.03) v2(30.4,60.37) v2(30.78,152.68) v2(30.78,132.36) v2(30.78,131.47) v2(30.78,85.49) v2(31.02,197.22) v2(31.63,153.39) v2(31.62,151.75) v2(31.77,163.85) v2(31.77,163.19) v2(31.77,162.53) v2(31.8,126.16) v2(32.29,197.22) v2(32.28,128.93) v2(32.41,195.6) v2(32.43,124.36) v2(32.46,123.21) v2(33.32,125.5) v2(33.49,135.13) v2(33.49,134.47) v2(33.52,67.81) v2(33.56,197.22) v2(34.19,195.6) v2(34.29,77.52) v2(34.31,68.34) v2(34.31,67.68) v2(34.31,67.02) v2(34.36,128.93) v2(34.59,76.73) v2(34.67,25.09) v2(34.83,197.22) v2(35.1,190.63) v2(35.22,77.75) v2(35.22,76.98) v2(35.72,25.8) v2(35.84,68.98) v2(35.84,67.71) v2(35.84,66.44) v2(35.84,65.17) v2(35.84,63.9) v2(35.84,62.63) v2(35.84,61.36) v2(35.84,60.09) v2(35.84,58.82) v2(35.84,57.55) v2(35.84,48.66) v2(35.84,46.12) v2(35.84,43.58) v2(35.84,41.04) v2(35.84,38.5) v2(35.84,35.96) v2(35.84,33.42) v2(35.84,32.15) v2(35.84,30.88) v2(35.84,29.61) v2(35.84,28.34) v2(35.84,27.07) v2(35.86,120.67) v2(35.99,190.65) v2(36.1,197.25) v2(36.31,70.16) v2(36.36,140.74) v2(36.75,190.65) v2(36.88,156.41) v2(36.88,149.86) v2(37.11,140.75) v2(37.21,71.08) v2(37.34,86.29) v2(37.34,85.02) v2(37.34,83.75) v2(37.34,82.48) v2(37.34,77.4) v2(37.34,76.13) v2(37.34,74.86) v2(37.34,73.59) v2(37.34,72.32) v2(37.54,190.65) v2(37.51,155.22) v2(37.51,154.2) v2(37.51,152.8) v2(37.54,151.41) v2(37.64,155.98) v2(37.64,150.52) v2(38.2,190.78) v2(38.99,163.8) v2(38.99,163.14) v2(38.99,162.48) v2(39.03,156.99) v2(39.03,156.11) v2(39.03,155.09) v2(39.03,152.17) v2(39.03,151.41) v2(39.03,149.63) v2(39.03,148.74) v2(39.21,134.86) v2(39.19,134.16) v2(42.87,89.13) v2(43.83,124.81) v2(43.78,113.79) v2(44.11,187.65) v2(44.14,89.13) v2(44.93,187.37) v2(45.41,89.13) v2(45.81,202.04) v2(46.14,188.04) v2(46.15,99.44) v2(46.17,102.77) v2(46.41,167.33) v2(46.43,159.81) v2(46.45,147.32) v2(46.43,121.88) v2(46.41,116.32) v2(46.43,107.78) v2(46.51,171.35) v2(46.48,169.39) v2(46.47,165.57) v2(46.45,161.84) v2(46.45,154.84) v2(46.5,151.15) v2(46.5,148.07) v2(46.45,146.4) v2(46.45,123.7) v2(46.49,113.37) v2(46.47,112.35) v2(46.49,111.32) v2(46.45,108.84) v2(46.63,152.3) v2(46.65,110.05) v2(46.68,89.13) v2(46.81,170.3) v2(46.85,188.04) v2(46.91,163.29) v2(46.91,99.44) v2(47,120.73) v2(47.13,141.94) v2(47.09,102.77) v2(47.29,140.36) v2(47.45,123.32) v2(47.47,107.12) v2(47.59,188.04) v2(47.75,167.35) v2(47.7,161.84) v2(47.72,156.42) v2(47.75,121.89) v2(47.75,107.78) v2(47.79,165.56) v2(47.84,157.89) v2(47.8,154.86) v2(47.85,151.1) v2(47.85,133.63) v2(47.8,125.09) v2(47.75,118.32) v2(47.75,116.44) v2(47.81,113.37) v2(47.81,111.34) v2(47.95,89.13) v2(48.35,202.04) v2(48.27,142.89) v2(48.31,126.13) v2(48.31,106.75) v2(48.47,169.22) v2(48.48,136.37) v2(48.75,115.15) v2(49.12,116.48) v2(49.22,127.96) v2(49.22,89.13) v2(49.27,163.85) v2(49.32,152.17) v2(49.32,137.56) v2(49.32,120.04) v2(49.27,110.11) v2(49.5,170.1) v2(49.62,202.04) v2(49.58,140.61) v2(49.6,107.08) v2(49.72,142.91) v2(49.83,132.61) v2(49.83,131.09) v2(49.78,130.02) v2(49.86,154.23) v2(49.91,138.77) v2(49.88,124.84) v2(50.24,159.84) v2(50.24,118.98) v2(50.34,161.41) v2(50.34,144.8) v2(50.4,165.04) v2(50.36,146.07) v2(50.42,121.73) v2(50.41,116.73) v2(50.48,157.78) v2(50.52,150.8) v2(50.49,89.13) v2(50.6,167.27) v2(50.65,156.18) v2(50.73,113.07) v2(50.73,110.88) v2(50.73,107.93) v2(50.82,170.35) v2(50.89,202.04) v2(50.95,152.15) v2(50.93,136.29) v2(50.97,140.46) v2(51,132.06) v2(51.05,142.9) v2(51.23,154.17) v2(51.2,129.92) v2(51.23,126.13) v2(51.27,169.25) v2(51.25,164.09) v2(51.34,115.1) v2(51.63,159.84) v2(51.61,152.13) v2(51.68,145.36) v2(51.84,150.86) v2(51.76,89.13) v2(51.92,167.27) v2(51.93,165.06) v2(51.91,164.12) v2(51.86,128.04) v2(51.96,161.03) v2(52.02,156.38) v2(52.05,149.56) v2(52.05,148.56) v2(52.03,123.77) v2(52.04,121.55) v2(52.02,118.88) v2(51.97,116.69) v2(52.05,113.06) v2(52.05,110.87) v2(52.05,107.88) v2(52.16,202.04) v2(52.51,134.65) v2(52.5,93.62) v2(53.03,89.13) v2(53.19,134.69) v2(53.18,93.62) v2(53.84,183.13) v2(53.82,108.38) v2(53.87,134.69) v2(54.32,202.98) v2(54.3,89.13) v2(54.36,206.79) v2(54.36,205.52) v2(54.36,204.25) v2(54.73,106.07) v2(54.94,115.22) v2(55,126.47) v2(55,117.69) v2(54.99,112.15) v2(55.08,170.49) v2(55.13,167.22) v2(55.13,165.18) v2(55.13,161.88) v2(55.13,159.85) v2(55.13,156.93) v2(55.13,154.76) v2(55.08,150.67) v2(55.13,149.69) v2(55.1,123.44) v2(55.12,113.99) v2(55.08,108.69) v2(55.07,98.06) v2(55.39,206.85) v2(55.64,147.56) v2(55.6,103.81) v2(55.57,89.13) v2(55.67,171.51) v2(55.74,170.49) v2(55.74,150.66) v2(55.66,126.46) v2(55.66,117.67) v2(55.65,112.15) v2(55.74,108.68) v2(55.73,98.06) v2(55.84,167.21) v2(55.79,165.18) v2(55.79,161.88) v2(55.79,156.95) v2(55.79,154.76) v2(55.79,149.69) v2(55.76,123.46) v2(55.75,118.51) v2(56.26,103.81) v2(56.66,206.85) v2(56.84,89.13) v2(56.92,103.81) v2(57.93,206.85) v2(57.96,171.88) v2(58.11,89.13) v2(58.41,164.09) v2(58.41,162.11) v2(58.43,159.85) v2(58.43,158.5) v2(58.43,156.91) v2(58.43,152.43) v2(58.43,151.13) v2(58.42,129.74) v2(58.43,126.82) v2(58.41,121.81) v2(58.41,117.96) v2(58.54,125.02) v2(58.56,120.2) v2(58.62,114.12) v2(58.6,108.64) v2(58.72,123.47) v2(59.1,169.69) v2(59.08,168.37) v2(59.09,158.49) v2(59.12,115.37) v2(59.2,206.85) v2(59.21,147.14) v2(59.15,111.95) v2(59.25,171.95) v2(59.29,165.76) v2(59.31,154.44) v2(59.27,105.97) v2(59.38,89.13) v2(59.73,162.08) v2(59.75,159.85) v2(59.75,156.93) v2(59.75,151.13) v2(59.73,121.82) v2(59.73,117.96) v2(59.76,126.84) v2(59.86,124.99) v2(59.94,114.13) v2(60.12,143.93) v2(60.37,158.14) v2(60.39,129.7) v2(60.37,108.57) v2(60.47,206.85) v2(60.53,147.12) v2(60.61,165.76) v2(60.62,136.65) v2(60.75,178.37) v2(60.65,89.13) v2(61.02,152.43) v2(61.04,133.82) v2(61.17,120.2) v2(61.26,114.13) v2(61.53,143.93) v2(61.64,206.9) v2(61.72,111.89) v2(61.71,105.88) v2(61.94,165.76) v2(61.85,147.13) v2(61.86,110.34) v2(61.92,89.13) v2(62.02,168.42) v2(62.03,154.38) v2(62.07,108.18) v2(62.16,162.67) v2(62.18,115.36) v2(62.3,160.1) v2(62.42,156.55) v2(62.38,129.67) v2(62.45,125.04) v2(62.43,117.96) v2(62.52,139.11) v2(62.65,132.5) v2(62.62,123.48) v2(62.66,158.14) v2(62.69,151.17) v2(62.7,126.91) v2(62.69,121.21) v2(62.91,206.9) v2(62.94,133.88) v2(62.99,187.68) v2(62.97,131.11) v2(63.04,111.88) v2(63.03,105.89) v2(63.19,89.13) v2(63.27,172.21) v2(63.26,110.34) v2(63.42,147.47) v2(63.49,162.66) v2(63.5,115.37) v2(63.62,160.07) v2(63.74,129.66) v2(63.75,117.94) v2(63.93,136.17) v2(63.94,123.48) v2(64.02,156.55) v2(63.96,154.28) v2(64.01,151.19) v2(63.98,145.38) v2(64.02,126.89) v2(63.98,114.08) v2(64.18,206.9) v2(64.46,89.13) v2(64.67,189.95) v2(64.71,172.31) v2(65.45,206.9) v2(65.73,176.3) v2(65.73,89.13) v2(66.72,206.9) v2(67,89.13) v2(67.61,149.15) v2(67.99,206.9) v2(68.27,89.13) v2(69.26,206.9) v2(69.54,89.13) v2(70.53,206.9) v2(70.81,89.13) v2(71.8,174.96) v2(71.95,206.93) v2(72.08,89.13) v2(72.46,174.96) v2(73.22,206.93) v2(73.35,89.13) v2(73.96,184.3) v2(74.49,206.93) v2(74.62,89.13) v2(75.76,206.93) v2(75.81,189.63) v2(75.89,89.13) v2(76.32,188.95) v2(76.47,189.63) v2(77.03,206.93) v2(77.16,89.13) v2(78.3,206.93) v2(78.43,89.13) v2(79.57,206.93) v2(79.62,92.26) v2(79.56,90.99) v2(79.56,89.72) v2(79.93,114.09) v2(79.93,111.2) v2(80.64,93.05) v2(80.87,196.97) v2(80.86,196.31) v2(81.91,93.06) v2(82.75,114.09) v2(82.75,111.2) v2(83.18,93.06) v2(83.41,102.89) v2(84.22,176.43) v2(84.45,93.06) v2(84.46,198.24) v2(84.46,196.65) v2(84.74,190.48) v2(84.91,176.43) v2(85.41,198.24) v2(85.41,196.65) v2(85.72,93.06) v2(86.79,96.92) v2(86.94,191.49) v2(86.99,93.06) v2(87.35,183.74) v2(87.37,184.43) v2(87.83,191.84) v2(88.03,184.43) v2(88.01,183.74) v2(88.16,194.15) v2(88.16,193.49) v2(88.31,96.92) v2(88.26,93.06) v2(88.36,195.37) v2(88.69,184.43) v2(88.69,183.74) v2(88.87,194.15) v2(88.87,193.49) v2(88.95,196.65) v2(89.35,183.71) v2(89.53,93.06) v2(89.83,176.68) v2(89.83,175.54) v2(90.39,176.09) v2(90.8,93.06) v2(90.85,175.54) v2(90.98,176.68) v2(92.07,93.06) v2(93.01,98.45) v2(93.34,93.06) v2(94.05,205.79) v2(94.61,185.87) v2(94.61,93.06) v2(95.63,206.65) v2(95.88,93.06) v2(96.69,162.33) v2(97.15,93.06) v2(98.42,93.06) v2(98.64,182.02) v2(99.59,181.94) v2(99.66,207.87) v2(99.69,93.06) v2(100.17,206.98) v2(100.59,208.81) v2(101,195.89) v2(100.96,93.06) v2(101.51,209.71) v2(102.04,196.91) v2(101.99,195.99) v2(101.99,194.77) v2(102.23,93.06) v2(102.39,210.61) v2(102.48,195.3) v2(103.03,196.02) v2(103.22,159.08) v2(103.28,211.48) v2(103.5,93.06) v2(104.18,212.41) v2(104.82,114.45) v2(104.77,93.06) v2(105.08,213.28) v2(105.98,214.2) v2(106.04,93.06) v2(106.57,170.91) v2(106.88,215.1) v2(107.31,93.06) v2(107.69,188.03) v2(107.69,187.37) v2(107.77,216) v2(108.58,93.06) v2(108.67,216.9) v2(108.81,194.97) v2(108.81,194.08) v2(109.47,194.97) v2(109.47,194.08) v2(109.57,217.79) v2(109.85,93.06) v2(110.13,194.97) v2(110.13,194.08) v2(110.47,218.69) v2(110.79,194.97) v2(110.79,194.08) v2(110.92,193.32) v2(111.12,93.06) v2(111.45,194.97) v2(111.45,194.08) v2(111.74,218.74) v2(111.93,101.09) v2(111.94,100.42) v2(112.39,93.06) v2(112.6,101.08) v2(112.6,100.42) v2(113.01,218.74) v2(113.26,101.08) v2(113.26,100.42) v2(113.63,194.23) v2(113.66,93.06) v2(113.92,101.08) v2(113.92,100.42) v2(114.28,218.74) v2(114.5,217.67) v2(114.93,93.06) v2(114.96,136.5) v2(115.55,218.74) v2(115.67,207.02) v2(116.2,93.06) v2(116.35,207.03) v2(116.5,174.65) v2(116.82,218.74) v2(117.47,93.06) v2(118.09,218.74) v2(118.74,93.06) v2(120.01,93.06) v2(121.28,93.06) v2(122.3,210.56) v2(122.46,93.53) v2(123.43,94.34) v2(123.77,208) v2(124.42,210.51) v2(124.7,94.36) v2(125.01,104.8) v2(125.85,104.8) v2(125.97,94.36) v2(126.66,104.8) v2(127.24,94.36) v2(128.51,94.36) v2(129.41,213.74) v2(129.71,214.36) v2(129.78,94.36) v2(129.99,217.2) v2(130.14,123.47) v2(130.37,212.81) v2(130.55,154.07) v2(130.66,217.2) v2(130.79,218.74) v2(130.98,151.53) v2(131.05,94.36) v2(131.32,217.2) v2(131.87,152.8) v2(131.87,151.53) v2(131.98,217.2) v2(132.06,218.74) v2(132.32,94.36) v2(132.76,151.53) v2(133.2,211.63) v2(133.33,218.74) v2(133.3,208.25) v2(133.35,209.4) v2(133.59,94.36) v2(133.86,211.63) v2(134.01,209.4) v2(133.96,208.25) v2(134.6,218.74) v2(134.87,134.36) v2(134.86,94.36) v2(135.55,152.9) v2(135.55,152.24) v2(135.73,140.51) v2(135.73,139.82) v2(135.87,218.74) v2(135.89,135.05) v2(135.89,134.39) v2(135.89,133.73) v2(136.13,94.22) v2(136.27,174.69) v2(136.81,93.15) v2(136.93,174.69) v2(136.9,142.72) v2(136.93,141.88) v2(137.14,218.74) v2(137.33,152.9) v2(137.33,152.24) v2(137.39,209.41) v2(137.4,208.24) v2(137.64,174.7) v2(137.59,146.45) v2(137.59,145.77) v2(137.59,145.11) v2(137.59,144.45) v2(137.59,143.79) v2(137.59,142.72) v2(137.59,141.88) v2(137.66,140.48) v2(137.66,139.82) v2(137.66,134.97) v2(137.66,134.31) v2(137.66,133.63) v2(137.89,111.17) v2(138.05,209.41) v2(137.97,130.71) v2(138.06,208.24) v2(138.08,93.06) v2(138.22,141.3) v2(138.41,218.74) v2(138.55,111.17) v2(138.55,110.51) v2(138.86,170.2) v2(139.31,169.67) v2(139.35,93.06) v2(139.62,170.28) v2(139.62,143.53) v2(139.62,142.85) v2(139.62,141.91) v2(139.62,141.25) v2(139.68,218.74) v2(139.75,169.16) v2(140.08,169.74) v2(140.51,169.19) v2(140.46,145.54) v2(140.62,93.06) v2(140.95,218.74) v2(141.06,208.87) v2(141.72,208.87) v2(141.89,93.06) v2(142.22,218.74) v2(142.74,146.05) v2(143.16,93.06) v2(143.49,218.74) v2(143.51,217.21) v2(144.43,93.06) v2(144.76,218.74) v2(144.83,215.67) v2(144.83,211.6) v2(145.59,215.67) v2(145.56,210.72) v2(145.7,93.06) v2(146.03,218.74) v2(146.81,204.01) v2(146.94,217.19) v2(146.97,93.06) v2(147.11,183.99) v2(147.3,218.74) v2(147.54,205.57) v2(147.46,204.27) v2(147.62,217.19) v2(147.72,134.03) v2(147.72,133.32) v2(147.72,132.61) v2(147.77,208.25) v2(147.77,184.02) v2(148.24,93.06) v2(148.43,134.03) v2(148.43,133.32) v2(148.43,132.61) v2(148.45,184.02) v2(148.57,218.74) v2(148.83,183.38) v2(149.14,134.03) v2(149.14,133.32) v2(149.14,132.61) v2(149.16,184.02) v2(149.51,93.06) v2(149.58,131.87) v2(149.84,218.74) v2(149.85,184.02) v2(149.86,134.03) v2(149.86,133.32) v2(149.86,132.61) v2(150.44,150.21) v2(150.44,149.5) v2(150.44,148.79) v2(150.52,147.34) v2(150.52,146.63) v2(150.52,145.92) v2(150.52,145.21) v2(150.52,144.5) v2(150.52,143.79) v2(150.62,157.96) v2(150.62,157.25) v2(150.62,154.4) v2(150.57,134.03) v2(150.57,133.32) v2(150.57,132.61) v2(150.78,93.06) v2(150.9,135.84) v2(151.11,218.74) v2(151.1,150.36) v2(151.1,149.65) v2(151.53,166.27) v2(151.61,117.24) v2(152.05,93.06) v2(152.14,151.69) v2(152.24,167.05) v2(152.24,166.34) v2(152.38,218.74) v2(152.95,167.05) v2(152.95,166.34) v2(153.31,165.76) v2(153.32,93.06) v2(153.65,218.74) v2(153.67,167.05) v2(153.67,166.34) v2(154.02,165.76) v2(154.02,116.2) v2(154.38,167.05) v2(154.38,166.34) v2(154.59,93.06) v2(154.92,218.74) v2(155.09,167.05) v2(155.09,166.34) v2(155.86,93.06) v2(156.19,218.74) v2(157.13,93.06) v2(157.46,218.74) v2(158.44,218.72) v2(158.4,93.06) v2(158.67,145.95) v2(159.67,93.06) v2(159.81,116.23) v2(159.94,147.34) v2(159.94,144.55) v2(159.96,145.87) v2(160.19,131.59) v2(160.19,130.83) v2(160.19,130.07) v2(160.22,116.91) v2(160.85,187.95) v2(160.8,186.33) v2(160.78,116.35) v2(160.94,93.06) v2(161.21,145.95) v2(161.53,187.94) v2(161.46,130.07) v2(161.69,186.05) v2(162.22,187.93) v2(162.21,93.06) v2(162.25,151.91) v2(162.45,186.05) v2(162.48,133.88) v2(163.47,154.33) v2(163.49,134.77) v2(163.49,133.88) v2(163.48,93.06) v2(163.88,129.94) v2(164.18,124.99) v2(164.75,93.06) v2(164.79,125.29) v2(165.35,124.91) v2(166.02,93.06) v2(167.3,145.56) v2(167.29,93.06) v2(167.53,211.19) v2(167.53,209.92) v2(167.53,208.65) v2(167.53,207.38) v2(167.53,206.11) v2(167.53,204.84) v2(167.53,203.57) v2(167.53,202.3) v2(167.53,201.03) v2(167.53,199.76) v2(167.53,198.49) v2(167.53,197.22) v2(167.53,195.95) v2(167.86,161.36) v2(168.4,194.54) v2(168.56,93.06) v2(169.74,194.34) v2(169.74,193.07) v2(169.74,191.8) v2(169.74,190.53) v2(169.74,189.26) v2(169.74,187.99) v2(169.74,186.72) v2(169.74,185.45) v2(169.74,184.18) v2(169.74,182.91) v2(169.74,181.64) v2(169.74,180.37) v2(169.74,179.1) v2(169.74,177.83) v2(169.74,176.56) v2(169.74,175.29) v2(169.74,174.02) v2(169.74,172.75) v2(169.74,171.48) v2(169.74,170.21) v2(169.74,168.94) v2(169.75,167.67) v2(169.77,166.4) v2(169.83,93.06) v2(169.87,165.14) v2(170.01,163.87) v2(170.23,162.62) v2(170.47,161.37) v2(170.75,160.13) v2(171.08,158.91) v2(171.1,93.06) v2(171.46,157.69) v2(171.88,156.5) v2(172.1,142.11) v2(172.08,132.18) v2(172.18,140.85) v2(172.34,155.31) v2(172.29,143.37) v2(172.37,93.06) v2(172.54,139.63) v2(172.46,131.59) v2(172.66,97.58) v2(172.85,154.15) v2(172.76,144.55) v2(172.77,116.86) v2(173.16,138.52) v2(173.25,125.17) v2(173.32,97.58) v2(173.4,153) v2(173.47,145.63) v2(173.64,93.06) v2(173.99,151.88) v2(174.01,137.58) v2(174.35,146.52) v2(174.62,150.78) v2(174.91,93.06) v2(175.05,136.84) v2(175.05,116.89) v2(175.24,147.42) v2(175.3,149.7) v2(175.26,97.58) v2(175.83,148.55) v2(175.76,116.89) v2(175.92,97.58) v2(176.22,136.34) v2(176.18,93.06) v2(176.93,116.89) v2(177.45,93.06) v2(177.47,136.12) v2(177.67,126.31) v2(178.35,97.94) v2(178.46,126.72) v2(178.73,136.17) v2(178.72,93.06) v2(179.12,97.94) v2(179.9,97.74) v2(179.96,136.51) v2(179.99,93.06) v2(180.6,97.9) v2(181.08,137.1) v2(181.27,97.89) v2(181.26,93.06) v2(182.2,137.71) v2(182.53,93.06) v2(183.37,137.28) v2(183.8,93.06) v2(184.49,136.64) v2(184.63,97.96) v2(185.07,93.06) v2(185.29,97.96) v2(185.59,136.01) v2(185.59,123.65) v2(185.95,97.96) v2(186.25,123.65) v2(186.34,93.06) v2(186.69,135.37) v2(187.45,97.96) v2(187.61,93.06) v2(187.79,134.74) v2(187.88,105.97) v2(188.01,109.17) v2(188.07,102.38) v2(188.11,97.96) v2(188.77,97.96) v2(188.89,134.1) v2(188.87,106.58) v2(188.88,93.06) v2(189.36,109.16) v2(190.02,133.52) v2(189.96,126.26) v2(190.07,102.39) v2(190.15,93.06) v2(190.62,126.26) v2(190.7,109.22) v2(190.75,97.96) v2(191.25,133.21) v2(191.28,126.26) v2(191.42,93.06) v2(192.07,97.94) v2(192.52,133.25) v2(192.69,93.06) v2(192.78,97.94) v2(193.54,98.19) v2(193.74,133.61) v2(193.99,102.63) v2(193.96,93.06) v2(194.65,102.63) v2(194.98,133.86) v2(195.23,93.06) v2(195.31,102.63) v2(196.13,105.18) v2(196.13,104.52) v2(196.2,133.5) v2(196.5,93.06) v2(197.43,133.18) v2(197.77,93.06) v2(198.67,132.9) v2(199.04,93.06) v2(199.92,132.66) v2(200.18,130.87) v2(200.21,92.56) v2(200.3,127.09) v2(200.46,91.32) v2(200.84,130.87) v2(201.17,132.47) v2(201.5,130.87) v2(202.43,132.32) v2(203.7,132.22) v2(204.97,132.16) v2(205.53,130.58) v2(206.24,132.15) v2(206.42,130.59) v2(207.51,132.18) v2(208.55,97.94) v2(208.55,97.18) v2(208.77,132.25) v2(210.04,132.37) v2(211.3,132.54) v2(218.68,135.62) v2(219.08,119.51) v2(219.66,136.42) v2(219.83,108.81) v2(221.22,111.55) v2(221.64,138.02) v2(222.62,138.82) v2(223.82,122.7) v2(225.5,110.69) v2(226.64,101.39) v2(226.99,122.45) v2(227.41,139.79) v2(227.38,121.21) v2(227.5,110.39) v2(227.89,138.61) v2(227.89,137.34) v2(227.89,136.07) v2(227.89,134.8) v2(227.89,133.53) v2(227.89,132.26) v2(227.89,130.99) v2(228.34,129.8) v2(228.54,99.17) v2(228.75,102.08) v2(229.2,104.21) v2(229.15,101.37) v2(229.26,99.16) v2(229.41,102.08) v2(229.57,129.49) v2(229.92,101.37) v2(230.22,108.28) v2(230.22,107.51) v2(230.22,106.75) v2(230.22,106.09) v2(230.36,98.3) v2(230.84,129.49) v2(231.12,98.82) v2(231.59,105.58) v2(232.11,129.49) v2(232.07,119.78) v2(232.74,119.76) v2(233.12,105.58) v2(233.38,129.49) v2(234.65,129.49) v2(235.92,129.49) v2(237.19,129.35) v2(237.19,128.08) v2(237.19,126.81) v2(237.24,125.35) v2(237.24,124.08) v2(237.24,122.81) v2(237.24,121.54) v2(237.24,120.27) v2(237.24,119) v2(237.24,117.73) v2(237.24,116.46) v2(237.24,115.19) v2(237.24,113.92) v2(237.24,112.65) v2(237.24,111.38) v2(237.24,110.11) v2(237.24,108.84) v2(237.24,107.57) v2(237.24,106.3) v2(237.24,105.03) v2(237.24,103.76) v2(237.24,102.49) v2(237.24,101.22) v2(237.24,99.95) v2(237.24,98.68) v3(50.52,184.98) v3(50.52,184.22) v3(51.28,184.98) v3(51.28,184.22) v3(52.04,184.98) v3(52.04,184.22) v3(52.83,185.01) v3(52.83,184.25) v3(53.59,185.01) v3(53.59,184.25) v3(54.35,185.01) v3(54.35,184.25) v3(87.04,206.55) v3(88.06,206.55) v3(88.95,206.55) v3(89.96,206.55) v3(94.86,206.65) v3(96.49,206.65) v3(97.43,206.65) v3(98.34,206.65) v3(98.39,200.01) v3(99.11,206.27) v3(99.16,200.01) v3(99.92,206.17) v3(99.92,205.41) v3(99.92,200) v3(100.68,206.17) v3(100.68,205.41) v3(100.68,200) v3(101.04,206.93) v3(101.44,206.17) v3(101.44,205.41) v3(101.6,207.49) v3(102,206.83) v3(102.2,208.05) v3(102.61,207.39) v3(102.97,208.45) v3(103.75,208.51) v3(106.5,194.84) v3(106.5,194.08) v3(106.5,193.32) v3(107.26,194.84) v3(107.26,194.08) v3(107.26,193.32) v3(108.02,194.84) v3(108.02,194.08) v3(108.02,193.32) v3(113.44,193.53) v3(114.47,203.68) v3(114.47,202.92) v3(152.18,118.15) v3(152.7,160.17) v3(152.7,159.41) v3(152.7,158.65) v3(152.7,157.12) v3(152.7,156.36) v3(152.7,155.6) v3(152.7,154.33) v3(152.7,153.57) v3(152.7,152.8) v3(152.73,117.54) v3(152.73,116.78) v3(152.73,116.02) v3(153.5,117.54) v3(153.5,116.78) v3(156.51,117.57) v3(161.84,155.6) v3(161.88,154.82) v3(161.88,154.06) v3(161.88,153.3) v3(162.64,152.54) v3(163.4,152.54) v3(168.37,164.56) v3(168.52,163.31) v3(168.52,162.55) v3(168.52,161.79) v3(168.52,161.02) v3(173.05,124.41) v3(173.81,124.41) v3(174.57,124.41) v3(175.33,124.41) v3(176.09,124.41) v3(176.86,124.41) v3(178.5,130.62) v3(178.5,129.85) v3(178.5,129.09) v3(178.5,128.33) v3(178.91,127.68) v3(189.69,131.95) v3(190.42,131.72) v3(193.19,131.77)
