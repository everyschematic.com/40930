# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SN_VCORE1:
  vias: v2(142.77,145.61)
SN_VCORE2:
  vias: v2(150.72,167.84)
SNDW_RCOMP: length 5.6
  TOP w0.254: v1(109.02,127.54) 110.23,128.75 110.23,130.55 109.24,131.55 R68458.1
  BOTTOM w0.254: v1(109.02,127.54) 109.28,127.54 U6539.DF33
SP2: length 1.4
  BOTTOM w0.114: U40.9 32.68,61.49 TP100.1
SP5: length 1.9
  BOTTOM w0.114: TP101.1 32.94,59.46 32.41,59.99 U40.12
SP7: length 2.8
  BOTTOM w0.114: TP102.1 30.6,57.38 30.91,57.68 30.91,58.06 30.53,58.44 30.39,58.44 30.26,58.57 U40.14
SP9: length 2.8
  BOTTOM w0.114: U40.16 29.26,57.55 28.87,57.17 TP103.1
SP11: length 2.2
  BOTTOM w0.114: U40.19 27.41,57.88 TP97.1
SP14: length 4.8
  BOTTOM w0.114: U40.22 26.85,61.49 26.59,61.74 26.59,61.97 26.36,62.2 25.85,62.2 25.62,61.97 25.17,61.97 24.81,61.62 24.81,60.47 TP98.1
SP_PLLVDD: length 17.2
  TOP w0.254: C459.2 C460.2 125.53,191.79 125.49,191.82 R329.1 124.35,191.82 124.34,191.83 124,191.83 v1(123.94,191.89) 123.68,192.15 123.39,192.15 121.08,194.46 119.12,194.46 v2(116.33,197.25) 115.56,198.03 C461.1 L8.2 113.3,198.03 C462.1
  BOTTOM w0.254: v1(123.94,191.89) 124.32,191.51 U8.M6
SPI0_CLK_R: length 4.2
  BOTTOM w0.114: C96795.2 121.11,106.22 121.21,106.33 U6548.6 ; C96795.2 120.31,105.69 120.29,105.66 R68572.1 ; C96795.2 119.04,106.22 TP13312.1
SPI0_CS0#_R: length 3.2
  BOTTOM w0.114: R68582.2 132,108.91 TP13311.1 131.95,108.87 U6548.1
SPI0_SI_R: length 10.9
  BOTTOM w0.114: R68574.1 120.57,101.34 120.95,100.96 TP13313.1 120.95,99.46 121.51,98.9 122.42,98.9 122.8,99.29 122.8,102.56 122.05,103.32 U6546.5
SPI0_SO_R: length 5.6
  BOTTOM w0.114: R68576.1 133.04,106.99 133.4,107.34 TP13314.1 132.38,107.59 131.77,106.98 131.08,106.98 130.47,107.6 U6548.2
SPI_TPM_CS#: length 71.1
  TOP w0.114: v1(87.04,119.25) 87.04,118.83 86.93,118.72 85.89,118.72 85.77,118.6 85.77,118.37 85.89,118.26 86.93,118.26 87.04,118.14 87.04,117.92 86.93,117.8 85.89,117.8 85.77,117.69 85.77,117.46 85.89,117.34 88.08,117.34 88.36,117.07 88.36,116.91 87.76,116.31 87.76,116.14 87.92,115.98 88.08,115.98 88.68,116.58 88.84,116.58 89.01,116.42 89.01,116.26 88.4,115.66 88.4,115.5 88.57,115.34 88.73,115.34 89.33,115.94 89.49,115.94 90.16,115.26 90.16,115.1 89.94,114.88 89.94,114.72 90.1,114.56 90.27,114.56 90.49,114.78 90.65,114.78 90.85,114.58 90.85,111.66 91.36,111.15 91.36,110 92.25,109.11 92.25,107.97 92.63,107.59 92.93,107.59 93.61,106.92 93.61,106.33 93.49,106.22 93,106.22 92.88,106.1 92.88,105.87 93,105.76 93.49,105.76 93.61,105.65 93.61,104.04 93.48,103.91 v2(92.88,103.91) 92.33,103.36 86.79,103.36 86.53,103.1 86.53,102.87 85.39,101.73 84.23,101.73 83.48,100.99 83.48,100.23 83.08,99.82 R68921.2
  IN1 w0.089: v1(106.29,127.5) 106.07,127.5 105.84,127.28 105.84,123.54 105.61,123.31 103.53,123.31 103.04,122.83 102.41,122.83 102.23,122.65 101.72,122.65 101.29,123.09 101.29,124.1 101.16,124.23 100.86,124.23 100.77,124.14 100.77,123.17 100.68,123.09 100.21,123.09 100.12,123.17 100.12,123.75 99.99,123.87 99.26,123.87 98.72,123.34 98.24,123.34 97.96,123.06 93.9,123.06 91.77,120.93 89.76,120.93 88.23,119.4 87.19,119.4 v1(87.04,119.25)
  BOTTOM w0.102: v1(106.29,127.5) 106.46,127.34 U6539.DF39
SPI_TPM_CS#_TPM: length 3.7
  TOP w0.114: U33.20 v2(84.02,98.32) 83.36,98.32 83.01,98.67 R586.1 R68921.1
SPL_WLAN#: length 139.2
  TOP w0.102: 101.5,122.21 103.52,122.21 104.52,123.21 v1(104.52,123.75)
  TOP w0.114: 101.5,122.21 101.24,122.48 100.27,122.48 100.02,122.22 94.38,122.22 94.03,122.58 93.26,122.58 93.13,122.45 R68934.2
  IN1 w0.089: v1(190.67,110.89) 190.85,110.72 198.12,110.72 198.67,111.27 198.67,111.83 v2(199.31,112.47)
  IN4 w0.089: v1(104.52,123.75) 104.69,123.57 104.69,122.96 105.96,121.69 105.96,121.56 107.23,120.29 107.23,119.83 109.47,117.6 109.47,116.89 110.18,116.18 110.18,115.06 110.79,114.45 110.79,113.81 110.41,113.43 110.41,111.91 111.3,111.02 112.06,111.02 114.47,108.61 117.39,108.61 118.41,107.59 125.65,107.59 127.4,105.84 128.14,105.84 131.37,102.61 139.59,102.61 139.8,102.82 147.06,102.82 147.77,102.1 159.94,102.1 160.04,102 160.95,102 161.36,101.6 166.52,101.6 167.74,102.82 171.8,102.82 172.38,103.4 173.02,103.4 174.54,101.88 179.66,101.88 182.67,104.89 182.67,107.59 184.2,109.12 184.2,110.13 185.42,111.35 188.46,111.35 188.74,111.63 189.94,111.63 v1(190.67,110.89)
  BOTTOM w0.102: U6539.DT44 104.01,122.94 104.01,123.54 104.19,123.72 104.41,123.72 104.44,123.75 v1(104.52,123.75)
  BOTTOM w0.114: v2(199.31,112.47) 200.96,114.12 200.96,118.51 201.06,118.61 R68942.1
SRTC_RST#: length 50
  TOP w0.089: 106.34,122.32 106.66,122.64 106.66,124.55 107.18,125.06 v1(107.2,125.06)
  TOP w0.114: 106.34,122.32 105.96,122.32 104.93,121.29 104.93,118.88 104.16,118.11 100.91,118.11 100.01,119.01 95.84,119.01 92.93,116.1 92.93,112.72 92.4,112.19 92.38,112.19 v1(92.36,112.16) ; Q6520.3 78.79,106.19 78.53,105.94 77.9,105.94 77.77,105.81 77.77,105.43 77.39,105.05 R971.2 ; Q6520.3 78.99,106.76 79.7,106.04 C1211.1 ; Q6520.3 78.79,107.46 78.38,107.87 v2(78.38,108.35) 78.38,108.84 v1(78.23,108.99)
  IN3 w0.102: v1(92.36,112.16) 90.78,113.74 85.95,113.74 82.85,110.64 81.96,110.64 80.82,109.5 78.74,109.5 v1(78.23,108.99)
  BOTTOM w0.102: U6539.DK37 107.33,125.06 v1(107.2,125.06)
SSD_DET_A12: length 1.2
  TOP w0.114: v1(105.39,127.55) 105.36,127.58 TP13423.1
  BOTTOM w0.102: U6539.DF41 105.62,127.55 v1(105.39,127.55)
SSD_DET_E0: length 5.9
  BOTTOM w0.102: TP13422.1 126.23,122.07 125.28,123.02 125.08,123.02 124.48,123.62 122.76,123.62 U6539.DP4
SSD_MS_PWR_EN_GPPA11: length 124.2
  TOP w0.114: v1(74.59,98.52) 74.65,98.47 74.65,96.08 v2(76.12,94.61) 76.12,93.75 75.1,92.73 75.1,91.46 75.36,91.21 v2(75.36,91.13) ; v2(23.92,79.14) 24.38,79.6 25.01,79.6 25.19,79.78 25.95,79.78 26.08,79.65 U6565.2
  IN4 w0.089: v1(97.84,123.47) 97.84,122.58 97.96,122.45 97.96,120.8 92.88,115.72 92.88,112.14 92.37,111.63 92.37,109.49 90.48,107.59 88.67,107.59 85.94,104.86 82.91,104.86 82.34,104.29 78.79,104.29 76.12,101.62 76.12,99.46 75.18,98.52 v1(74.59,98.52)
  BOTTOM w0.102: U6539.DL52 100.63,124.84 100.35,125.12 100.04,125.12 99.66,124.74 98.88,124.74 97.84,123.69 v1(97.84,123.47)
  BOTTOM w0.114: v2(23.92,79.14) 24.43,78.64 26.97,78.64 27.1,78.51 27.99,78.51 28.49,78 32.68,78 33.57,77.11 33.57,76.48 33.83,76.22 35.61,76.22 35.86,76.48 35.86,77.73 36.26,78.13 36.26,81.16 36.01,81.4 35.25,81.4 34.63,82.02 34.63,85.66 35.1,86.13 35.1,87.88 35.99,88.77 35.99,89.53 37.59,91.13 v2(75.36,91.13)
SSD_MS_PWR_EN_GPPD16: length 121.8
  TOP w0.114: R69100.1 27.96,82.95 29.15,84.15 29.15,84.6 30.65,86.1 32.35,86.1 v1(35.83,82.62)
  BOTTOM w0.102: 112.62,114.01 112.62,119.35 112.57,119.4 112.57,119.91 112.95,120.29 112.95,121.54 U6539.DV25
  BOTTOM w0.114: v1(35.83,82.62) 35.83,84.68 v2(36.04,84.88) 36.37,85.21 36.37,85.49 36.37,85.49 36.37,87.5 37.16,88.29 37.16,88.85 38.12,89.81 76.12,89.81 77.26,90.95 77.26,91.59 79.29,93.62 93.26,93.62 93.64,94 96.95,94 98.24,95.3 98.24,100.63 98.57,100.96 98.57,104.64 99.49,105.56 99.99,105.56 100.71,106.27 104.01,106.27 104.97,107.24 107.64,107.24 108.5,108.1 110.66,108.1 111.07,108.51 111.07,109.9 110.97,110 110.97,110.94 111.55,111.53 112.95,111.53 113.3,111.88 113.3,112.24 112.62,112.93 112.62,114.01
SSD_PLTRST#: length 6.4
  TOP w0.114: v2(22.88,74.95) 22.91,74.98 R69097.2 23.27,75.49 23.41,75.64 v2(23.97,75.64) 24.43,76.1 25.19,76.1 25.43,76.33 U6565.4
  BOTTOM w0.114: v2(22.88,74.95) 22.88,74.42 22.1,73.64 CN16.50
STRAP0: length 7.1
  BOTTOM w0.102: 116.99,185.57 117.74,185.57 118.28,185.02 119.88,185.02 120.05,184.85 U8.D1
  BOTTOM w0.114: R344.1 114.44,185.6 114.65,185.39 115.29,185.39 v2(115.62,185.07) 115.74,185.19 116.6,185.19 116.73,185.32 R353.2 116.99,185.57
STRAP1: length 7.6
  BOTTOM w0.114: R345.1 115.03,184.93 115.54,184.43 R354.2 116.28,184.71 116.44,184.87 117.74,184.87 117.82,184.79 119.71,184.79 120.03,184.48 120.49,184.48 120.86,184.85 U8.D2
STRAP2: length 10.6
  BOTTOM w0.102: 116.99,182.65 117.87,182.65 118.97,183.74 120.08,183.74 120.18,183.64 120.54,183.64 120.72,183.82 120.72,184.2 121,184.48 121.28,184.48 121.53,184.73 121.53,185.01 121.76,185.24 122.26,185.24 U8.E4
  BOTTOM w0.114: R346.1 114.6,183.16 114.93,182.83 115.5,182.83 115.55,182.78 v4(115.57,182.78) 115.64,182.78 115.89,183.03 116.6,183.03 116.73,182.9 R355.2 116.99,182.65
STRAP3: length 8.9
  BOTTOM w0.114: U8.E3 121.71,185.7 121.28,185.26 118.84,185.26 117.52,186.59 R356.2 116.73,186.3 116.6,186.18 115.16,186.18 v2(115.11,186.23) 115.11,186.46 114.78,186.79 R347.1
STRAP4: length 10.3
  BOTTOM w0.102: 117.65,181.94 117.69,181.97 119.79,181.97 120.46,182.65 120.57,182.65 120.79,182.88 121.3,182.88 121.53,183.1 121.53,184.25 121.92,184.64 U8.D3
  BOTTOM w0.114: 117.65,181.94 117.6,181.89 R357.2 116.73,181.63 116.6,181.51 116,181.51 115.51,181.99 114.6,181.99 114.44,182.14 R348.1
STRAP5: length 6.7
  BOTTOM w0.102: 116.99,183.54 118.08,183.54 118.51,183.97 120.24,183.97 U8.C1
  BOTTOM w0.114: R349.1 114.98,183.92 v2(115.01,183.94) 115.11,184.05 116.6,184.05 116.73,183.92 R358.2 116.99,183.54
SUSB#: length 280.5
  TOP w0.114: R69086.1 156.84,113.83 156.71,113.95 v1(156.7,113.95) ; v1(87.63,120.8) 88.06,120.37 88.06,118.89 91.74,115.21 91.74,112.04 92.18,111.59 92.95,111.59 94.74,109.8 D13107.1 95.54,109.25 96.57,108.23 96.57,106.83 97.08,106.31 D13108.1 97.71,106.31 97.84,106.44 97.84,107.08 98.12,107.37 R68474.2 99.74,107.37 100.4,106.7 100.4,106.09 100.25,105.94 100.25,103.15 99.99,102.89 v2(99.99,102.77) 99.44,102.21 99.44,100.91 100.53,99.82 100.53,97.79 v1(100.88,97.43) ; v2(172.87,147.24) 173.05,147.24 173.63,147.82 R68849.1 ; v1(177.85,116.61) 177.85,117.5 176.45,118.89 176.45,120.42 175.94,120.93 173.88,120.93 173.76,120.8 v1(173.76,120.29) ; v1(200.35,111.78) 200.45,111.68 200.45,110.89 200.91,110.44 200.91,108 200.71,107.79 200.71,107.41 201.42,106.7 202,106.7 v2(202.51,107.21) 202.51,107.18 202.74,106.96 202.74,106.73 203.12,106.35 204.24,106.35 204.39,106.5 R68951.2
  IN1 w0.089: v1(105.33,126.36) 105.23,126.36 104.95,126.64 104.95,127.15 104.57,127.53 102.48,127.53 99.82,124.86 97.71,124.86 96.77,123.92 93.34,123.92 91.31,121.89 89.28,121.89 88.18,120.8 v1(87.63,120.8) ; v1(113.96,97.46) 113.56,97.05 105.46,97.05 105.2,97.3 101.01,97.3 v1(100.88,97.43) ; v1(177.85,116.61) 177.85,116.23 176.6,114.98 176.6,114.55 176.32,114.27 175.2,114.27 175.01,114.46 175.01,114.89 174.69,115.21 171.72,115.21 171.57,115.05 170.04,115.05 169.64,114.65 164.76,114.65 164.43,114.32 162.22,114.32 161.34,115.21 158,115.21 156.75,113.95 v1(156.7,113.95)
  IN3 w0.102: v1(173.76,120.29) 173.76,120.09 174.95,118.89 176.63,118.89 177.95,117.57 189.83,117.57 190.29,117.12 190.29,115.85 190.67,115.47 191.94,115.47 192.96,114.45 199.05,114.45 200.35,113.15 v1(200.35,111.78) ; v2(202.51,107.21) 201.62,106.32 198.55,106.32 197.91,105.69 194.1,105.69 192.45,107.34 182.8,107.34 179.5,110.64 176.32,110.64 172.13,106.45 170.28,106.45 169.95,106.12 167.76,106.12 167.3,105.66 160.17,105.66 159.08,104.57 152.47,104.57 152.19,104.29 150.14,104.29 149.58,103.73 148.68,103.73 147.9,102.94 137.61,102.94 136.93,102.26 133.35,102.26 131.69,100.61 123.49,100.61 122.85,99.97 120.19,99.97 119.68,99.46 116.66,99.46 115.01,97.81 114.32,97.81 v1(113.96,97.46)
  IN4 w0.089: v2(172.87,147.24) 171.27,147.24 169.34,145.31 169.34,135.4 171.37,133.37 171.37,128.55 171.24,128.42 171.24,126.26 171.88,125.63 171.88,123.21 173.76,121.33 v1(173.76,120.29)
  BOTTOM w0.102: U6539.DJ43 105.25,126.36 v1(105.33,126.36)
  BOTTOM w0.114: v2(172.87,147.24) 170.94,147.24 170.86,147.16 170.1,147.16 169.77,147.49 168.37,147.49 168.12,147.75 167.25,147.75 166.75,147.24 PU9006.2
SUSC#: length 77
  TOP w0.089: v1(106.29,126.31) 105.84,125.85 105.84,124.99 105.71,124.86 105.71,123.41 103.85,121.55 101.03,121.55
  TOP w0.114: v1(148.84,103.3) 148.84,102.69 148.97,102.56 R69089.2 ; R68473.2 91.58,120.9 91.79,121.1 92.88,121.1 93.01,120.98 94.08,120.98 94.48,121.38 100.33,121.38 100.55,121.61 100.96,121.61 101.03,121.55
  IN4 w0.089: v1(148.84,103.3) 148.2,103.93 139.01,103.93 138.63,103.56 131.84,103.56 128.54,106.85 127.78,106.85 125.27,109.37 118.66,109.37 116.5,111.53 116.5,112.09 114.93,113.66 112.85,113.66 112.44,114.07 112.44,114.68 111.93,115.19 111.35,115.19 110.98,115.55 110.98,116.52 110.28,117.22 110.28,117.93 108.25,119.96 108.25,120.39 106.92,121.73 106.92,122.77 106.84,122.84 106.84,125.76 v1(106.29,126.31)
  BOTTOM w0.102: v1(106.29,126.31) 106.11,126.31 U6539.DJ41
SUSCLK_32K: length 260.1
  TOP w0.114: v1(106.31,120.1) 106.54,120.1 106.78,119.86 106.78,119.2 104.77,117.19 104.01,117.19 103.8,116.99 103.8,116.61 103.17,115.97 103.17,115.85 102.41,115.08 102.41,113.05 102.15,112.8 102.15,112.16 99.87,109.88 99.87,107.97 101.01,106.83 101.01,105.81 100.76,105.56 100.76,102.77 99.94,101.95 99.94,101.32 101.04,100.23 101.04,98.02 101.77,97.28 101.77,94.64 101.14,94 79.42,94 77.54,92.12 77.54,90.7 76.78,89.94 53.26,89.94 53,89.68 42.18,89.68 42.01,89.51 37.71,89.51 36.37,88.16 36.37,82.45 35.99,82.06 34.72,82.06 32.43,84.35 31.41,84.35 31.06,84.71 30.55,84.71 30.02,84.17 30.02,83.08 28.04,81.1 25.8,81.1 24.81,80.11 23.49,80.11 23.03,79.65 v2(23.03,79.14)
  IN4 w0.089: v1(196.46,110) 196.08,109.62 194.1,109.62 193.31,110.41 187.29,110.41 186.74,109.85 186.74,108.94 184.58,106.78 184.58,104.42 180.26,100.1 155.87,100.1 155.62,100.35 147.11,100.35 146.6,100.86 142.41,100.86 141.94,101.34 140.73,101.34 140.11,100.71 138.24,100.71 137.8,101.16 128.4,101.16 125.45,104.11 125.45,105.13 124.51,106.07 123.11,106.07 122.85,105.81 117.27,105.81 116.12,106.96 112.95,106.96 110.41,109.5 109.65,109.5 109.01,110.13 109.01,111.02 109.9,111.91 109.9,113.31 109.52,113.69 109.52,115.16 109.7,115.34 109.7,115.97 108.99,116.68 108.99,117.4 106.31,120.08 v1(106.31,120.1)
  BOTTOM w0.102: U6539.DW41 105.65,120.75 v1(106.31,120.1)
  BOTTOM w0.114: R69098.2 16.84,69.34 16.56,69.62 15.29,69.62 14.14,70.76 14.14,72.16 12.24,74.06 12.24,77.37 12.59,77.72 15.26,77.72 15.67,78.13 16.45,78.13 17.04,78.71 22.6,78.71 v2(23.03,79.14) ; R670.2 195.88,110.77 196.46,110.18 v1(196.46,110)
SUSCLK_32KHZ: length 2.9
  BOTTOM w0.114: R670.1 193.67,110.77 193.04,111.4 CN17.50
SUSLED#: length 118.7
  TOP w0.114: v2(154.64,100.81) 153.6,99.77 153.6,98.94 153.28,98.62 152.88,98.62 152.76,98.74 U37.28 151.01,98.74 150.11,97.84 150.11,97.78 149.98,97.66 149.5,97.66 149.37,97.53 R67486.1
  IN3 w0.102: v2(204.48,107.97) 204.48,105.65 201.82,102.99 v2(201.82,100.61) 200.93,99.72 197.53,99.72 196.72,98.9 178.17,98.9 177.3,98.03 170.57,98.03 169.63,97.1 165.88,97.1 165.61,96.82 161.6,96.82 160.84,97.58 156.1,97.58 154.86,98.83 154.86,100.59 v2(154.64,100.81)
  IN4 w0.089: v2(204.48,107.97) 204.99,108.48 206.04,108.48 206.27,108.25 206.27,107.61 206.55,107.34 210.61,107.34 212.26,108.99 214.56,108.99 215.57,107.97 219.37,107.97 223.06,111.66 228.26,111.66 228.65,112.04 228.65,112.67 227.76,113.56 227.76,116.48 226.74,117.5 226.74,118.01 226.36,118.39 226.36,119.17 v2(225.88,119.66)
  BOTTOM w0.114: v2(204.48,107.97) 204.48,110.62 202.45,112.65 CN48.21 ; CN55.11 228.32,119.96 228.24,119.88 226.11,119.88 v2(225.88,119.66) ; v2(201.82,100.61) 202.65,99.78 204.32,99.78 204.85,100.31 CN52.13
SUSON: length 229.3
  TOP w0.114: v1(168.96,135.73) 168.63,135.73 168.32,136.04 R68949.2 ; v1(155.79,113.82) 155.6,113.63 155.6,112.96 155.47,112.83 R25320.1 155.2,112.67 155.33,112.54 156.26,112.54 156.66,112.14 U37.120 ; PR5004.2 92.45,169.24 v2(92.27,169.06)
  IN1 w0.089: v1(119.18,175.28) 119.18,174.76 120.37,173.58 120.37,170.41 121.2,169.57 121.61,169.57 122.22,168.96 122.22,168.42 123.54,167.1 123.95,167.1 125.47,165.58 130.78,165.58 133.27,163.09 133.27,157.12 132.63,156.49 132.63,155.09 133.01,154.71 133.78,154.71 134.54,153.95 136.95,153.95 137.99,152.9 137.99,144.65 138.98,143.66 138.98,138.71 142.64,135.05 151.05,135.05 152.32,133.78 152.32,132.76 152.98,132.1 153.84,132.1 154.22,131.72 154.22,130.86 159.46,125.63 161.46,125.63 161.84,125.24 161.84,124.86 161.59,124.61 161.59,124.1 162.61,123.09 165.83,123.09 166.67,122.25 166.67,121.94 168.57,120.04 170.1,120.04 170.23,119.91 171.42,119.91 171.62,120.11 v1(171.62,120.27) ; v1(168.96,135.73) 168.78,135.91 167.57,135.91 v2(166.45,137.03)
  IN3 w0.102: v2(62.99,186) 64.87,186 66.85,187.98 69.13,187.98 69.64,188.49 72.31,188.49 73.05,189.23 v1(73.05,189.25) ; v1(155.79,113.82) 156.34,114.37 157.45,114.37 158.36,115.29 161.92,115.29 162.61,115.97 162.61,116.61 162.99,116.99 164.76,116.99 165.15,117.37 167.18,117.37 168.19,118.39 169.9,118.39 171.62,120.11 v1(171.62,120.27)
  IN4 w0.089: v2(166.45,137.03) 170.94,132.54 170.94,129.13 170.73,128.93 170.73,125.63 171.37,124.99 171.37,122.7 171.7,122.37 171.7,120.34 v1(171.62,120.27) ; v1(73.05,189.25) 73.05,188.46 72.31,187.73 70.91,187.73 69.01,185.82 69.01,184.3 70.93,182.38 70.93,181.36 73.34,178.95 73.34,178.31 74.33,177.33 85.76,177.33 86.53,176.55 86.53,175.43 87.89,174.08 89.77,174.08 92.27,171.57 v2(92.27,169.06)
  BOTTOM w0.114: PR9285.2 v1(168.96,135.73) ; v2(62.99,186) 62.89,186.1 62.25,186.1 62.1,185.95 60.62,185.95 60.12,185.44 PR9287.2 ; v1(73.05,189.25) 73.05,189.35 73.61,189.92 PR5023.1 ; v2(92.27,169.06) 94.18,170.96 v2(94.79,170.96) 105.56,170.96 109.77,175.18 119.08,175.18 v1(119.18,175.28)
  BOTTOM w0.203: v2(166.45,137.03) 166.45,137.06 PR7078.1
SWP_PWR: length 2.6
  TOP w0.114: TP13164.1 65.7,97.69 v2(66.21,98.19)
  BOTTOM w0.114: CN58.4 66.2,98.21 v2(66.21,98.19)
SYS_HWPG: length 348.5
  TOP w0.114: PR8060.2 17.52,111.96 17.36,112.12 v2(16.91,112.12) ; U37.124 155.06,109.91 155.57,109.4 v2(155.57,108.35) 154.3,109.62 152.9,109.62 152.62,109.89 150.69,109.89 150.19,109.39 148.03,109.39 147.79,109.15 147.79,108.39 147.24,107.85 146.86,107.85 146.73,107.72 144.19,107.72 143.36,106.88 143.36,105.13 142.84,104.62 142.84,103.2 142.32,102.67 D60.1 142.32,101.46 142.92,100.86 142.92,99.62 142.4,99.09 v2(142.4,98.96) ; v2(186.99,123.66) 186.99,123.65 186.99,123.4 186.63,123.05 v2(186.63,123.03) 186.17,123.03 186.16,123.02 184.76,123.02 183.69,121.94 183.69,118.89 182.6,117.81 v1(182.6,112.47) ; PR8041.1 32.29,115.08 32.41,115.21 32.41,115.57 v2(32.24,115.74)
  IN3 w0.102: v2(142.4,98.96) 142.4,98.94 139.92,96.47 124.91,96.47 124.66,96.72 119.58,96.72 119.1,96.24 117.72,96.24 116.48,94.99 114.12,94.99 v2(113.08,96.03) ; v1(182.6,112.47) 182.14,112.93 181.1,112.93 179.99,111.82 175.85,111.82 172.13,108.1 167.84,108.1 165.43,110.51 157.73,110.51 v2(155.57,108.35) ; v2(172.72,130.32) 172.72,129.36 176.07,126.01 178.35,126.01 179.44,124.92 185.73,124.92 v2(186.99,123.66) ; v2(50.39,189.66) 51.05,189 55.7,189 56.31,188.39 56.31,186.81 v2(58.52,184.6)
  IN4 w0.089: v2(50.39,189.66) 48.2,187.47 46.75,187.47 42.34,183.07 42.34,180.69 40.72,179.07 37.62,179.07 35.22,176.68 35.22,173.12 35.86,172.49 35.86,169.25 34.72,168.11 34.72,166.65 33.95,165.88 31.8,165.88 29.64,163.73 29.64,162.46 27.6,160.42 27.6,155.67 29,154.27 29,149.75 28.44,149.2 28.44,133.45 27.73,132.74 27.73,130.58 28.62,129.69 28.62,120.67 29.38,119.91 29.38,119.15 32.24,116.29 v2(32.24,115.74) 32.24,105.5 33.95,103.78 33.95,100.48 36,98.43 36.74,98.43 38.93,96.24 45.05,96.24 45.69,95.6 48.61,95.6 50.21,94 50.21,92.86 51.4,91.67 74.01,91.67 75.43,93.08 75.96,93.08 79.55,96.67 85.77,96.67 86.79,95.65 92.5,95.65 93.01,96.16 95.93,96.16 97.46,94.63 112.95,94.63 113.08,94.76 v2(113.08,96.03)
  BOTTOM w0.114: PR6022.1 58.52,185.11 v2(58.52,184.6) ; v2(32.24,115.74) 32.08,115.59 28.39,115.59 26.93,114.12 25.18,114.12 23.76,112.7 18.68,112.7 18.1,112.12 v2(16.91,112.12) ; v2(172.72,130.32) 172.72,130.25 173.05,129.91 PR6004.1
SYS_PWROK: length 17.6
  TOP w0.114: R68478.1 v2(127.81,118.26) 127.36,118.7 126.6,118.7 125.65,119.66 124.89,119.66 v1(124.76,119.78)
  IN4 w0.089: v1(124.76,119.78) 124.25,120.29 124.25,120.93 123.24,121.94 121.92,121.94 120.9,122.96 119.68,122.96 119.43,123.21 118.92,123.21 118.54,123.59 118.54,127.15 118.99,127.61 v1(119.03,127.61)
  BOTTOM w0.102: v1(119.03,127.61) 119.03,127.61 119.21,127.61 U6539.DF10
SYS_RESET#: length 9.4
  TOP w0.089: v1(119.04,128.21) 119.21,128.21 119.57,128.57 121.06,128.57 121.25,128.37 121.25,127.61 121.48,127.38 122.09,127.38
  TOP w0.114: 122.09,127.38 122.55,127.38 123.46,128.29 125.42,128.29 v2(125.55,128.17) R68469.2
  BOTTOM w0.102: U6539.DD10 119.24,128.23 119.06,128.23 v1(119.04,128.21)
SYS_SHDN#: length 387.9
  TOP w0.114: PR6002.1 174.09,134.04 v2(173.76,133.7) ; v2(200.45,105.69) 200.45,105.89 199.13,107.21 199.13,110.46 198.34,111.25 198.34,115.54 198.78,115.97 198.78,123.95 200.58,125.75 201.32,125.75 201.95,126.39 v2(206.8,126.39) 206.93,126.39 207.69,127.15 209.43,127.15 v2(209.92,127.64) ; U37.85 166.63,105.14 166.09,105.69 165.27,105.69 164.82,105.23 v2(164.82,104.64) ; v1(104.26,104.04) 104.26,104.24 104.57,104.54 105.71,104.54 105.99,104.26 Q86.3
  TOP w0.254: PR6002.1 175.56,133.4 175.79,133.18 PR6009.1
  IN1 w0.089: v2(172.13,149.88) 171.88,149.88 169.46,152.3 169.46,154.58 167.98,156.07 167.98,158.22 166.58,159.62 166.58,167.24 165.98,167.84 160.02,167.84 158.97,168.88 152.59,168.88 151.8,169.67 143.34,169.67 140,173.01 140,174.77 138.93,175.84 136.14,175.84 134.41,177.57 130.09,177.57 129.46,178.2 125.52,178.2 122.09,181.63 119.81,181.63 118.59,182.84 114.26,182.84 113.86,182.44 111.27,182.44 110.87,182.05 103.01,182.05 102.15,182.9 101.7,182.9 101.35,183.24 101.35,183.68 100.1,184.93 98.27,184.93 97.89,185.32 97.04,185.32 96.69,184.97 95.89,184.97 95.37,185.49 v1(95.37,185.86) ; v1(142.98,102.26) 142.54,102.26 142.51,102.28 140.03,102.28 139.72,101.98 128.67,101.98 128.04,102.61 118.33,102.61 117.8,102.08 109.47,102.08 108.4,103.15 105.15,103.15 v1(104.26,104.04)
  IN3 w0.102: v2(56.81,187.98) 56.81,188.75 65.38,197.31 71.36,197.31 72.31,196.36 79.04,196.36 80.67,197.99 83.41,197.99 84.02,197.38 89.07,197.38 90.34,196.11 90.34,192.81 94.15,189 94.15,187.11 95.37,185.89 v1(95.37,185.86) ; v2(209.92,127.64) 208.34,129.22 200.29,129.22 198.92,130.59 197.24,130.59 195.79,129.14 192,129.14 188.64,125.78 179.8,125.78 178.81,126.77 177.34,126.77 176.07,128.04 176.07,132.36 174.72,133.7 v2(173.76,133.7) 173.2,134.26 172.33,134.26 171.5,135.1 171.5,138.07 169.62,139.95 169.62,144.55 169.84,144.78 169.84,145.64 171.62,147.42 171.62,149.37 v2(172.13,149.88) ; v2(200.45,105.69) 198.56,103.79 193.2,103.79 190.85,106.14 188.72,106.14 188.01,105.43 187.37,105.43 186.99,105.81 183.62,105.81 179.3,110.13 176.4,110.13 171.45,105.18 165.35,105.18 v2(164.82,104.64) 164.22,105.24 160.51,105.24 158.62,103.35 155.01,103.35 154.73,103.07 149.96,103.07 149.12,102.23 146.96,102.23 146.1,101.37 144.19,101.37 143.3,102.26 v1(142.98,102.26)
  BOTTOM w0.114: v1(142.98,102.26) 139.72,105.52 137.51,105.52 137.44,105.6 136.81,105.6 136.32,106.09 136.32,107.62 135.99,107.95 135.99,108.53 135.06,109.46 135.06,109.84 133.65,111.25 133.65,113.31 132.89,114.07 132.89,116.1 133.55,116.76 PR3022.2 ; v2(56.81,187.98) 57.58,187.98 57.8,187.76 PR6020.1
TABLET_MODE: length 395.8
  TOP w0.114: v1(135.43,106.63) 135.91,106.63 136.62,107.34 137.33,107.34 138.98,108.99 138.98,109.37 139.59,109.98 140.46,109.98 141.65,111.17 146.88,111.17 147.34,111.63 147.72,111.63 148.99,112.9 149.35,112.9 149.63,113.18 151.93,113.18 R69084.1 ; v2(136.96,205.95) 138.41,205.95 140.59,208.13 v2(140.59,209.7) 140.59,210.04 141.14,210.59 141.14,210.97 140.93,211.19 140.09,211.19 U6525.1 ; v2(210.74,127.4) 210.74,125.88 209.09,124.23 209.09,119.91 211.72,117.28 211.72,113.01 211.26,112.56 211.26,108.75 207.56,105.05 207.44,105.05 206.67,104.29 204.9,104.29 204.01,103.4 203.12,103.4 202.74,103.02 202.74,101.11 202.99,100.86 202.99,99.97 202.1,99.08 v2(202.1,95.22)
  IN1 w0.089: v2(202.1,95.22) 201.52,95.22 201.24,95.5 174.32,95.5 173.78,96.03 172.13,96.03 171.83,95.73 169.52,95.73 168.96,96.29 153.72,96.29 153.08,96.92 145.72,96.92 145.16,97.48 v1(138.09,97.48) 137.71,97.48 137.18,98.02 135.4,98.02 134.87,97.48 120.11,97.48 119.81,97.18 118.41,97.18 116.33,95.09 105.89,95.09 105.33,95.65 101.95,95.65 101.39,95.09 96.62,95.09 95.93,95.78 92.66,95.78 v2(91.75,96.68)
  IN3 w0.102: v2(210.74,127.4) 210.48,127.15 209.34,127.15 209.17,126.97 203.96,126.97 202.36,125.37 197.94,125.37 197.18,124.61 191.82,124.61 190.04,122.83 186.1,122.83 185.59,122.32 181.66,122.32 181.15,122.83 169.72,122.83 169.44,123.11 167.79,123.11 166.92,123.97 166.67,123.97 166.29,124.36 166.29,124.61 164.57,126.33 161.72,126.33 159.43,128.62 159.43,130.71 155.62,134.52 154.86,134.52 149.52,139.85 144.95,139.85 144.32,140.48 144.32,145.95 143.17,147.09 143.17,151.61 142.62,152.17 142.62,154.71 143.05,155.14 143.05,168.55 138.86,172.74 133.52,172.74 131.87,174.39 131.87,176.3 130.98,177.19 130.98,178.84 129.08,180.74 126.03,180.74 125.39,181.38 125.39,181.89 123.49,183.79 123.49,186.11 124.25,186.88 124.25,189.25 124.38,189.38 124.38,194.33 123.87,194.84 123.87,195.6 124.12,195.85 124.12,203.71 125.16,204.75 125.16,205.51 126.79,207.14 132.52,207.14 132.82,206.85 135.03,206.85 135.52,206.36 136.55,206.36 v2(136.96,205.95)
  BOTTOM w0.114: v1(138.09,97.48) 137.59,97.99 137.59,99.46 137.21,99.84 137.21,102.69 137.5,102.98 137.5,104.53 137.13,104.9 136.44,104.9 135.43,105.91 v1(135.43,106.63) 135.43,107.46 135.25,107.64 135.25,108.15 134.36,109.04 134.36,109.55 132.63,111.27 132.63,112.8 132.25,113.18 131.49,113.18 130.95,113.72 130.57,113.72 129.59,114.7 129.59,118.89 130.98,120.29 131.74,120.29 132.13,120.67 132.13,121.69 132.89,122.45 U6556.13 ; v2(91.75,96.68) 90.65,95.58 87.12,95.58 86.28,96.42 86.28,98.96 86.65,99.33 CN4.2
TBT1_CC1: length 53.6
  IN1 w0.406: v5(7.92,67.46) 8.3,67.46 8.55,67.71
  IN1 w0.508: v1(10.54,71.78) 10.28,71.78 v1(9.9,71.4) 9.9,70.96 9.57,70.63 9.57,70 8.55,68.98 8.55,67.71
  IN3 w0.406: 8.55,67.71 8.3,67.46 v5(7.92,67.46)
  IN3 w0.508: v2(20.77,47.65) 21.15,47.27 v2(21.38,47.27) 21.51,47.27 22.14,47.9 22.14,49.43 21.51,50.06 18.84,50.06 15.29,53.62 15.29,54.63 14.02,55.9 14.02,64.16 13.25,64.92 13.25,66.72 14.07,67.54 14.07,71.78 13.89,71.95 13.89,72.54 13.38,73.05 11.09,73.05 10.54,72.49 v1(10.54,71.78) 10.28,71.78 v1(9.9,71.4) 9.9,70.96 9.57,70.63 9.57,69.92 8.55,68.91 8.55,67.71
  BOTTOM w0.203: D13118.1 10.59,71.83 v1(10.54,71.78) 10.28,71.78 v1(9.9,71.4)
  BOTTOM w0.254: v5(7.92,67.46) 7.79,67.46 7.63,67.3 CN10.B5
  BOTTOM w0.305: v2(20.77,47.65) 20.77,47.8 20.26,48.31 U6555.9
  BOTTOM w0.508: v2(20.77,47.65) 21.15,47.27 v2(21.38,47.27) 21.51,47.27 21.89,47.65 C96868.2
TBT1_CC2: length 28.7
  IN3 w0.508: v2(21.38,49.17) 21.22,49.34 v2(20.72,49.34) 18.42,49.34 14.52,53.24 14.52,54.38 13.13,55.78 13.13,57.81 11.73,59.2 11.73,63.9 11.86,64.03 11.86,64.69 v2(11.67,64.88) 11.2,65.35 v2(11.17,65.35)
  BOTTOM w0.254: CN10.A5 9.41,66.04 9.67,65.78 9.98,65.78 10.22,65.54 D13119.1
  BOTTOM w0.305: v2(20.72,49.34) 20.7,49.31 U6555.7
  BOTTOM w0.508: v2(20.72,49.34) 21.22,49.34 v2(21.38,49.17) 21.89,48.66 C96867.2 ; 10.98,65.54 v2(11.17,65.35) ; 10.98,65.54 11.01,65.54 v2(11.67,64.88) ; 10.98,65.54 D13119.1
TBT_FORCE_PWR: length 156.8
  TOP w0.079: U6549.B10 18.79,61.57 18.79,61.13 18.5,60.85 17.69,60.85 17.68,60.86 17.65,60.86
  TOP w0.114: v1(91.61,125.9) 92.02,126.31 R68686.1 ; 17.65,60.86 17.45,60.86 16.91,60.32 R68609.1 R68613.1 15.64,60.32 15.54,60.22 15.16,60.22 v2(14.9,59.97) 14.9,58.32 16.43,56.79 20.87,56.79 21,56.92 22.27,56.92 22.52,56.66 v1(22.52,56.41) 22.52,55.78 22.12,55.37 21.48,55.37 20.62,54.51 20.62,50.7 20.11,50.19 20.11,44.65 v1(19.73,44.27)
  IN1 w0.089: v1(86.15,104.29) 85.64,103.78 80.06,103.78 77.74,101.47 77.74,99.03 73.78,95.07 73.78,94.33 70.45,91 37.5,91 35.89,89.39 35.89,88.82 34.56,87.5 34.56,81.59 31.67,78.7 31.67,68.66 28.94,65.94 27.22,65.94 26.77,65.48 26.77,60.04 26.84,59.97 26.84,57.93 25.57,56.66 22.78,56.66 v1(22.52,56.41)
  BOTTOM w0.102: 90.22,124.87 90.58,124.87 v1(91.61,125.9)
  BOTTOM w0.114: R68718.2 20.12,44.73 19.73,44.35 v1(19.73,44.27) ; v1(86.15,104.29) 86.15,105.43 85.85,105.74 85.85,106.63 84.03,108.44 84.03,109.84 83.9,109.97 83.9,114.23 88.08,118.41 88.08,121.21 88.64,121.76 88.64,123.67 89.84,124.87 90.22,124.87
TBT_FORCE_PWR_GPPB3: length 15
  TOP w0.089: v1(105.44,129.36) 105.27,129.54 102.92,129.54 102.69,129.31 102.53,129.31
  TOP w0.114: R68686.2 92.75,126.59 94.48,126.59 96.06,128.17 97.33,128.17 97.71,128.55 100.2,128.55 100.96,129.31 102.53,129.31
  BOTTOM w0.102: v1(105.44,129.36) 105.44,129.27 U6539.DB41
TBT_I2C_INT#: length 166.4
  TOP w0.114: R68728.1 93.52,128.8 95.04,130.32 97.45,130.32 97.79,130.65 105.17,130.65 v1(105.55,130.28)
  IN1 w0.089: v2(28.14,49.43) 27.22,49.43 26.72,49.93 26.72,55.14 27.6,56.03 27.6,63.01 32.43,67.84 32.43,78.38 35.17,81.12 35.17,87.02 36.49,88.34 36.49,88.92 37.97,90.4 72.04,90.4 v2(74.34,92.69)
  IN4 w0.089: v1(105.55,130.28) 104.2,128.93 101.06,128.93 98.5,126.36 98.5,125.14 96.82,123.47 96.82,122.78 96.74,122.7 96.74,122.37 94.41,120.04 94.41,119.02 90.98,115.59 90.98,110.39 89.58,108.99 82.85,108.99 80.69,106.83 78.91,106.83 76.6,104.52 v1(70.45,104.52)
  BOTTOM w0.102: U6539.CW40 v1(105.55,130.28)
  BOTTOM w0.114: R68734.1 25.18,49.43 Q6625.1 27.98,49.43 27.99,49.43 v2(28.14,49.43) ; v1(70.45,104.52) 70.53,104.44 70.53,102.51 71.04,102 71.22,102 72.15,101.07 72.15,99.04 73.02,98.17 73.02,98.14 73.43,97.74 73.43,93.61 v2(74.34,92.69)
TBT_I2C_INT#_D: length 8.4
  BOTTOM w0.114: Q6625.3 25.25,50.58 R68734.2 24.81,51.08 24.68,51.2 v2(24,51.2) 22.65,51.2 22.43,51.43 R68730.1 22.07,51.89 21.76,51.58 21.76,51.3 20.77,50.31 U6555.5
TBT_LSX0_RXD: length 7.3
  TOP w0.079: 23.78,67.47 23.77,67.46 23.71,67.46 23.56,67.3 21.56,67.3 21,66.74 20.79,66.74 20.62,66.58 20.62,66.16 U6549.L7
  TOP w0.114: 23.78,67.47 24.02,67.71 24.55,67.71 24.97,68.13 R68874.1 24.97,69.08 24.86,69.19 24.86,69.44 R68816.2
TBT_LSX0_RXD_SOC: length 147
  TOP w0.114: v1(24.07,71.66) 24,71.59 24,71.36 24.1,71.26 24.39,71.26 24.79,70.86 24.79,70.23 24.92,70.1 R68816.1
  IN3 w0.114: v1(24.07,71.66) 24.01,71.6 24.01,71.37 24.14,71.24 24.43,71.24 24.54,71.13 24.84,71.13 25.2,71.5 25.2,75.69 26.47,76.96 26.47,79.16 28.24,80.92 28.24,84.99 27.86,85.37 27.86,86.51 26.08,88.29 26.08,92.99 29.13,96.03 33.45,96.03 33.95,95.53 45,95.53 45.28,95.25 60.6,95.25 61.2,95.84 69.71,95.84 71.15,97.29 72.46,97.29 73.28,98.1 75.03,98.1 76.26,99.34 77.64,99.34 78.25,99.95 81.83,99.95 82.19,100.3 83.15,100.3 83.21,100.35 95.83,100.35 96.53,99.65 97.48,99.65 98.48,100.66 98.48,101.63 99.6,102.75 101.29,102.75 102.13,103.59 102.85,103.59 104.03,104.77 105.51,104.77 106.75,106.02 108.33,106.02 109.76,107.45 110.94,107.45 111.83,108.34 112.34,108.34 113.09,109.09 113.09,109.34 115.13,111.39 117.55,111.39 119.08,112.93 120.1,112.93 120.21,113.04 121.88,113.04 122.39,113.55 122.39,114.11 122.3,114.2 122.08,114.2 121.88,113.99 v1(121.88,113.97)
  BOTTOM w0.102: 122.62,118.97 122.21,119.38 121.98,119.38 121.08,120.28 121.08,120.79 120.92,120.94 120.92,121.51 U6539.DV8
  BOTTOM w0.114: 122.62,118.97 122.85,118.73 122.85,117.44 122.4,116.99 122.4,115 122.35,114.94 122.35,113.8 122.23,113.69 122.07,113.69 121.88,113.88 v1(121.88,113.97) 121.3,113.39 R68365.2 R68372.1
TBT_LSX0_TXD: length 7.3
  TOP w0.079: U6549.M7 20.41,66.59 20.72,66.9 20.94,66.9 21.5,67.46 23.49,67.46 23.6,67.57 23.6,67.62 23.62,67.64
  TOP w0.114: 23.62,67.64 23.92,67.94 24.46,67.94 24.74,68.22 24.74,68.4 24.66,68.48 24.38,68.48 24.3,68.56 24.3,68.73 24.4,68.83 R68610.1 24.63,69.22 24.63,69.47 24.45,69.65 R68815.2
TBT_LSX0_TXD_SOC: length 145.4
  TOP w0.114: R68815.1 24.56,70.35 24.56,70.77 24.3,71.03 24.01,71.03 23.67,71.37 v1(23.4,71.37)
  IN3 w0.114: v1(23.4,71.37) 23.67,71.37 24.04,71 24.33,71 24.44,70.89 24.94,70.89 25.45,71.4 25.45,75.59 26.72,76.86 26.72,79.06 28.48,80.82 28.48,85.09 28.1,85.47 28.1,86.61 26.32,88.39 26.32,92.89 29.23,95.79 33.35,95.79 33.85,95.28 44.9,95.28 45.18,95.01 60.7,95.01 61.3,95.6 69.81,95.6 71.25,97.05 72.56,97.05 73.38,97.86 75.13,97.86 76.36,99.09 77.74,99.09 78.35,99.7 81.93,99.7 82.29,100.06 83.25,100.06 83.31,100.11 95.73,100.11 96.43,99.41 97.58,99.41 98.72,100.56 98.72,101.53 99.7,102.51 101.39,102.51 102.23,103.35 102.95,103.35 104.13,104.53 105.61,104.53 106.85,105.77 108.43,105.77 109.86,107.21 111.04,107.21 111.93,108.1 112.44,108.1 113.33,108.99 113.33,109.24 115.23,111.15 117.65,111.15 119.18,112.68 120.2,112.68 120.31,112.8 121.98,112.8 122.63,113.45 122.63,114.02 122.79,114.18 v1(122.79,114.2)
  BOTTOM w0.102: 122.71,119.18 122.69,119.18 122.3,119.58 122.07,119.58 121.28,120.37 121.28,120.88 121.13,121.03 121.13,121.77 120.72,122.18 U6539.DU8
  BOTTOM w0.114: 122.71,119.18 123.08,118.81 123.08,117.34 122.63,116.89 122.63,114.9 122.58,114.84 122.58,114.41 v1(122.79,114.2)
TBT_LSX1_RXD: length 6.5
  TOP w0.114: v1(120.87,127.61) 120.88,127.61 121.39,127.1 122.65,127.1 123.36,127.81 v2(124.15,127.81) 124.2,127.76 124.2,127.28 124.61,126.87 R68366.2 125.47,126.87 R68373.1
  BOTTOM w0.102: v1(120.87,127.61) 120.93,127.61 U6539.DD6
TBT_LSX2_RXD: length 10.4
  TOP w0.089: 112.82,122.07 112.82,123.09 113.2,123.47 113.2,124.12 v1(113.57,124.48)
  TOP w0.114: R68367.2 R68374.1 v4(112.77,117.6) 112.73,117.63 112.73,117.97 112.57,118.13 R68908.2 112.95,118.42 113.08,118.54 113.08,119.15 113.46,119.53 113.46,119.91 112.82,120.55 112.82,122.07
  BOTTOM w0.102: v1(113.57,124.48) 113.76,124.48 U6539.DM23
TBT_LSX3_RXD: length 11.5
  TOP w0.114: v1(117.5,116.2) 117.65,116.05 R68375.1
  IN2 w0.102: v1(114.47,123.72) 115.23,122.96 115.23,122.73 116.48,121.48 116.48,120.32 118.03,118.77 118.03,116.61 117.62,116.2 v1(117.5,116.2)
  BOTTOM w0.102: U6539.DN21 114.56,123.72 v1(114.47,123.72)
  BOTTOM w0.114: v1(117.5,116.2) 117.8,116.51 R68368.2
TBTA_RX1_N: length 3.6
  BOTTOM w0.114: C96802.2 11.45,69.55 arc(11.29,69.66) 11.09,69.69 10.84,69.69 arc(10.7,69.67) R68671.2 arc(10.54,69.63) 10.5,69.66 arc(10.45,69.69) 10.39,69.69 9.84,69.69 arc(9.78,69.68) 9.74,69.64 arc(9.71,69.57) 9.7,69.5 9.7,69.31 arc(9.67,69.17) 9.59,69.05 arc(9.51,68.94) 9.48,68.82 arc(9.37,68.62) 9.16,68.54 CN10.A10
TBTA_RX1_P: length 3.6
  BOTTOM w0.114: CN10.A11 9.2,69.04 arc(9.26,69.06) 9.31,69.09 9.43,69.21 arc(9.46,69.25) 9.47,69.31 9.47,69.5 arc(9.49,69.64) 9.54,69.76 arc(9.67,69.88) 9.84,69.92 10.08,69.92 arc(10.33,69.97) 10.55,70.12 R68670.2 10.71,70.03 arc(10.83,69.95) 10.97,69.92 11.17,69.92 arc(11.26,69.94) 11.35,70 11.44,70.09 arc(11.49,70.16) C96801.2
TBTA_RX2_N: length 5.7
  TOP w0.114: C96809.2 arc(11.49,62.92) 11.44,62.85 11.4,62.81 arc(11.33,62.76) 11.25,62.75 10.99,62.75 arc(10.77,62.79) R68673.2 arc(10.41,62.8) 10.21,62.76 9.95,62.76 arc(9.68,62.87) 9.57,63.14 9.57,63.27 arc(9.51,63.57) 9.34,63.82 8.68,64.48 arc(8.51,64.6) 8.3,64.64 8.29,64.64 arc(8.09,64.68) v5(7.92,64.79)
  BOTTOM w0.114: CN10.B10 7.91,64.79 arc(7.92,64.79) v5(7.92,64.79)
TBTA_RX2_P: length 5.7
  TOP w0.114: v5(7.92,64.26) arc(8.09,64.37) 8.29,64.41 8.3,64.41 arc(8.42,64.39) 8.52,64.32 9.18,63.66 arc(9.3,63.48) 9.34,63.27 9.34,63.14 arc(9.52,62.71) 9.95,62.53 10.21,62.53 arc(10.41,62.49) R68672.2 arc(10.75,62.48) 10.93,62.52 11.25,62.52 arc(11.33,62.5) 11.4,62.46 11.44,62.42 arc(11.49,62.34) C96808.2
  BOTTOM w0.114: CN10.B11 7.83,64.3 arc(7.88,64.29) v5(7.92,64.26)
TBTA_SBU1_CCG5_L: length 3.2
  BOTTOM w0.114: U6555.38 17.81,53.87 17.94,54 17.94,54.56 18.71,55.34 18.71,55.64 R68713.1
TBTA_SBU1_CCG5_R: length 3
  BOTTOM w0.114: U6555.36 16.81,53.74 16.94,53.87 16.94,55.48 R68715.1
TBTA_SBU1_CON_CCG5: length 31.3
  IN3 w0.114: v1(11.22,71.47) 11.6,71.09 11.6,70.63 10.59,69.62 10.16,69.62 9.19,68.65 9.19,66.82 8.22,65.86 v5(7.92,65.86)
  IN4 w0.089: v1(16.43,54.51) 14.52,56.41 14.52,66.45 14.9,66.83 14.9,70.82 14.67,71.05 14.11,71.05 13.63,71.52 v1(13.41,71.52)
  BOTTOM w0.114: U6555.35 16.31,53.87 16.43,54 v1(16.43,54.51) ; CN10.B8 7.86,65.79 v5(7.92,65.86) ; v1(11.22,71.47) 11.44,71.69 R68955.1 D13146.1 13.24,71.69 v1(13.41,71.52)
TBTA_SBU1_TX_BB: length 21.5
  TOP w0.079: U6549.M10 19.03,66.56 18.26,67.33 17.19,67.33 16.71,67.81 16.51,67.81 16.3,68.02
  TOP w0.114: R68612.1 16.71,68.83 v1(16.1,68.22) 16.3,68.02
  IN1 w0.089: v1(18.56,57.43) 18.56,56.75 18.44,56.63 17.95,56.63 17.83,56.75 17.83,57.17 17.7,57.3 v1(17.19,57.3)
  IN4 w0.089: v1(16.1,68.22) 16.1,68.04 16.78,67.36 16.78,60.25 17.83,59.2 17.83,57.68 18.08,57.43 v1(18.56,57.43)
  BOTTOM w0.114: R68713.2 18.46,57.32 v1(18.56,57.43) ; R68715.2 17.16,57.3 v1(17.19,57.3)
TBTA_SBU2_CCG5_L: length 3.3
  BOTTOM w0.114: U6555.39 18.31,53.87 18.17,54 18.17,54.47 18.94,55.24 18.94,55.41 R68714.1
TBTA_SBU2_CCG5_R: length 2.9
  BOTTOM w0.114: R68716.1 17.17,55.57 17.17,53.89 17.31,53.76 U6555.37
TBTA_SBU2_CON_CCG5: length 31.2
  IN4 w0.089: v1(12.89,67.54) 13,67.42 13,66.06 13.2,65.86 13.43,65.86 13.63,66.06 13.63,66.95 14.14,67.46 14.14,70.75 14.27,70.87 14.6,70.87 14.73,70.75 14.73,66.9 14.35,66.52 14.35,56.34 15.79,54.89 15.79,54.25 v1(15.92,54.12)
  BOTTOM w0.114: U6555.34 15.81,54.01 v1(15.92,54.12) ; CN10.A8 9.28,67.54 9.47,67.74 9.85,67.74 10.32,68.21 D13147.1 R68956.1 12.58,68.21 12.89,67.9 v1(12.89,67.54)
TBTA_SBU2_RX_BB: length 21.3
  TOP w0.079: v1(16.91,68.22) 16.91,67.87 17.29,67.49 18.43,67.49 19.24,66.68 19.24,66.16 U6549.L10
  TOP w0.114: R68611.1 17.4,68.4 17.32,68.48 17.17,68.48 v1(16.91,68.22)
  IN1 w0.089: v1(19.17,57.43) 18.66,57.93 v1(17.19,57.93)
  IN4 w0.089: v1(19.17,57.43) 18.33,58.26 18.33,59.38 17.19,60.52 17.19,67.59 16.91,67.87 v1(16.91,68.22)
  BOTTOM w0.114: v1(17.19,57.93) 17.7,57.43 17.7,56.88 R68716.2 ; R68714.2 19.17,56.93 v1(19.17,57.43)
TBTA_SSRX1_N: length 2.9
  TOP w0.079: 16.95,65.82 16.97,65.82 16.98,65.84 arc(17.01,65.85) 17.04,65.86 17.07,65.86 arc(17.12,65.84) 17.15,65.78 17.15,65.38 arc(17.18,65.22) 17.28,65.09 arc(17.42,64.98) 17.6,64.95 17.75,64.95 arc(17.82,64.93) 17.88,64.89 arc(17.95,64.84) 18.04,64.82 18.21,64.82 arc(18.35,64.85) 18.47,64.93 U6549.J11
  TOP w0.114: R68596.1 16.65,65.73 arc(16.68,65.8) 16.75,65.82 16.95,65.82
TBTA_SSRX1_N_C: length 8.6
  TOP w0.114: v1(15.54,65.53) 15.62,65.61 arc(15.78,65.72) 15.97,65.76 16.05,65.76 arc(16.16,65.71) 16.2,65.6 R68596.2
  BOTTOM w0.114: v1(15.54,65.53) 14.63,65.53 arc(14.49,65.56) 14.37,65.64 14.28,65.73 arc(14.2,65.85) 14.17,66 14.17,69.28 arc(14.01,69.66) 13.63,69.82 13.36,69.82 arc(13.13,69.78) 12.94,69.65 D13152.1 12.75,69.7 arc(12.65,69.77) 12.52,69.8 12.39,69.8 arc(12.24,69.77) 12.11,69.71 12.05,69.66 arc(11.98,69.59) C96802.1
TBTA_SSRX1_P: length 3
  TOP w0.079: U6549.J12 18.23,65.03 arc(18.28,65.05) 18.3,65.11 18.3,65.15 arc(18.28,65.23) 18.2,65.25 17.95,65.25 arc(17.88,65.24) 17.83,65.2 17.76,65.14 arc(17.72,65.11) 17.68,65.1 17.6,65.1 arc(17.5,65.12) 17.41,65.18 17.37,65.22 arc(17.32,65.29) 17.31,65.38 17.31,65.78 arc(17.24,65.95) 17.07,66.02 17.04,66.02 arc(17.01,66.02) 16.98,66.04 16.97,66.05 16.95,66.05
  TOP w0.114: 16.95,66.05 16.75,66.05 arc(16.68,66.08) 16.65,66.14 R68594.1
TBTA_SSRX1_P_C: length 8.6
  TOP w0.114: R68594.2 16.2,66.31 arc(16.18,66.2) 16.12,66.11 16.09,66.08 arc(15.99,66.01) 15.87,65.99 15.84,65.99 arc(15.7,66.01) 15.58,66.09 v1(15.54,66.14)
  BOTTOM w0.114: v1(15.54,66.14) 15.36,65.95 arc(15.14,65.81) 14.88,65.76 14.63,65.76 arc(14.58,65.77) 14.53,65.8 14.44,65.89 arc(14.41,65.94) 14.4,66 14.4,69.28 arc(14.17,69.82) 13.63,70.05 13.09,70.05 arc(12.97,70.07) D13151.1 arc(12.75,70.05) 12.6,70.02 12.39,70.02 arc(12.2,70.06) 12.04,70.17 C96801.1
TBTA_SSRX2_N: length 2.8
  TOP w0.079: 17.12,61.83 17.12,61.85 17.14,61.87 arc(17.15,61.89) 17.16,61.92 17.16,61.96 arc(17.16,61.97) 17.16,61.97 17.16,62.01 arc(17.18,62.11) 17.25,62.19 17.37,62.29 arc(17.45,62.34) 17.54,62.36 17.7,62.36 arc(17.77,62.37) 17.83,62.41 arc(17.91,62.46) 18,62.48 18.21,62.48 arc(18.35,62.45) 18.47,62.37 U6549.C11
  TOP w0.114: R68601.1 16.65,61.7 arc(16.72,61.53) 16.89,61.46 17.01,61.46 arc(17.09,61.5) 17.12,61.58 17.12,61.83
TBTA_SSRX2_N_C: length 5.1
  TOP w0.114: C96809.1 arc(11.97,62.92) 12.02,62.85 12.06,62.81 arc(12.12,62.77) 12.18,62.76 12.54,62.76 arc(12.72,62.8) D13156.1 arc(13.06,62.78) 13.27,62.73 13.53,62.73 arc(13.67,62.71) 13.8,62.63 14.86,61.56 arc(14.97,61.49) 15.09,61.46 15.95,61.46 arc(16.02,61.48) 16.07,61.52 16.13,61.58 arc(16.19,61.65) R68601.2
TBTA_SSRX2_P: length 2.8
  TOP w0.079: 17.35,61.83 17.35,61.85 17.34,61.87 arc(17.32,61.89) 17.32,61.92 17.32,61.98 arc(17.32,61.99) 17.32,62 arc(17.33,62.04) 17.35,62.07 17.47,62.17 arc(17.51,62.19) 17.54,62.2 17.68,62.2 arc(17.72,62.19) 17.76,62.17 17.83,62.1 arc(17.88,62.06) 17.95,62.05 18.15,62.05 arc(18.26,62.16) 18.15,62.27 U6549.C12
  TOP w0.114: R68600.1 16.65,61 arc(16.72,61.17) 16.89,61.24 17.01,61.24 arc(17.25,61.34) 17.35,61.58 17.35,61.83
TBTA_SSRX2_P_C: length 5.1
  TOP w0.114: R68600.2 arc(16.19,61.05) 16.15,61.11 16.07,61.19 arc(16.02,61.22) 15.95,61.24 15.09,61.24 arc(14.88,61.28) 14.7,61.4 13.63,62.46 arc(13.59,62.49) 13.53,62.51 13.27,62.51 arc(13.06,62.46) D13155.1 12.85,62.36 arc(12.66,62.49) 12.44,62.53 12.27,62.53 arc(12.17,62.51) 12.09,62.46 12.01,62.38 arc(11.97,62.32) C96808.1
TBTA_SSTX1_N: length 2.3
  TOP w0.079: U6549.G11 18.47,64.01 arc(18.35,63.93) 18.21,63.9 18.03,63.9 arc(17.94,63.92) 17.86,63.97 arc(17.8,64.01) 17.73,64.03 17.66,64.03 arc(17.49,64.06) 17.35,64.15 17.3,64.21 17.26,64.25 arc(17.22,64.27) 17.19,64.28 17.13,64.28 arc(17.1,64.27) 17.07,64.26 17.06,64.24 17.04,64.24
  TOP w0.114: R68599.1 16.65,64.11 arc(16.69,64.21) 16.78,64.24 17.04,64.24
TBTA_SSTX1_N_C: length 9.8
  TOP w0.114: C96805.1 11.96,69.51 arc(12.02,69.68) 12.19,69.75 12.47,69.75 arc(12.69,69.7) D13154.1 arc(13.11,69.74) 13.39,69.8 13.77,69.8 arc(13.98,69.75) 14.16,69.63 arc(14.24,69.51) 14.27,69.36 14.27,68.61 arc(14.26,68.56) 14.23,68.51 arc(14.09,68.3) 14.04,68.06 14.04,64.98 arc(14.07,64.84) 14.15,64.71 14.52,64.35 arc(14.64,64.27) 14.78,64.24 15.9,64.24 arc(15.99,64.22) 16.06,64.17 R68599.2
TBTA_SSTX1_P: length 2.3
  TOP w0.079: U6549.G12 18.19,64.11 arc(18.24,64.13) 18.27,64.19 18.27,64.23 arc(18.24,64.31) 18.16,64.33 17.95,64.33 arc(17.88,64.32) 17.83,64.28 17.76,64.22 arc(17.72,64.19) 17.68,64.18 17.66,64.18 arc(17.56,64.2) 17.47,64.26 17.46,64.27 17.37,64.36 arc(17.29,64.41) 17.2,64.44 17.13,64.44 arc(17.1,64.44) 17.07,64.46 17.06,64.47 17.04,64.47
  TOP w0.114: 17.04,64.47 16.78,64.47 arc(16.69,64.51) 16.65,64.6 R68598.1
TBTA_SSTX1_P_C: length 9.8
  TOP w0.114: R68598.2 arc(16.2,64.74) 16.2,64.74 16,64.54 arc(15.92,64.49) 15.83,64.47 14.78,64.47 arc(14.73,64.48) 14.68,64.51 14.31,64.88 arc(14.28,64.92) 14.27,64.98 14.27,68.06 arc(14.3,68.21) 14.39,68.35 arc(14.47,68.47) 14.5,68.61 14.5,69.36 arc(14.45,69.6) 14.32,69.79 arc(14.06,69.96) 13.77,70.02 13.09,70.02 arc(13.06,70.03) 13.02,70.04 12.98,70.06 arc(12.92,70.09) D13153.1 arc(12.69,70.02) 12.47,69.97 12.23,69.97 arc(12.17,69.99) 12.11,70.02 12.01,70.13 arc(11.97,70.19) C96804.1
TBTA_SSTX2_N: length 2.3
  TOP w0.079: 16.94,63.05 16.96,63.05 16.97,63.04 arc(16.99,63.02) 17.02,63.01 17.13,63.01 arc(17.21,63.03) 17.28,63.08 17.41,63.21 arc(17.44,63.23) 17.47,63.25 arc(17.55,63.27) 17.62,63.28 17.7,63.28 arc(17.77,63.29) 17.83,63.33 arc(17.91,63.38) 18,63.4 18.21,63.4 arc(18.35,63.37) 18.47,63.29 U6549.E11
  TOP w0.114: 16.94,63.05 16.73,63.05 arc(16.67,63.08) 16.65,63.14 R68605.1
TBTA_SSTX2_N_C: length 4.8
  TOP w0.114: v1(15.54,63.19) 15.54,63.18 arc(15.6,63.04) 15.73,62.99 15.84,62.99 arc(15.92,63) 15.99,63.05 R68605.2
  BOTTOM w0.114: v1(15.54,63.19) 15.52,63.17 arc(15.33,63.05) 15.11,63 14.34,63 arc(14.2,62.97) 14.08,62.89 13.96,62.78 arc(13.92,62.75) 13.86,62.73 13.27,62.73 arc(13.06,62.78) D13158.1 arc(12.72,62.8) 12.54,62.76 12.21,62.76 arc(12.14,62.77) 12.09,62.81 12.01,62.89 arc(11.97,62.95) C96813.1
TBTA_SSTX2_P: length 2.3
  TOP w0.079: U6549.E12 18.15,63.19 arc(18.26,63.08) 18.15,62.97 17.95,62.97 arc(17.88,62.98) 17.83,63.02 17.76,63.09 arc(17.72,63.11) 17.68,63.12 17.62,63.12 arc(17.6,63.12) 17.57,63.11 arc(17.53,63.1) 17.5,63.08 17.39,62.97 arc(17.27,62.88) 17.13,62.86 17.02,62.86 arc(16.99,62.85) 16.97,62.83 16.96,62.82 16.94,62.82
  TOP w0.114: 16.94,62.82 16.73,62.82 arc(16.67,62.8) 16.65,62.73 R68604.1
TBTA_SSTX2_P_C: length 4.8
  TOP w0.114: R68604.2 16.06,62.67 arc(15.96,62.73) 15.84,62.76 15.73,62.76 arc(15.6,62.7) v1(15.54,62.57)
  BOTTOM w0.114: v1(15.54,62.57) 15.53,62.58 arc(15.31,62.72) 15.06,62.77 14.34,62.77 arc(14.29,62.76) 14.24,62.73 14.13,62.62 arc(14,62.53) 13.86,62.51 13.27,62.51 arc(13.06,62.46) D13157.1 12.85,62.36 arc(12.66,62.49) 12.44,62.53 12.23,62.53 arc(12.17,62.52) 12.11,62.48 12.01,62.38 arc(11.97,62.32) C96812.1
TBTA_TX1_N: length 5.3
  TOP w0.114: C96805.2 11.36,69.63 arc(11.24,69.72) 11.09,69.75 10.96,69.75 arc(10.76,69.7) R68667.2 arc(10.36,69.74) 10.09,69.8 9.85,69.8 arc(9.63,69.71) 9.55,69.49 arc(9.42,69.05) 9.06,68.75 arc(8.96,68.71) 8.85,68.7 8.35,68.7 arc(8.12,68.66) v5(7.92,68.53)
  BOTTOM w0.114: CN10.B3 7.45,68.3 arc(7.6,68.33) 7.73,68.41 7.79,68.47 arc(7.85,68.51) v5(7.92,68.53)
TBTA_TX1_P: length 5.3
  TOP w0.114: C96804.2 11.32,70.07 arc(11.22,70) 11.09,69.97 11.02,69.97 arc(10.79,70.02) R68666.2 10.51,70.08 arc(10.45,70.04) 10.38,70.02 9.85,70.02 arc(9.47,69.87) 9.32,69.49 arc(9.22,69.17) 8.97,68.96 arc(8.91,68.94) 8.85,68.93 8.23,68.93 arc(8.06,68.97) v5(7.92,69.06)
  BOTTOM w0.114: CN10.B2 7.43,68.79 arc(7.59,68.83) 7.73,68.92 7.83,69.02 arc(7.87,69.05) v5(7.92,69.06)
TBTA_TX2_N: length 4.7
  BOTTOM w0.114: CN10.A3 9.18,65.04 arc(9.31,65.02) 9.42,64.94 arc(9.45,64.89) 9.46,64.83 arc(9.48,64.74) 9.54,64.66 9.6,64.6 arc(9.67,64.49) 9.7,64.36 9.7,63.17 arc(9.81,62.9) 10.08,62.79 10.27,62.79 arc(10.44,62.82) R68669.2 arc(10.7,62.84) 10.84,62.81 11.25,62.81 arc(11.3,62.82) 11.34,62.84 C96813.2
TBTA_TX2_P: length 4.7
  BOTTOM w0.114: C96812.2 11.5,62.33 arc(11.49,62.38) 11.46,62.43 11.37,62.52 arc(11.3,62.57) 11.22,62.58 10.91,62.58 arc(10.8,62.56) 10.71,62.5 R68668.2 10.55,62.42 arc(10.39,62.52) 10.21,62.56 10.08,62.56 arc(9.65,62.74) 9.47,63.17 9.47,64.36 arc(9.46,64.4) 9.44,64.44 9.38,64.49 arc(9.32,64.53) 9.24,64.54 CN10.A2
TBTB_HPD: length 11.8
  BOTTOM w0.102: U6539.DF47 102.98,127.34 102.67,127.65 101.8,127.65 101.78,127.63 100.38,127.63 100.35,127.65 99.36,127.65 97.84,126.13 97.84,125.81 97.27,125.24 95.68,125.24 94.76,124.33 94.51,124.33 94.03,123.85 TP13240.1
TCP0_AUX_DN: length 188
  TOP w0.114: v1(22.91,70.76) 22.89,70.74 arc(22.82,70.64) 22.79,70.51 22.79,69.82 arc(22.76,69.74) 22.68,69.7 22.64,69.7 arc(22.56,69.67) 22.52,69.59 R68608.1
  IN3 w0.089: 119.88,150.29 119.89,150.31 119.89,150.35 120.03,150.49 arc(120.08,150.52) 120.14,150.53 121.04,150.53 arc(121.23,150.61) 121.31,150.8 arc(121.39,151) v1(121.58,151.08)
  IN3 w0.114: v1(22.91,70.76) 23.05,70.61 arc(23.08,70.58) 23.08,70.54 23.08,70.26 arc(23.27,69.82) 23.71,69.63 24.25,69.63 arc(24.78,69.74) 25.23,70.04 25.83,70.64 arc(26.05,70.96) 26.13,71.35 26.13,71.71 arc(26.13,71.77) 26.16,71.82 27.28,73.42 arc(27.33,73.52) 27.36,73.62 27.89,76.63 arc(27.91,76.68) 27.94,76.73 29.02,78.28 29.86,83.05 29.2,86.78 27.56,89.13 27.26,90.85 27.49,92.16 28.66,93.84 29.94,94.74 31.35,94.99 32.81,94.73 33.66,94.14 35.21,93.86 36.69,94.12 37.61,93.96 39.08,94.22 39.86,94.02 40.54,94.14 41.16,94.03 41.92,94.17 42.76,94.02 43.52,94.15 44.15,94.04 45.23,94.23 46.02,94.09 47.01,94.27 47.65,94.16 48.27,94.27 48.9,94.15 49.55,94.27 50.19,94.16 50.79,94.26 51.42,94.15 52.04,94.26 52.61,94.16 53.19,94.26 53.81,94.16 54.45,94.27 55.11,94.15 55.76,94.27 56.37,94.16 56.98,94.27 57.58,94.16 58.22,94.27 58.86,94.16 59.49,94.27 60.09,94.16 60.69,94.27 61.34,94.15 62.02,94.27 62.65,94.16 63.25,94.27 63.89,94.15 64.55,94.27 65.17,94.16 65.81,94.27 66.45,94.16 67.05,94.26 67.69,94.15 69.72,94.51 71.17,95.52 71.37,95.65 72.06,96.14 73.18,96.34 74.12,97 76.67,97.45 78.84,98.97 79.18,99.03 80.07,98.87 81,99.03 81.77,98.9 82.57,99.04 82.67,99.19 83.87,99.4 84.54,99.29 84.73,99.32 86.15,99.07 87.74,99.35 90.03,98.95 91.96,99.29 93.64,98.99 94.57,99.16 95.99,98.91 96.29,98.7 96.89,98.59 97.88,98.76 98.8,99.41 99.31,100.14 100.45,100.93 101.55,101.13 104.42,103.14 105.67,103.36 106.39,103.86 106.65,104.24 107.09,104.54 107.87,104.68 108.12,104.63 108.9,104.77 110.11,105.62 111.32,105.83 114.67,108.18 116.38,108.48 117.1,108.99 118.15,110.48 119.96,111.75 120.69,111.88 121.43,111.75 122.49,111.93 123.63,112.73 124.27,112.85 125.89,113.98 127.54,116.33 128.09,116.72 128.72,117.61 129.78,118.36 130.81,119.82 131.73,120.47 131.99,120.84 132.23,122.19 132.05,123.2 132.22,124.16 131.77,126.69 131.92,127.53 131.51,129.82 131.56,130.07 131.42,130.86 131.15,131.25 130.01,132.04 129.47,132.81 128.83,133.27 127.56,133.49 126.16,133.25 123.48,133.72 121.58,133.38 121.25,133.44 120.93,133.38 120.6,133.44 120.26,133.38 119.87,133.45 119.83,133.48 119.53,133.91 119.39,134.74 119.6,135.92 119.45,136.74 119.79,138.66 119.31,141.39 120.17,146.28 119.99,147.28 119.99,147.29 119.56,149.71 119.61,149.95 119.76,150.18 119.88,150.29
  BOTTOM w0.102: v1(121.58,151.08) 121.58,151.05 arc(121.62,150.89) 121.71,150.75 121.8,150.66 arc(121.84,150.63) U6539.AP5
TCP0_AUX_DN_R: length 5.2
  TOP w0.079: 22.9,68.09 22.89,68.08 22.89,68.06 arc(22.88,68.03) 22.86,68 22.76,67.9 arc(22.7,67.86) 22.62,67.84 21.69,67.84 arc(21.36,67.78) 21.09,67.59 20.86,67.36 arc(20.79,67.31) 20.7,67.28 arc(20.56,67.24) 20.45,67.15 20.08,66.78 arc(19.98,66.64) 19.95,66.48 U6549.M8
  TOP w0.114: R68608.2 22.44,68.8 arc(22.41,68.75) 22.4,68.69 22.4,68.63 arc(22.44,68.54) 22.52,68.5 22.88,68.5 arc(23.01,68.45) 23.06,68.33 23.06,68.26 23.05,68.23 22.9,68.09
TCP0_AUX_DP: length 188
  TOP w0.114: v1(23.52,70.76) 23.52,70.51 arc(23.48,70.42) 23.39,70.38 23.16,70.38 arc(23.11,70.37) 23.07,70.34 arc(23.03,70.29) 23.02,70.22 23.02,69.82 arc(23.05,69.74) 23.13,69.7 23.17,69.7 arc(23.25,69.67) 23.29,69.59 R68606.1
  IN3 w0.089: v1(120.95,151.08) 121.09,150.94 arc(121.12,150.9) 121.13,150.85 121.13,150.8 arc(121.1,150.74) 121.04,150.71 120.14,150.71 arc(120.01,150.69) 119.9,150.61 119.77,150.48 119.72,150.48 119.71,150.46
  IN3 w0.114: v1(23.52,70.76) 23.35,70.6 arc(23.33,70.57) 23.33,70.53 23.33,70.26 arc(23.44,69.99) 23.72,69.87 24.25,69.87 arc(24.69,69.96) 25.06,70.21 25.66,70.81 arc(25.83,71.06) 25.88,71.35 25.88,71.71 arc(25.9,71.84) 25.96,71.96 27.08,73.56 arc(27.11,73.61) 27.13,73.67 27.66,76.67 arc(27.69,76.78) 27.74,76.87 28.79,78.38 29.62,83.05 28.98,86.69 27.33,89.04 27.01,90.85 27.26,92.26 28.49,94.01 29.85,94.97 31.35,95.23 32.9,94.96 33.75,94.36 35.21,94.11 36.69,94.37 37.61,94.21 39.09,94.47 39.87,94.27 40.54,94.39 41.16,94.28 41.92,94.41 42.76,94.26 43.52,94.4 44.15,94.29 45.23,94.48 46.02,94.34 47.01,94.51 47.65,94.4 48.27,94.51 48.9,94.4 49.55,94.51 50.19,94.4 50.79,94.51 51.42,94.4 52.04,94.51 52.61,94.41 53.19,94.51 53.81,94.4 54.45,94.51 55.11,94.4 55.76,94.51 56.37,94.4 56.98,94.51 57.58,94.4 58.22,94.52 58.86,94.4 59.49,94.51 60.09,94.41 60.69,94.51 61.34,94.4 62.02,94.52 62.65,94.41 63.25,94.51 63.89,94.4 64.55,94.51 65.17,94.4 65.81,94.52 66.45,94.4 67.05,94.51 67.69,94.4 69.63,94.74 71.03,95.72 71.13,95.79 71.23,95.85 71.97,96.37 73.08,96.57 74.03,97.23 76.57,97.68 78.75,99.2 79.18,99.27 80.07,99.12 81,99.28 81.77,99.14 82.43,99.26 82.53,99.41 83.87,99.65 84.54,99.53 84.73,99.57 86.15,99.32 87.74,99.6 90.03,99.19 91.96,99.53 93.64,99.24 94.57,99.4 96.08,99.13 96.38,98.92 96.89,98.83 97.78,98.99 98.63,99.58 99.14,100.31 100.35,101.16 101.45,101.36 104.32,103.37 105.58,103.59 106.22,104.04 106.48,104.41 107,104.77 107.87,104.92 108.12,104.88 108.81,105 110.01,105.84 111.22,106.06 114.58,108.41 116.28,108.71 116.93,109.16 117.97,110.65 119.87,111.98 120.69,112.12 121.43,111.99 122.4,112.16 123.54,112.96 124.17,113.07 125.72,114.16 127.36,116.5 127.92,116.89 128.54,117.79 129.61,118.53 130.63,120 131.55,120.64 131.76,120.93 131.98,122.19 131.8,123.2 131.97,124.16 131.52,126.69 131.67,127.53 131.27,129.82 131.31,130.07 131.19,130.77 130.97,131.08 129.84,131.87 129.3,132.64 128.73,133.04 127.56,133.25 126.16,133 123.48,133.47 121.58,133.14 121.25,133.2 120.93,133.14 120.6,133.2 120.26,133.14 119.78,133.22 119.66,133.31 119.31,133.81 119.14,134.74 119.35,135.92 119.21,136.74 119.54,138.66 119.06,141.39 119.65,144.74 119.5,144.96 119.55,145.26 119.77,145.41 119.93,146.28 119.76,147.24 119.53,147.4 119.48,147.7 119.64,147.92 119.58,148.22 119.36,148.37 119.31,148.67 119.46,148.89 119.32,149.71 119.38,150.05 119.53,150.29 119.71,150.46
  BOTTOM w0.102: v1(120.95,151.08) 121.18,150.84 arc(121.23,150.78) 121.24,150.7 U6539.AP7
