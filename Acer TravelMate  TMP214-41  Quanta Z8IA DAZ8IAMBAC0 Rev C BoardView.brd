# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C0_SDA_TS: length 3.1
  BOTTOM w0.102: U6539.DW18 116.13,120.15
  BOTTOM w0.114: 116.13,120.15 116.13,118.38 TP13372.1
I2C1_CLK_TP: length 46.1
  TOP w0.114: R558.2 128.07,100.23 128.7,100.86 131.11,100.86 v2(131.49,101.24) 131.87,101.62 131.87,101.88 133.65,103.65 133.65,103.98 v1(133.83,104.16)
  IN2 w0.102: v1(115.95,114.45) 115.95,114.91 117.01,115.97 117.01,119.1 116,120.11 116,121.28 114.73,122.55 114.73,122.96 114.47,123.21 114.22,123.21 113.99,123.44 113.99,125.35 113.58,125.75 v1(113.57,125.75)
  IN4 w0.089: v1(115.95,114.45) 115.95,113.48 116.99,112.44 116.99,111.73 118.84,109.88 125.52,109.88 127.77,107.63 128.48,107.63 129.28,106.83 130.48,106.83 132.76,104.54 133.45,104.54 v1(133.83,104.16)
  BOTTOM w0.102: v1(113.57,125.75) 113.73,125.75 U6539.DJ23
  BOTTOM w0.114: R68738.1 116,114.4 v1(115.95,114.45)
I2C1_DATA_TP: length 40.6
  TOP w0.114: R560.2 129.2,100.22 129.33,100.35 131.31,100.35 v2(132.76,101.8) 132.76,102 134.28,103.52 134.28,104.37 v1(133.8,104.85)
  IN4 w0.089: v1(116.53,114.45) 116.53,113.41 117.34,112.59 117.34,111.91 118.99,110.26 125.78,110.26 127.96,108.07 128.54,108.07 129.38,107.24 130.7,107.24 133.04,104.9 133.75,104.9 v1(133.8,104.85)
  BOTTOM w0.102: 115.62,119.4 115.62,121.24 115.66,121.28 115.78,121.59 115.84,121.77 115.84,122.32 U6539.DT18
  BOTTOM w0.114: 115.62,119.4 115.49,119.28 115.49,118.01 115.74,117.75 115.74,116.99 115.64,116.89 115.64,115.44 116.53,114.55 v1(116.53,114.45) 116.76,114.22 R68739.1
I2C2_SCL_SEN_HUB: length 84.1
  TOP w0.089: 112.06,122.07 112.29,122.3 112.29,125.37 112.03,125.63 111.9,125.63 v1(111.75,125.78)
  TOP w0.114: R68742.1 112.06,115.08 112.44,115.47 112.44,117.88 112.19,118.13 112.19,119.4 111.55,120.04 111.55,121.56 112.06,122.07
  IN3 w0.089: 111.48,127.33 111.39,127.24 111.39,126.17 111.75,125.81
  IN3 w0.102: v1(111.75,125.78) 111.75,125.81 ; v2(103.03,177.16) 104.67,177.16 105.25,177.75 109.34,177.75 109.7,177.39 109.7,176.55 113.48,172.76 113.48,169.54 113.91,169.11 113.91,166.7 114.55,166.06 114.55,165.07 114.22,164.74 113.84,164.74 113.33,164.23 113.33,163.6 113.46,163.47 113.46,159.79 112.97,159.31 112.97,157.53 112.57,157.12 112.57,156.61 112.82,156.36 112.82,155.22 111.81,154.2 111.81,131.47 110.92,130.58 110.92,128.11 111.48,127.55 111.48,127.33
  BOTTOM w0.102: v1(111.75,125.78) 111.74,125.77 111.56,125.77 U6539.DJ29
  BOTTOM w0.114: R25632.1 v2(103.03,177.16) 103.03,178.08 v2(102.66,178.46) 102.66,178.81 102.26,179.22 101.56,179.22 101.01,179.77 101.01,181.25 101.76,182 Q6632.3
I2C2_SDA_SEN_HUB: length 80.3
  TOP w0.089: 111.68,122.07 112.11,122.5 112.11,125.24 111.96,125.4 111.2,125.4 110.84,125.75 v1(110.84,125.75)
  TOP w0.114: R68743.1 111.5,113.76 111.65,113.91 111.65,115.18 112.19,115.72 112.19,117.75 111.93,118.01 111.93,119.28 111.3,119.91 111.3,121.69 111.68,122.07
  IN3 w0.089: 111.04,127.4 111.21,127.24 111.21,126.12 v1(110.84,125.75)
  IN3 w0.102: v1(106.42,176.65) 105.35,176.65 105.15,176.86 105.15,177.13 105.41,177.39 109.16,177.39 109.34,177.21 109.34,176.4 113.13,172.62 113.13,169.39 113.56,168.96 113.56,166.54 114.14,165.96 114.14,165.55 113.71,165.12 113.58,165.12 112.95,164.49 112.95,163.47 112.57,163.09 112.57,159.48 112.06,158.98 112.06,157.38 111.68,156.99 111.68,154.84 111.07,154.23 111.07,131.24 110.66,130.83 110.66,129.03 110.03,128.39 110.03,128.04 110.54,127.53 110.92,127.53 111.04,127.4
  BOTTOM w0.102: v1(110.84,125.75) 110.67,125.75 U6539.DJ31
  BOTTOM w0.114: R25630.1 106.61,176.47 v1(106.42,176.65) 106.42,178 106.09,178.33 Q6633.3
I2C3_SCL_NFC: length 74.5
  TOP w0.114: v1(70.4,106.93) 70.38,106.96 69.51,106.96 68.58,106.02 68.58,103.76 67.84,103.02 R68740.1 67.84,101.85 v2(67.42,101.44) 64.44,98.46 R67570.1 64.44,95.79 64.31,95.65 Q6556.3
  IN3 w0.089: v1(110.84,127.02) 110.29,126.47 110.29,123.34
  IN3 w0.102: v1(70.4,106.93) 70.4,109.55 75.08,114.22 75.08,114.42 79.04,118.39 80.56,118.39 81.1,118.92 81.1,119.55 81.55,120.01 88.03,120.01 89.61,121.59 98.88,121.59 99.18,121.89 108.43,121.89 110.66,119.66 110.94,119.66 111.2,119.91 111.2,121.41 110.29,122.31 110.29,123.34
  BOTTOM w0.102: v1(110.84,127.02) 110.98,127.02 U6539.DF29
I2C3_SDA_NFC: length 74.7
  TOP w0.114: Q6559.3 61.87,96.06 61.76,96.17 R67564.1 61.76,96.79 62.02,97.05 63.67,97.05 64.05,97.43 64.05,98.7 67,101.65 R68741.1 67,103.51 68.02,104.52 v2(68.02,106.1) 69.31,107.39 v1(70.81,107.39)
  IN3 w0.089: v1(110.84,126.39) 110.47,126.02 110.47,123.53 110.66,123.34
  IN3 w0.102: 110.66,123.34 110.66,122.7 111.55,121.82 111.55,121.31 111.42,121.18 111.42,119.81 111.07,119.45 110.36,119.45 109.77,120.04 109.65,120.04 108.15,121.54 99.33,121.54 99,121.21 89.86,121.21 88.31,119.66 81.71,119.66 81.45,119.4 81.45,118.77 80.68,117.99 79.15,117.99 75.48,114.32 75.48,114.09 70.78,109.39 70.78,107.49 70.81,107.46 v1(70.81,107.39)
  BOTTOM w0.102: v1(110.84,126.39) 110.99,126.39 U6539.DG29
I2C_INT#_TS: length 8.9
  BOTTOM w0.102: R68420.1 109.96,114.98 110.33,115.36 TP13369.1 110.38,115.52 110.38,119.17 110,119.55 110,120.86 110.42,121.28 110.54,121.59 110.6,121.77 110.6,122.57 U6539.DT31
I2C_RST#_TS: length 6.4
  BOTTOM w0.102: TP13370.1 110.18,117.52 110.18,119 109.8,119.38 109.8,121.03 109.9,121.13 109.9,122.94 U6539.DR32
I2C_SEL_PIN: length 1.6
  TOP w0.114: R68203.2 25.95,121.94 25.9,122 U6537.31
I2CA_SCL: length 9.9
  BOTTOM w0.102: U8.B7 124.83,182.86 124.83,182.11
  BOTTOM w0.305: 124.83,182.11 124.83,182 123.82,180.98 121.97,180.98 121.46,180.47 119.28,180.47 118.54,179.73 118.54,178.79 v2(118.31,178.56)
I2CA_SDA: length 8.8
  BOTTOM w0.305: U8.A7 125.29,182.38 125.29,181.85 124.02,180.58 122.17,180.58 121.63,180.04 119.61,180.04 119.3,179.73 119.3,178.84 v2(119.58,178.56)
I2CINT13: length 3.2
  TOP w0.114: U6516.B5 154.61,215.39 v2(154.21,215.79) 154.21,216.92 154.35,217.07 R68989.1
  BOTTOM w0.114: v2(153.84,216.43) 153.84,216.16 v2(154.21,215.79)
I219_PCH_SMCLK: length 198
  TOP w0.114: v1(74.11,109.12) 74.5,108.72 v2(74.5,106.99) 74.06,106.55 74.06,104.01 71.22,101.16 71.22,100.66 72.44,99.44 72.44,98.12 v1(72.49,98.07) 73.23,97.33 R68348.1 73.23,96.25 73.42,96.05 R68893.2 73.42,95.3 73.71,95.02 73.71,94.78 73.83,94.65 Q6616.3 ; v2(13.25,168.04) 13.14,167.93 Q6554.3 12.36,167.98 R67525.1
  IN1 w0.089: v2(43.78,117.17) 43.78,118.08 43.1,118.77 33.19,118.77 32.81,119.15 30.02,119.15 28.62,120.55 27.73,120.55 27.1,121.18 23.8,121.18 22.65,122.32 22.65,128.93 21.13,130.45 21.13,134.01 22.91,135.79 22.91,137.56 v2(22.65,137.82) ; v1(78.56,114.83) 79.98,116.25 81.64,116.25 81.97,116.58 82.83,116.58 84.21,117.95 88.8,117.95 89.62,118.77 91.97,118.77 93.72,120.52 94.05,120.52 95.1,121.56 101.58,121.56 101.77,121.75 106.98,121.75 107.3,121.43 109.49,121.43 110.38,122.32 114.73,122.32 115.75,123.35 115.75,125.41 v1(115.42,125.75)
  IN3 w0.102: v2(13.25,168.04) 12.75,168.04 12.11,167.41 12.11,163.98 10.71,162.58 10.71,160.83 11.5,160.04 13.89,160.04 16.52,157.41 16.52,155.2 22.65,149.08 v2(22.65,137.82) ; v1(74.11,109.12) 78.56,113.56 v1(78.56,114.83)
  IN4 w0.089: v1(72.49,98.07) 72.36,98.07 70.38,96.08 58.29,96.08 57.83,96.54 53.69,96.54 49.5,100.73 48.18,100.73 47.8,101.11 46.02,101.11 42.46,104.67 42.46,105.43 43,105.97 43,108.83 42.46,109.37 42.46,115.47 43.38,116.38 43.38,116.76 v2(43.78,117.17)
  BOTTOM w0.102: v1(115.42,125.75) 115.47,125.75 U6539.DK19
I219_PCH_SMDATA: length 202.3
  TOP w0.114: v2(11.22,164.49) 11.22,165.25 11.21,165.26 R67526.1 10.33,165.5 v2(10.21,165.63) 10.08,165.76 10.08,166.52 10.19,166.63 Q6554.6 ; v1(73.81,108.58) 74.09,108.3 74.09,107.21 73.68,106.8 73.68,104.26 70.84,101.42 70.84,100.5 72.05,99.29 72.05,98.37 v1(71.88,98.19) 71.88,97.74 72.05,97.56 72.44,97.56 72.56,97.43 R68349.1 72.36,97.28 71.88,96.8 71.88,96.49 71.5,96.11 71.5,95.2 71.88,94.81 71.88,92.78 72.31,92.35 R68894.2 73.35,93.08 73.09,93.35 Q6616.6
  IN1 w0.089: v2(21.89,137.82) 22.52,137.18 22.52,135.91 20.75,134.13 20.75,130.2 22.27,128.67 22.27,122.2 23.67,120.8 26.84,120.8 27.48,120.16 28.49,120.16 29.89,118.77 32.56,118.77 32.94,118.39 42.97,118.39 43.35,118.01 43.35,116.91 v2(43.78,116.48) ; v1(79.17,114.83) 80.23,115.9 81.78,115.9 82.11,116.23 82.98,116.23 84.34,117.59 88.94,117.59 89.76,118.41 92.12,118.41 93.87,120.16 94.2,120.16 95.22,121.18 101.9,121.18 102.13,121.41 106.85,121.41 107.21,121.05 109.62,121.05 110.51,121.94 114.85,121.94 115.93,123.02 115.93,124.67 116.29,125.03 v1(116.29,125.04)
  IN3 w0.102: v2(21.89,137.82) 21.89,149.34 16.17,155.06 16.17,157.13 13.63,159.66 11.35,159.66 10.33,160.68 10.33,162.71 11.73,164.11 11.73,166.01 11.55,166.19 11.4,166.19 11.22,166.01 v2(11.22,164.49) ; v1(73.81,108.58) 74.19,108.58 79.17,113.56 v1(79.17,114.83)
  IN4 w0.089: v1(71.88,98.19) 71.88,98.09 70.23,96.44 58.59,96.44 58.11,96.92 53.89,96.92 49.7,101.11 48.36,101.11 47.98,101.5 46.15,101.5 42.84,104.8 42.84,105.31 43.35,105.81 43.35,109.12 42.84,109.62 42.84,115.34 43.78,116.28 v2(43.78,116.48)
  BOTTOM w0.102: v1(116.29,125.04) 116.44,125.04 U6539.DM17
I219_SMCLK: length 10.9
  TOP w0.114: U6521.28 16.83,167.01 16.02,167.81 16.02,168.96 15.54,169.44 15.29,169.44 v2(15.03,169.69) 14.81,169.47 R4023.1 14.14,168.81 13.89,169.06 R67525.2 13.14,169.3 12.87,169.57 12.11,169.57 11.73,169.19 11.73,168.04 11.62,167.93 Q6554.4
I219_SMDATA: length 8
  TOP w0.114: R67526.2 11.99,165.87 11.69,166.17 11.69,166.48 11.84,166.63 Q6554.1 13.01,166.63 13.25,166.39 13.25,166.14 13.4,165.99 R4024.1 13.78,166.27 13.93,166.42 14.5,166.42 TP13162.1 15.92,166.01 16.05,166.14 16.42,166.14 16.75,165.81 U6521.31
ICCINSERTN: length 17
  TOP w0.114: U6509.19 215.1,97.53 215.37,97.81 v2(215.37,99.32)
  BOTTOM w0.114: CN53.2 225.9,101.64 225.16,102.38 v2(219.45,102.38) 217.09,102.38 216.83,102.13 216.83,100.79 v2(215.37,99.32)
ICMNT: length 119.6
  TOP w0.114: v2(206.17,122.58) v2(207.25,121.5) 208.33,120.42 208.33,119.78 211.12,116.99 211.12,113.43 210.73,113.04 210.73,109.23 207.44,105.94 207.06,105.94 206.17,105.05 204.9,105.05 203.8,103.96 202.53,103.96 201.06,102.49 201.06,97.79 198.05,94.78 175.17,94.78 173.78,96.16 172,96.16 171.61,95.77 C6564.2 171.24,95.4 171.06,95.22 170.1,95.22 169.92,95.4 169.92,96.54 169.34,97.13 169.11,97.13 168.29,97.94 U37.67
  IN3 w0.102: v1(164.64,122.2) 165.27,122.83 169.34,122.83 169.57,122.6 178.35,122.6 179.57,121.38 181.31,121.38 182.4,120.3 184.55,120.3 184.99,119.86 188.34,119.86 189.07,120.59 191.01,120.59 191.27,120.85 202.67,120.85 203.75,121.94 205.28,121.94 205.91,122.58 v2(206.17,122.58)
  BOTTOM w0.114: PR32.2 163.16,121.33 163.24,121.41 163.85,121.41 v1(164.64,122.2) 165.02,122.58 165.78,122.58 166.62,123.42 PC37.2
IDCHG_R: length 138.3
  TOP w0.114: v2(171.72,97.58) 171.25,98.05 170.22,98.05 169.75,98.52 C96796.2 169.59,98.85 169.3,99.14 U37.70
  IN1 w0.089: v1(196.49,123.67) 196.77,123.39 196.77,121.69 196.39,121.31 192.83,121.31 191.36,119.83 189.33,119.83 188.49,119 184.22,119 183.56,119.66 170.1,119.66 169.97,119.78 168.55,119.78 166.96,121.37 v1(166.17,121.37)
  IN2 w0.102: v2(171.72,97.58) 172.51,98.37 181.71,98.37 181.88,98.55 201.7,98.55 204.13,100.99 204.13,102.13 204.64,102.64 206.12,102.64 206.29,102.46 207.36,102.46 207.69,102.13 207.69,101.75 207.94,101.5 210.74,101.5 212.2,102.96 212.2,103.46 217.22,108.48 218.81,108.48 222.04,111.71 222.04,117.24 v2(221.55,117.74)
  IN3 w0.102: v2(221.55,117.74) 220.32,118.96 219,118.96 217.63,120.32 217.63,122.64 217.44,122.83 213.79,122.83 211.25,125.37 207.76,125.37 206.94,126.18 203.8,126.18 202.61,124.99 198.67,124.99 197.38,123.69 196.51,123.69 v1(196.49,123.67)
  BOTTOM w0.114: PR26.2 164.15,121.07 164.26,121.18 PC73.2 164.76,121.55 164.89,121.69 165.86,121.69 v1(166.17,121.37)
IDEA_G_3VLDO: length 3
  TOP w0.114: PQ8014.2 22.05,115.69 PR8044.1 23.26,115.69 23.41,115.84 23.63,115.84 23.78,115.69 PQ8016.3
IDEA_G_5VS5_PD_C1: length 2.9
  TOP w0.114: PQ8017.2 28.39,109.1 27.85,109.1 PR8059.1 27.24,109.07 PQ8018.3
ILIM_HI: length 3.7
  TOP w0.114: R414.2 24.08,98.04 23.71,98.4 22.48,98.4 v2(22.25,98.17) 21.81,97.72 U14.16
ILIM_LO: length 2.9
  TOP w0.114: v2(23.52,97.94) 22.77,97.94 22.4,97.57 R415.2 22.02,97.28 21.97,97.22 U14.15
IMONCPU_1: length 39.8
  TOP w0.178: v2(165.48,142.57) 165.22,142.57 v2(164.89,142.9) 164.79,143 PR7059.2
  IN2 w0.178: v2(165.48,142.57) 164.56,142.57 160.95,138.96 160.95,137.69 159.81,136.55 152.32,136.55 149.3,139.57 143.96,139.57 143.24,140.29 143.24,145.63 142.54,146.33 142.54,148.61 142.16,148.99 141.57,148.99 v1(141.45,149.12)
  BOTTOM w0.178: v1(141.45,149.12) 142.04,149.12 PR7060.2
IMVP_PWRGD: length 115.7
  TOP w0.114: v1(104.21,95.22) 103.75,94.76 103.17,94.76 102.99,94.94 102.99,97.38 103.42,97.81 v2(103.42,100.86) 103.42,101.65 103.81,102.03 103.81,105.55 104.06,105.8 104.83,105.8 105.99,106.96 107.74,106.96 108.39,107.61 Q85.2 109.07,108.16 109.27,108.35 109.27,108.99 109.68,109.4 R68466.2
  IN3 w0.102: v2(136.27,141.85) 136.32,141.8 136.32,131.26 137.05,130.53 137.05,124.2 136.42,123.57 136.42,118.01 134.54,116.13 134.54,112.32 130.22,108 130.22,106.07 127.88,103.73 120.77,103.73 117.83,100.78 116.12,100.78 114.4,99.06 111.53,99.06 109.9,97.43 109.42,97.43 106.8,94.81 104.59,94.81 104.21,95.2 v1(104.21,95.22)
  IN4 w0.089: v2(136.27,141.85) 136.27,141.88 136.7,142.31 141.6,142.31 143.94,139.98 151.56,139.98 152.09,139.44 153.94,139.44 154.6,140.1 154.6,140.23 155.37,140.99 155.37,142.97 v1(154.88,143.46)
  BOTTOM w0.203: v1(154.88,143.46) 154.99,143.56 PR7041.1 155.47,143.3 155.62,143.15 PR7040.2
INPUT3VSEL: length 13.8
  BOTTOM w0.079: 101.52,119.69 101.52,119.79 101.9,120.16 101.9,120.55 102.43,121.08 102.43,122.49 U6539.DT49
  BOTTOM w0.102: 101.52,119.69 R68413.1
  BOTTOM w0.114: R68413.1 101.52,118.01 101.26,117.75 101.26,117.01 101.57,116.71 101.57,116.58 102.18,115.97 102.18,115.21 102.31,115.08 v2(102.31,112.32) 101.01,111.02 R68410.2
INT1_GSENSOR_MB: length 11.5
  TOP w0.114: v2(146.6,212.11) 146.6,211.93 146.21,211.54 Q6637.1 145.65,211.54 144.44,212.76 v2(144.19,212.76) R68998.2 143.05,214.53 142.66,214.91 U6515.5
  BOTTOM w0.114: R25641.1 149.77,213.37 149.41,213.01 148.75,213.01 148.62,213.14 147.63,213.14 v2(146.6,212.11)
INT2_GSENSOR1: length 1.1
  TOP w0.114: TP1310.1 143.17,215.41 U6515.6
INT_AMIC-VREFO: length 6.2
  TOP w0.114: C564.1 15.85,27.81 R447.2 16.68,28.22 15.42,29.48 v2(15.42,30.7)
  BOTTOM w0.114: v2(15.42,30.7) 15.73,30.7 16.04,31.01 U20.27
INT_BT_OFF#_L: length 176.5
  IN1 w0.089: v1(121.71,95.78) 122.17,96.24 137.23,96.24 137.46,96.01 143.63,96.01 144.9,94.74 150.9,94.74 151.48,95.32 153.03,95.32 153.64,94.71 200.76,94.71 201.86,93.62 202.48,93.62 203.25,92.86 v2(209.09,92.86)
  IN4 w0.089: 94.71,115.41 94.71,111.22 98.22,107.72 99.89,107.72 103.44,104.17 103.44,103.77 104.05,103.16 104.45,103.16 106.09,101.52 114.09,101.52 115.18,100.43 117.57,100.43 120.12,97.88 121.01,97.88 121.71,97.18 v1(121.71,95.78)
  IN4 w0.102: v1(102.62,126.31) 102.6,126.34 101.6,126.34 99.99,124.73 99.99,121.94 99.44,121.38 99.44,120.14 94.71,115.41
  BOTTOM w0.102: v1(102.62,126.31) 102.34,126.31 U6539.DH49
  BOTTOM w0.114: v2(209.09,92.86) 209.09,94.64 210.61,96.16 210.61,98.96 212.26,100.61 v2(212.26,101.88) 212.26,103.4 211.75,103.91 208.83,103.91 208.3,103.37 205.43,103.37 204.9,103.91 202.23,103.91 201.34,103.02 200.07,103.02 199.69,103.4 199.69,106.32 199.44,106.58 198.93,106.58 197.61,107.9 196.33,107.9 196.1,108.13 R68692.2
INT_BTN_L: length 4.6
  TOP w0.114: v2(205.28,98.04) R67861.1
  BOTTOM w0.114: v2(205.28,98.04) 205.73,98.04 206.17,98.47 206.17,100.17 206.35,100.35 CN52.10
INT_EDP_AUXN: length 112.6
  IN1 w0.089: v1(127.05,151.91) 126.92,151.91 126.74,151.74 126.74,151.6 126.86,151.48 128.87,151.48 129.28,151.08 129.89,151.08 130.25,151.43 130.25,151.66 131.26,152.67 131.26,154.43 130.93,154.76 130.93,163.14 129.46,164.61 124.61,164.61 120.9,168.32 120.9,168.6 119.2,170.3 119.2,173.35 116.99,175.56 115.24,175.56 114.22,176.58 109.27,176.58 108.82,177.03 103.75,177.03 103.21,177.57 100.6,177.57 99,179.17 96.7,179.17 95.04,177.52 89.78,177.52 88.56,176.3 88.56,174.52 88.01,173.96 87.07,173.96 86.86,173.76 71.17,173.76 68.63,176.3 68.63,180.11 65.7,183.03 65.7,187.09 67.1,188.49 67.43,188.49 67.86,188.92 67.86,189.47 67.74,189.6 v2(67.58,189.6)
  BOTTOM w0.102: U6539.AJ1 124.04,152.85 124.58,152.85 124.89,152.55 126.06,152.55 126.32,152.3 126.66,152.3 v1(127.05,151.91)
  BOTTOM w0.114: v2(67.58,189.6) 67.89,189.91 67.89,190.12 67.45,190.55 C556.2
INT_EDP_AUXN_C: length 3
  TOP w0.114: R25271.1 67.13,191.86 v2(67.19,191.92)
  BOTTOM w0.114: C556.1 67.36,191.16 67.53,191.33 67.53,191.58 v2(67.19,191.92) 67.36,192.09 67.36,192.3 67.15,192.51 CN29.22
INT_EDP_AUXP: length 112.6
  IN1 w0.089: v1(126.41,151.91) 126.56,151.76 126.56,151.52 126.78,151.3 128.8,151.3 129.21,150.9 129.97,150.9 130.42,151.36 130.42,151.58 131.44,152.6 131.44,154.5 131.11,154.83 131.11,163.22 129.53,164.79 124.68,164.79 121.08,168.4 121.08,168.68 119.38,170.38 119.38,173.43 117.06,175.74 115.31,175.74 114.29,176.76 109.34,176.76 108.89,177.21 103.82,177.21 103.28,177.75 100.68,177.75 99.08,179.35 96.62,179.35 94.97,177.7 89.71,177.7 88.39,176.37 88.39,174.59 87.93,174.14 86.99,174.14 86.79,173.94 71.24,173.94 68.8,176.37 68.8,180.18 65.88,183.1 65.88,187.02 67.18,188.31 67.51,188.31 68.04,188.85 68.04,189.4 v2(68.24,189.61)
  BOTTOM w0.102: U6539.AJ2 123.6,152.65 124.5,152.65 124.8,152.35 125.98,152.35 v1(126.41,151.91)
  BOTTOM w0.114: v2(68.24,189.61) 68.12,189.73 C557.2
INT_EDP_AUXP_C: length 3
  TOP w0.114: v2(67.85,191.92) 67.94,191.83 R25270.1
  BOTTOM w0.114: CN29.23 67.65,192.47 67.59,192.4 67.59,192.18 v2(67.85,191.92) 67.76,191.83 67.76,191.26 68.02,191 C557.1
INT_EDP_TXN0: length 108.9
  IN1 w0.089: v2(65.32,189.76) 65.7,189.76 65.83,189.64 65.83,189.42 65.83,188.86 65.07,188.11 65.07,187.22 64.51,186.66 64.51,179.53 70.86,173.17 87.17,173.17 87.37,173.38 88.29,173.38 88.67,173.76 89.89,173.76 90.22,174.09 95.48,174.09 96.53,173.03 99.14,173.03 102.56,176.45 105.56,176.45 106.02,175.99 113,175.99 113.48,175.51 114.24,175.51 114.78,174.98 116.63,174.98 118.61,173 118.61,171.67 118.23,171.29 118.23,170.43 119.59,169.08 119.59,168.82 124.94,163.47 129.21,163.47 130.04,162.64 130.04,157.96 129.2,157.12 129.2,154.71 130.04,153.87 130.04,152.75 129.84,152.55 126.79,152.55 126.68,152.66 126.68,152.79 126.94,153.06 v1(127.05,153.06)
  BOTTOM w0.102: U6539.AG1 123.98,153.57 125.36,153.57 125.49,153.69 126.28,153.69 126.54,153.44 126.66,153.44 v1(127.05,153.06)
  BOTTOM w0.114: C553.2 65.55,190.55 65.72,190.38 65.72,189.9 65.58,189.76 v2(65.32,189.76)
INT_EDP_TXN0_C: length 2.1
  BOTTOM w0.114: CN29.19 65.65,192.23 65.73,192.15 65.73,191.18 65.55,191 C553.1
INT_EDP_TXN1: length 105.5
  IN1 w0.089: v1(128.32,153.06) 128.54,153.29 128.54,157.47 129.41,158.34 129.41,161.75 129,162.15 125.45,162.15 118.99,168.6 118.99,168.81 117.6,170.2 117.6,171.55 117.98,171.93 117.98,172.74 116.33,174.39 114.52,174.39 114.02,174.9 113.2,174.9 112.69,175.41 105.71,175.41 105.28,175.84 102.79,175.84 99.41,172.46 96.09,172.46 95.48,173.07 92.58,173.07 92.23,172.72 87.53,172.72 87.39,172.59 70.56,172.59 63.8,179.35 63.8,186.84 64.42,187.46 64.42,188 63.88,188.54 63.88,189.15 v2(63.65,189.38)
  BOTTOM w0.102: U6539.AF2 123.55,154 125.19,154 125.39,154.2 126.54,154.2 127.12,153.62 127.55,153.62 127.56,153.6 127.58,153.6
  BOTTOM w0.114: 127.58,153.6 128.28,153.6 128.44,153.44 128.44,153.18 v1(128.32,153.06) ; v2(63.65,189.38) 63.77,189.51 63.77,189.96 63.93,190.11 63.93,190.27 63.8,190.4 C555.2
INT_EDP_TXN1_C: length 2.2
  BOTTOM w0.114: C555.1 63.9,191 64.08,191.18 64.08,191.63 64.29,191.84 64.29,192.16 64.15,192.3 CN29.16
INT_EDP_TXP0: length 109
  IN1 w0.089: v1(126.41,153.06) 126.5,152.97 126.5,152.59 126.72,152.37 129.91,152.37 130.22,152.68 130.22,153.94 129.38,154.78 129.38,157.04 130.22,157.88 130.22,162.71 129.28,163.65 125.01,163.65 119.77,168.89 119.77,169.15 118.41,170.51 118.41,171.22 118.79,171.6 118.79,173.07 116.71,175.16 114.85,175.16 114.32,175.69 113.56,175.69 113.07,176.17 106.09,176.17 105.63,176.63 102.49,176.63 99.07,173.21 96.6,173.21 95.55,174.27 90.14,174.27 89.81,173.94 88.59,173.94 88.21,173.55 87.29,173.55 87.09,173.35 70.94,173.35 64.69,179.6 64.69,186.59 65.25,187.14 65.25,188.03 66.01,188.79 66,189.07 66,189.55 v1(66.21,189.76)
  BOTTOM w0.102: v1(126.41,153.06) 126.41,153.28 126.2,153.49 125.57,153.49 125.45,153.36 123.77,153.36 123.5,153.63 U6539.AG2
  BOTTOM w0.114: C552.2 66.11,190.55 65.95,190.38 65.95,190.03 v1(66.21,189.76)
INT_EDP_TXP0_C: length 2.2
  BOTTOM w0.114: C552.1 66.11,191 65.96,191.16 65.96,192.12 66.15,192.32 CN29.20
INT_EDP_TXP1: length 105.4
  IN1 w0.089: v2(64.31,189.38) 64.05,189.13 64.05,188.62 64.6,188.07 64.6,187.38 63.98,186.77 63.98,179.42 70.63,172.77 87.32,172.77 87.45,172.9 92.15,172.9 92.5,173.25 95.55,173.25 96.16,172.64 99.34,172.64 102.72,176.02 105.35,176.02 105.79,175.59 112.77,175.59 113.28,175.08 114.09,175.08 114.6,174.57 116.4,174.57 118.16,172.82 118.16,171.85 117.77,171.47 117.77,170.28 119.17,168.88 119.17,168.68 125.52,162.33 129.08,162.33 129.59,161.82 129.59,158.26 128.72,157.4 128.72,153.29 v1(128.95,153.06)
  BOTTOM w0.102: 127.58,153.83 127.56,153.83 127.55,153.82 127.21,153.82 126.62,154.4 125.31,154.4 125.11,154.2 124,154.2 U6539.AF1
  BOTTOM w0.114: C554.2 64.46,190.55 64.16,190.24 64.16,190.01 64,189.86 64,189.68 v2(64.31,189.38) ; v1(128.95,153.06) 128.67,153.34 128.67,153.53 128.37,153.83 127.58,153.83
INT_EDP_TXP1_C: length 2.2
  BOTTOM w0.114: CN29.17 64.65,192.3 64.51,192.16 64.51,191.74 64.31,191.54 64.31,191.16 64.46,191 C554.1
INT_HUB_TO_CPU: length 31.4
  TOP w0.114: R25634.2 131.86,215.41 131.74,215.53 131.74,216.26 131.5,216.5 R25639.2 130.29,216.5 v2(130.27,216.48) 130.27,215.74 130.91,215.11 Q6540.1 130.91,213.2 v2(130.98,213.13) ; v2(150.16,214.53) 150.28,214.64 152.33,214.64 152.47,214.78 152.95,214.78 153.08,214.64 U6516.A4
  IN1 w0.089: v2(130.98,213.13) 131.41,213.56 132.02,213.56 133.09,212.49 135.63,212.49 137,213.86 140.03,213.86 140.33,214.17 148.23,214.17 148.36,214.04 149.8,214.04 150.16,214.4 v2(150.16,214.53)
INT_RF_OFF#_L: length 164.6
  IN1 w0.089: v1(89.07,101.62) 89.45,101.62 89.83,101.24 90.6,101.24 90.98,100.86 94.89,100.86 96.52,102.49 102.79,102.49 103.04,102.74 108.25,102.74 109.3,101.69 117.97,101.69 118.49,102.21 127.86,102.21 128.54,101.52 139.82,101.52 140.08,101.77 142.26,101.77 142.82,101.22 146.76,101.22 147.37,100.61 151.43,100.61 152.14,101.32 154.91,101.32 155.98,100.25 162.45,100.25 162.99,99.72 169.59,99.72 170.12,99.18 178.51,99.18 178.91,98.78 194.66,98.78 195.12,98.32 196.51,98.32 v2(196.9,97.94)
  BOTTOM w0.102: U6539.DC52 100.67,128.73 100.35,128.42 100.17,128.29 98.72,128.29 97.38,126.95 97.25,126.95 96.97,126.67 93.87,126.67 92.07,124.86 91.49,124.86 90.32,123.69 90.22,123.69
  BOTTOM w0.114: v1(89.07,101.62) 88.37,102.32 88.37,102.96 88.21,103.12 88.21,108.07 87.51,108.77 85.45,108.77 84.84,109.38 84.84,110.22 84.7,110.36 84.7,113.64 88.95,117.88 88.95,120.67 89.5,121.23 89.5,123.14 90.06,123.69 90.22,123.69 ; R68693.2 195.24,106.96 195.42,106.78 196.34,106.78 196.51,106.96 197.53,106.96 198.04,106.45 v2(198.04,106.02) 198.04,101.24 197.23,100.43 197.23,98.27 v2(196.9,97.94)
INTRUDER#: length 17.7
  TOP w0.089: 107.74,122.07 107.74,123.21 108.11,123.58 v1(108.11,124.41)
  TOP w0.114: R68401.2 107.26,109.85 106.5,110.61 R68406.1 C96716.1 106.5,112.42 106.81,112.73 107.42,112.73 107.67,112.98 107.67,113.5 v2(107.36,113.81) 107.03,114.14 107.03,115.28 106.37,115.94 106.37,117.32 107.79,118.74 107.79,122.02 107.74,122.07
  BOTTOM w0.102: U6539.DM37 107.98,124.41 v1(108.11,124.41)
IR_WP#_EC: length 251.8
  TOP w0.114: v2(153.06,108.91) 152.83,109.14 U37.2 ; v2(180.21,120.55) 180.21,120.21 v2(180.72,119.71) 180.72,113.13 v1(180.59,113)
  IN1 w0.089: v1(180.59,113) 180.51,112.93 180.51,112.29 179.27,111.05 174.59,111.05 174.37,110.82 173.73,110.82 173.1,111.45 171.01,111.45 169.57,110 168.6,110 168.45,109.85 161.44,109.85 160.78,109.19 154.2,109.19 153.92,108.91 v2(153.06,108.91) ; v2(180.21,120.55) 180,120.34 177.62,120.34 176.86,121.1 168.4,121.1 167.25,122.25 167.25,122.48 165.25,124.48 164,124.48 163.62,124.86 163.62,125.24 162.1,126.77 159.18,126.77 154.99,130.96 154.99,132.18 151.38,135.79 143.17,135.79 140.13,138.83 140.13,140.23 140.51,140.61 140.51,144.52 138.83,146.2 138.83,163.34 137.78,164.4 136.41,164.4 133.83,166.98 125.57,166.98 123.62,168.93 123.24,168.93 121.71,170.46 121.71,173.5 120.44,174.77 120.44,175.87 118.16,178.15 116.45,178.15 115.88,178.72 115.65,178.72 v1(115.62,178.69)
  IN3 w0.102: v2(33.32,195.6) 33.32,194.97 33.83,194.46 38.27,194.46 40.56,192.17 44.5,192.17 48.56,196.24 52.24,196.24 52.5,195.98 61.74,195.98 63.5,197.74 71.57,197.74 72.44,196.87 78.79,196.87 80.41,198.5 83.54,198.5 84.22,197.81 89.28,197.81 90.85,196.24 90.85,192.94 92.76,191.03 93.9,191.03 94.56,190.37 94.56,187.32 94.91,186.97 96.82,186.97 97.3,187.45 105.61,187.45 106.62,186.43 113.1,186.43 113.96,185.57 113.96,185.26 115.79,183.44 115.79,179.35 115.62,179.17 v1(115.62,178.69)
  BOTTOM w0.114: v2(33.32,195.6) 33.32,195.09 33.57,194.84 34.72,194.84 34.97,194.59 CN50.4
IRQ_R: length 76.5
  TOP w0.114: v1(72.66,109.27) 69.97,109.27 67.36,106.65 67.36,104.57 66.49,103.7 66.49,101.9 v2(64.75,100.16) 63.55,98.96 63.55,97.81 63.28,97.55 61.76,97.55 61.26,97.05 60.88,97.05 60.4,96.57 R67557.2 R67555.1 59.45,95.81 59.66,95.6 Q6555.3
  IN3 w0.089: v1(112.66,124.48) 112.29,124.12 112.29,123.61 112.57,123.34
  IN3 w0.102: 112.57,123.34 112.66,123.25 112.66,120.35 111.2,118.89 109.77,118.89 109.14,119.53 108.76,119.53 107.49,120.8 102.66,120.8 101.77,119.91 100.88,119.91 100.3,120.49 92.57,120.49 90.66,118.59 82.47,118.59 80.49,116.61 79.62,116.61 78.58,115.57 78.13,115.57 76.94,114.39 76.94,114.11 76.3,113.46 76.02,113.46 72.66,110.11 v1(72.66,109.27)
  BOTTOM w0.102: v1(112.66,124.48) 112.86,124.48 U6539.DM25
ISEN1N: length 24.3
  IN2 w0.178: v2(157.91,141.91) 157.91,142.24 158.43,142.76 158.43,144.73 158.03,145.13 158.03,147.46 153.4,152.09 151.25,152.09 151.03,152.32 v2(150.64,152.32)
  BOTTOM w0.178: PC7035.1 158.06,140.84 157.78,141.12 PR7038.2 PC7034.1 157.73,142.08 v2(157.91,141.91) 158.13,141.68 PR7039.1 ; PR7012.2 146.73,152.42 147.01,152.14 149.97,152.14 150.14,152.32 v2(150.64,152.32)
ISEN1P: length 25.4
  IN2 w0.178: v2(150.64,151.65) 151.04,151.65 151.18,151.79 153.27,151.79 157.65,147.41 157.65,145.06 158.11,144.6 158.11,142.9 157.4,142.19 157.4,138.83 157.35,138.78 v1(157.35,138.71)
  BOTTOM w0.178: v2(150.64,151.65) 150.1,151.65 149.94,151.81 147.01,151.81 146.73,151.53 PR7011.2 ; v1(157.35,138.71) 157.56,138.92 157.56,140 157.4,140.16 PR7037.2
ISEN1P_1: length 1
  BOTTOM w0.178: PR7036.2 PR7037.1
ISEN2N: length 28.6
  IN1 w0.178: v2(150.48,159.27) 151.06,159.27 151.3,159.03 151.3,152.8 152.32,151.79 153.34,151.79 157.86,147.28 157.86,144.85 160.07,142.64 160.07,141.45 v2(159.79,141.17)
  BOTTOM w0.178: PR7031.2 146.73,160.45 147.21,160.93 147.9,160.93 149.56,159.27 v2(150.48,159.27)
  vias: v2(159.13,140.99)
ISEN2P: length 31.7
  IN1 w0.178: v2(150.49,159.93) 150.94,159.93 151.58,159.28 151.58,153.03 152.45,152.17 153.36,152.17 158.14,147.39 158.14,145.08 160.42,142.8 160.42,140.97 159.88,140.42 159.7,140.42 v2(159.68,140.43)
  BOTTOM w0.178: v2(159.68,140.43) 159.68,140.1 160.11,139.68 PR7045.2 ; PR7030.2 146.73,161.61 147.08,161.26 148.04,161.26 149.37,159.93 v2(150.49,159.93)
ISEN2P_1: length 1
  BOTTOM w0.178: PR7045.1 PR7044.2
ISH_I2C1_SCL: length 183.6
  TOP w0.089: 102.53,129.82 102.83,129.82 102.92,129.73 105.81,129.73 v1(106.18,129.36)
  TOP w0.114: Q6567.6 149.38,215.15 149.17,214.93 v2(149.14,214.93) 149.12,214.93 149.1,214.95 R67875.1 ; 102.53,129.82 99.36,129.82 98.72,129.18 95.93,129.18 94.53,127.78 94.53,127.28 94.15,126.9 93.06,126.9 92.76,127.2 92.76,127.45 92.63,127.58 R68744.1
  IN1 w0.089: v1(86.53,192.94) 86.69,193.09 91.51,193.09 92.93,194.51 101.47,194.51 101.65,194.33 102.53,194.33 102.79,194.59 104.44,194.59 105.15,193.87 105.15,193.27 106.04,192.38 108.71,192.38 109.27,192.94 115.29,192.94 118.03,195.68 118.03,198.27 117.55,198.75 117.55,202.43 118.16,203.04 118.16,205.81 120.31,207.97 120.31,210.08 122.17,211.93 126.64,211.93 128.04,213.33 129.81,213.33 130.88,214.4 132.38,214.4 132.63,214.14 136.04,214.14 136.6,214.7 139.59,214.7 139.92,215.03 149.02,215.03 149.12,214.93 v2(149.14,214.93)
  IN3 w0.102: v2(103.88,174.72) 103.98,174.72 104.36,174.34 104.9,174.34 105.1,174.55 107.01,174.55 110.15,171.4 110.15,167.9 109.39,167.13 109.39,165.38 108,163.98 108,160.17 108.22,159.94 108.22,158.24 107.49,157.5 107.23,157.5 106.6,156.87 106.6,155.67 106.8,155.47 106.8,135.35 106.47,135.02 106.47,129.65 v1(106.18,129.36)
  IN4 w0.089: v2(103.88,174.72) 103.68,174.93 103.68,175.41 104.19,175.92 104.19,179.98 101.14,183.03 101.14,184.43 100.25,185.32 100.25,186.81 94.43,192.63 90.55,192.63 89.3,191.39 87.57,191.39 86.53,192.43 v1(86.53,192.94)
  BOTTOM w0.102: U6539.CY39 106.28,129.36 v1(106.18,129.36)
ISH_I2C1_SDA: length 188.8
  TOP w0.114: v2(148.89,215.57) 148.86,215.54 147.8,215.54 147.65,215.69 R67873.1 147.65,216.46 148.13,216.94 151.43,216.94 151.6,216.77 Q6567.3
  IN1 w0.089: v2(148.89,215.57) 149.25,215.57 149.65,215.16 149.65,214.78 149.38,214.51 148.66,214.51 148.51,214.65 140.08,214.65 139.77,214.35 136.75,214.35 136.19,213.79 132.48,213.79 132.23,214.04 131.02,214.04 129.95,212.98 128.42,212.98 127.02,211.58 122.32,211.58 120.67,209.93 120.67,207.82 118.54,205.69 118.54,202.84 118.03,202.33 118.03,199.03 118.41,198.65 118.41,195.48 115.51,192.58 109.55,192.58 108.99,192.02 105.71,192.02 104.69,193.04 104.69,193.82 104.31,194.21 103.17,194.21 102.92,193.95 101.39,193.95 101.19,194.15 93.21,194.15 91.79,192.73 87.35,192.73 87.04,192.43 86.41,192.43 v1(85.9,192.94)
  IN3 w0.102: v1(102.71,128.47) 104.06,129.82 105.96,129.82 106.09,129.94 106.09,135.18 106.42,135.51 106.42,155.34 106.22,155.55 106.22,156.99 107.17,157.95 107.42,157.95 107.87,158.39 107.87,159.79 107.61,160.04 107.36,160.04 107.11,160.3 107.11,163.73 109.01,165.63 109.01,167.54 109.75,168.27 109.75,171.27 106.83,174.19 105.25,174.19 105.07,174.01 104.19,174.01 104.01,174.19 103.73,174.19 v2(103.2,174.72)
  IN4 w0.089: v2(103.2,174.72) 103.3,174.82 103.3,175.54 103.8,176.04 103.8,179.85 100.76,182.9 100.76,184.26 99.87,185.15 99.87,186.71 94.31,192.27 90.69,192.27 89.45,191.03 87.42,191.03 85.9,192.55 v1(85.9,192.94)
  BOTTOM w0.102: U6539.DB47 103.06,129.05 100.68,129.05 100.55,128.93 100.07,128.93 99.94,128.8 98.66,128.8 97.24,127.39 97.08,127.39 96.77,127.07 95.5,127.07 95.3,127.28 R68745.1
  BOTTOM w0.114: U6539.DB47 102.78,128.47 v1(102.71,128.47)
ISOLATEB: length 10.4
  TOP w0.114: U6521.1 24.09,163.81 24.28,163.62 24.28,162.3 23.89,161.92 R510.2 24.3,161.57 24.43,161.44 26.21,161.44 27.71,159.94 27.71,158.85 v2(27.76,158.8) 27.91,158.65 R9340.1 R509.2
IST_TP_0: length 4.9
  BOTTOM w0.102: U6539.A4 122.28,168.23 122.32,168.27 122.32,169.59 122.12,169.8 TP13266.1
IST_TP_1: length 4.1
  BOTTOM w0.102: TP13265.1 121.13,169.16 121.13,168.63 121.63,168.13 U6539.A6
JTAG_TCK: length 7.4
  BOTTOM w0.114: U8.AE5 123.31,202.25 122.91,202.65 116.65,202.65 TP70.1
JTAG_TDI: length 8.7
  BOTTOM w0.114: U8.AE6 123.98,201.81 120.04,201.81 119.43,201.19 117.77,201.19 117.22,200.63 TP72.1
JTAG_TDO: length 8.9
  BOTTOM w0.114: TP73.1 116.77,203.86 120.57,203.86 121.02,203.4 122.88,203.4 123.11,203.17 123.11,202.97 123.41,202.66 124.04,202.66 U8.AF6
JTAG_TMS: length 9.4
  BOTTOM w0.114: TP71.1 117.29,200.25 119.73,200.25 119.88,200.1 123.73,200.1 124.04,200.4 124.04,201.07 U8.AD6
JTAG_TRST#: length 7.8
  BOTTOM w0.114: U8.AG4 121.9,204.67 118.36,204.67 117.14,205.89 v2(116.45,205.89) R396.1
KB_BL_LED: length 76.3
  TOP w0.114: U37.113 159.46,109.78 158.62,108.94 v2(158.62,108.35)
  IN3 w0.102: v2(158.62,108.35) 160.02,109.75 164.26,109.75 165.02,108.99 165.02,107.72 165.78,106.96 166.77,106.96 167.36,106.37 169.84,106.37 170.3,106.83 172.18,106.83 176.22,110.87 181.25,110.87 181.91,111.53 185.59,111.53 187.12,110 190.67,110 193.59,107.08 201.72,107.08 v2(201.85,107.21)
  BOTTOM w0.114: Q31.2 214.82,117.89 214.55,117.62 v2(214.07,117.62) 213.25,116.8 213.25,111.5 213.15,111.4 213.15,109.37 210.61,106.83 204.13,106.83 203.25,107.72 202.36,107.72 v2(201.85,107.21)
KL_NO_EC: length 216.8
  TOP w0.114: R68769.2 173.28,121.05 172.82,121.05 172.69,120.93 172.69,119.91 172.82,119.78 173.88,119.78 v1(174.37,120.27) 174.47,120.16 174.47,119.71 v2(173.46,118.7) 172.93,118.7 172.21,117.98 172.21,116.68 v1(171.75,116.23)
  IN1 w0.089: v1(171.75,116.23) 171.11,116.23 170.74,115.85 169.62,115.85 169.24,115.47 166.67,115.47 166.29,115.85 166.29,116.74 164.76,118.26 164.76,119.91 164.38,120.29 161.21,120.29 159.81,121.69 157.4,121.69 156.57,122.51 156.57,123.15 155.75,123.97 149.02,123.97 147.75,122.7 141.78,122.7 139.54,124.94 139.54,136.75 138.09,138.2 138.09,142.01 137.79,142.31 136.57,142.31 136.44,142.44 136.44,146.2 133.8,148.84 133.8,154.05 133.4,154.45 132.89,154.45 132.38,154.96 132.38,156.61 133.01,157.25 133.01,162.96 130.63,165.35 125.42,165.35 123.87,166.9 123.36,166.9 122.03,168.23 122.03,168.87 121.58,169.31 121.18,169.31 120.16,170.33 120.16,173.4 118.79,174.77 118.79,176.68 117.93,177.54 115.59,177.54 115.03,178.1 109.88,178.1 109.49,178.49 104.41,178.49 103.83,179.07 101.24,179.07 99.54,180.77 94.81,180.77 94.53,180.49 94.41,180.49 93.39,179.47 86.91,179.47 86.15,180.24 86.15,181.51 81.94,185.72 80.21,185.72 79.8,185.32 79.8,185.06 79.52,184.78 73.55,184.78 73.32,184.55 70.66,184.55 69.9,185.32 69.51,185.32 68.37,184.17 67.95,184.17 67.81,184.31 67.81,185.65 69.13,186.97 69.13,188.74 69.64,189.25 69.64,190.14 69.39,190.4 64.05,190.4 63.55,189.89 62.02,189.89 61.01,188.87 61.01,186.08 61.46,185.62 v2(62.43,185.62)
  IN4 w0.089: v1(170.48,135.79) 171.62,134.64 171.62,129.69 174.42,126.9 174.42,126.26 173.78,125.63 172.64,125.63 172.13,125.12 172.13,123.72 174.37,121.48 v1(174.37,120.27)
  BOTTOM w0.114: PR9271.1 60.88,184.55 60.75,184.68 60.75,185.47 60.96,185.67 62.38,185.67 v2(62.43,185.62) ; PR9269.1 v1(170.48,135.79)
L_SPK+: length 75.9
  IN4 w1.016: 39,94.18 36.81,94.18 34.78,96.21 28.72,96.21 25.83,93.32 25.83,88.92 28.49,86.26 28.49,82.62 28.77,82.34 28.77,80.64 29.47,79.94 29.47,66.4 28.87,65.81 28.87,63.78 28.21,63.12 28.21,57.88 25.95,55.62 25.95,45.06 24.48,43.58 23.11,43.58 19.87,40.34 19.82,40.34
  BOTTOM w0.102: U20.42 19.91,36.75 v2(19.81,36.85)
  vias: v2(19.81,37.51) v2(40.17,93.62) v2(40.61,92.99) v2(40.83,93.64)
L_SPK+_1: length 154.5
  TOP w1.016: 38.18,92.63 38.18,95.56 39.11,96.49 40.51,96.49 42.26,98.24 42.26,100.66
  IN4 w1.016: 81.96,197.38 81.17,198.17 79.79,198.17 77.83,196.21 68.04,196.21 63.8,191.97 62.63,191.97 59.25,188.59 59.25,186.57 57.05,184.38 57.05,177.7 54.99,175.64 45.41,175.64 41.36,171.58 41.36,159.28 41.39,159.25 41.39,159.07 41.56,158.89 41.56,120.66 40.23,119.33 40.23,104.37 41.57,103.03 41.57,102.67
  BOTTOM w1.016: CN63.4 94.58,204.7 94.38,204.9 86.56,204.9 81.96,200.3 81.96,198.52
  vias: v2(41.87,101.72) v2(42.21,101.11) v2(42.53,101.71) v2(81.61,196.52) v2(82.27,196.52)
L_SPK+_1_VIKI:
  vias: v2(40.17,94.8) v2(40.51,95.4) v2(40.83,94.8)
L_SPK-: length 75.9
  IN4 w1.016: 21.64,40.15 23.74,42.26 25.07,42.26 27.27,44.47 27.27,55.06 29.54,57.32 29.54,62.53 30.2,63.19 30.2,64.92 30.81,65.53 30.81,80.51 30.09,81.23 30.09,82.88 29.81,83.16 29.81,86.97 27.15,89.63 27.15,92.76 29.28,94.89 33.95,94.89 36.19,92.66 41.88,92.66 42.34,93.11
  vias: v2(20.87,38.86) v2(20.87,38.12) v2(21.13,39.49) v2(41.49,93.64) v2(43.12,93.62)
L_SPK-_1: length 161.8
  TOP w1.016: 40.91,100.83 40.91,98.8 39.92,97.81 38.53,97.81 36.86,96.14 36.86,92.08 37.96,90.98 40.99,90.98 v2(41.35,91.34)
  IN4 w1.016: 83.28,197.97 81.61,199.64 79.4,199.64 77.29,197.53 67.25,197.53 63.02,193.29 62.08,193.29 57.91,189.12 57.91,187.12 55.67,184.88 55.67,178.25 54.4,176.98 44.87,176.98 40.04,172.15 40.04,158.55 40.24,158.35 40.24,121.37 38.91,120.04 38.91,103.52 39.89,102.53
  BOTTOM w1.016: CN63.3 86.98,203.45 83.48,199.96 83.48,198.52
  vias: v2(40.41,101.74) v2(41.07,101.73) v2(83.08,196.57) v2(83.74,196.57)
L_SPK-_1_VIKI:
  vias: v2(41.49,94.8) v2(43.14,94.8) v2(43.48,95.65)
LAN_DIS#: length 176
  TOP w0.089: 101.15,121.13 104.06,121.13 106.29,123.36 v1(106.29,123.8)
  TOP w0.114: 101.15,121.13 100.83,121.13 100.53,120.82 94.69,120.82 94.28,120.42 93.26,120.42 92.76,119.91 R68927.1 ; v2(30.65,162.58) v2(30.08,163.15) 29.77,163.46 R67504.2 31.16,163.98 31.96,164.78 31.96,165.5 32.09,165.63 Q6619.3
  IN3 w0.089: 110.79,162.84 110.79,159.64
  IN3 w0.102: 110.79,162.84 110.79,163.27 110.71,163.34 110.71,164.54 111.53,165.35 111.53,172.11 107.49,176.15 103.07,176.15 102.18,177.03 102.18,177.98 99.45,180.72 94.76,180.72 93.9,179.85 88.44,179.85 87.68,179.09 84.31,179.09 82.62,177.4 74.13,177.4 73.2,178.33 69.26,178.33 68.75,177.82 66.21,177.82 65.83,178.2 61.64,178.2 61.26,177.82 60.11,177.82 57.93,175.64 56.6,175.64 55.23,174.27 48.69,174.27 45,170.58 45,164.11 43.86,162.96 v2(43.73,162.96) ; 110.79,159.64 110.24,159.09 110.24,157.84 109.77,157.38 109.77,155.22 109.57,155.01 109.57,131.04 109.27,130.73 109.27,128.34 109.01,128.09 108.55,128.09 107.69,127.23 107.69,123.54 107.44,123.29 107.03,123.29 106.52,123.8 v1(106.29,123.8)
  BOTTOM w0.102: v1(106.29,123.8) 105.96,123.47 105.96,123.09 105.65,122.77 U6539.DT41
  BOTTOM w0.114: v2(30.65,162.58) 30.65,163.85 31.29,164.49 31.92,164.49 32.3,164.11 32.3,163.34 32.94,162.71 37.66,162.71 38.38,161.99 42.76,161.99 v2(43.73,162.96)
LAN_JTAG_TCK: length 4
  TOP w0.114: R67512.2 15.56,162.84 TP13161.1 16.14,163.05 16.56,163.47 16.56,164.01 16.76,164.21 U6521.35
LAN_JTAG_TDI: length 3.3
  TOP w0.114: v2(16.26,165.66) 16.3,165.66 16.55,165.41 U6521.32
  BOTTOM w0.114: v2(16.26,165.66) 15.82,165.66 15.62,165.87 TP13158.1 15.65,166.17 R67509.2
LAN_JTAG_TDO: length 2.7
  TOP w0.114: R67510.2 16.09,163.73 TP13159.1 16.09,164.04 16.66,164.61 U6521.34
LAN_JTAG_TMS: length 2.3
  TOP w0.114: U6521.33 16.07,165.01 TP13160.1 15.67,164.61 R67511.2
LAN_WAKE#: length 168.7
  TOP w0.102: v1(106.29,125.02) 105.91,124.64 105.91,123.29 103.96,121.33 100.94,121.33
  TOP w0.114: R36.1 93.01,120.67 93.04,120.7 94.18,120.7 94.58,121.1 100.43,121.1 100.66,121.33 100.94,121.33 ; R67505.2 26.9,162.72 v1(26.51,162.33)
  IN3 w0.089: 110.41,159.53 110.61,159.74 110.61,162.76 110.54,162.84 ; 106.97,127.4 106.84,127.28 106.84,125.56 v1(106.29,125.02)
  IN3 w0.102: v2(43.73,162.2) 45.51,163.98 45.51,167.66 46.02,168.17 50.85,168.17 52.12,169.44 52.12,171.6 54.3,173.78 55.07,173.78 56.7,175.41 58.02,175.41 59.87,177.26 61.64,177.26 62.07,177.7 65.83,177.7 66.35,177.17 82.73,177.17 84.4,178.84 87.93,178.84 88.69,179.6 93.77,179.6 94.03,179.35 94.79,179.35 95.04,179.6 95.55,179.6 95.8,179.85 99.59,179.85 101.52,177.93 101.52,177.06 102.66,175.92 107.36,175.92 111.3,171.98 111.3,165.5 110.28,164.49 110.28,163.09 110.54,162.84 ; 110.41,159.53 110.03,159.53 109.39,158.9 109.39,157.38 108.88,156.87 108.88,155.34 109.34,154.89 109.34,132.43 109.25,132.34 109.25,131.47 108.4,130.62 108.4,128.32 107.49,127.4 106.97,127.4
  BOTTOM w0.102: v1(106.29,125.02) 106.12,125.02 U6539.DM41
  BOTTOM w0.114: v2(43.73,162.2) 43.1,161.57 37.89,161.57 37.13,162.33 33.02,162.33 32.68,162 26.84,162 v1(26.51,162.33)
LAN_XTAL1: length 5.5
  TOP w0.114: Y4.1 32.04,169.38 30.55,169.38 30.27,169.1 30.27,168.54 29.9,168.17 C638.2 29.61,168.52 29.77,168.69 R511.2
LANPWR#: length 221.6
  TOP w0.114: v2(141.45,98.96) 141.45,98.83 142.08,98.19 142.69,98.19 144.09,99.59 144.44,99.59 145.61,100.76 v2(145.94,100.76) 147.11,101.93 147.11,102.08 147.82,102.79 147.82,103.53 148.46,104.16 149.32,104.16 149.42,104.06 150.54,104.06 150.82,103.78 150.82,103.67 150.95,103.54 U37.16 ; v2(34.03,176.38) 33.5,176.38 33.41,176.46 R67508.1
  IN3 w0.102: v2(141.45,98.96) 139.42,96.92 137.49,96.92 136.85,97.56 135.91,97.56 135.05,96.69 125.01,96.69 124.76,96.95 119.48,96.95 118.99,96.47 117.57,96.47 116.33,95.22 114.4,95.22 113.74,95.88 v2(113.74,96.03)
  IN4 w0.089: v2(113.74,96.03) 113.74,94.66 113.51,94.44 97.3,94.44 95.78,95.96 93.19,95.96 92.63,95.4 85.52,95.4 85.39,95.53 85.39,95.78 84.75,96.42 79.6,96.42 76.06,92.88 75.5,92.88 74.09,91.46 50.97,91.46 49.98,92.45 49.98,93.95 48.53,95.4 45.61,95.4 44.98,96.03 38.86,96.03 36.7,98.19 35.86,98.19 33.7,100.35 33.7,103.65 31.9,105.46 31.9,114.86 31.41,115.34 31.41,116.35 29.13,118.64 29.13,119.78 28.37,120.55 28.37,129.56 26.87,131.06 26.87,132.26 28.24,133.63 28.24,149.37 28.76,149.89 28.76,153.7 26.59,155.87 26.59,161.44 31.29,166.14 33.7,166.14 34.46,166.9 34.46,168.17 35.48,169.19 35.48,172.11 34.84,172.74 34.84,175.56 v2(34.03,176.38)
LANWAKEB: length 9
  TOP w0.114: U6521.2 24.24,164.21 v2(24.88,163.57) 24.88,163.16 24.76,163.04 R68925.2 25.07,162.72 25.57,163.22 27.48,163.22 27.73,162.96 R68924.1 28.14,162.43 28.37,162.2 29.68,162.2 Q6618.1
LED0: length 6.4
  TOP w0.114: U6521.26 16.83,167.81 16.62,168.02 16.62,169.37 15.92,170.08 TP13153.1
LED1/EESK: length 5.4
  TOP w0.114: TP13154.1 15.16,170.46 16.35,169.26 16.35,167.89 16.84,167.41 U6521.27
LED2/EEDO: length 2.6
  TOP w0.114: U6521.25 17.39,168.65 16.94,169.11 16.94,169.95 TP13152.1
LID#: length 461.5
  TOP w0.114: R67864.1 140,210.21 v2(140.51,210.72) ; v1(80.56,102.89) 80.56,102.38 80.21,102.03 80.21,101.47 80.79,100.89 v1(80.79,100.48) ; R25315.2 162.58,115.69 162.81,115.92 163.95,115.92 164.45,116.42 164.45,117.91 165.71,119.17 v2(166.27,119.17) ; HE1.1 147.85,212.98 147.75,212.87 147.75,211.35 147.85,211.25 C841.1 147.85,210.21 147.72,210.08 147.37,210.08 147.23,209.94 D13091.2 146.86,209.57 146.63,209.8 v2(146.63,211.3)
  IN1 w0.089: v2(146.63,211.3) 146.45,211.12 144.09,211.12 143.94,210.97 143.76,210.97 143,211.73 141.9,211.73 140.89,210.72 v2(140.51,210.72) 140,210.72 139.62,211.1 128.95,211.1 127.22,209.37 125.09,209.37 124.79,209.67 122.6,209.67 121.56,208.63 121.56,207.26 120.65,206.35 120.65,201.83 119.68,200.86 119.68,200.17 119.93,199.92 119.93,197.38 119.3,196.75 119.3,193.57 117.39,191.67 115.11,191.67 114.09,190.65 112.06,190.65 111.37,191.33 106.78,191.33 106.27,190.83 102.99,190.83 101.57,192.25 100.93,192.25 99.92,193.27 95.25,193.27 93.39,191.41 88.62,191.41 87.22,190.01 84.5,190.01 83.48,191.03 81.78,191.03 81.22,191.59 81.22,191.59 v1(80.98,191.84)
  IN2 w0.102: v2(71.69,100.86) 71.69,101.56 72.64,102.51 78.53,102.51 78.91,102.89 v1(80.56,102.89) 80.56,102.68 80.81,102.43 87.37,102.43 87.65,102.16 88.06,102.16 88.16,102.26 92.12,102.26 92.76,102.89 94.03,102.89 94.28,103.15 101.26,103.15 101.67,102.74 109.24,102.74 109.9,103.4 115.11,103.4 115.36,103.65 123.03,103.65 123.16,103.53 130.14,103.53 131.16,102.51 139.09,102.51 139.47,102.89 146.1,102.89 146.78,102.21 151.32,102.21 152.57,103.45 159.63,103.45 161.87,105.69 167.33,105.69 168.62,106.97 171.94,106.97 176.51,111.54 179.23,111.54 179.88,110.89 180.64,110.89 184.3,107.24 199.72,107.24 204.01,111.53 204.01,113.18 203.17,114.02 203.17,116.66 203.37,116.86 203.37,118.39 v2(202.99,118.77)
  IN3 w0.102: v2(166.27,119.17) 166.27,119.25 167.56,120.55 169.69,120.55 170.58,121.43 176.05,121.43 178.33,119.15 181.58,119.15 182.17,118.56 192.18,118.56 193.22,119.61 202.59,119.61 202.99,119.2 v2(202.99,118.77)
  IN4 w0.089: v1(80.98,191.84) 80.42,191.28 77.65,191.28 76.26,192.68 70.51,192.68 68.86,191.04 63.02,191.04 60.24,188.27 60.24,185.44 59.1,184.3 59.1,177.38 58.4,176.68 57.4,176.68 55.42,174.7 45.79,174.7 42.29,171.2 42.29,159.48 42.5,159.28 42.5,123.05 43.48,122.07 44.62,122.07 44.88,121.82 44.88,105.2 46.3,103.78 46.93,103.78 48.61,102.1 50.36,102.1 52.17,100.3 v2(53.21,100.3)
  BOTTOM w0.114: v2(71.69,100.86) 69.9,100.86 69.61,100.58 56.95,100.58 56.69,100.83 53.74,100.83 v2(53.21,100.3) ; CN4.6 83.74,99.85 83.61,99.72 81.55,99.72 v1(80.79,100.48) ; v1(80.98,191.84) 81.63,192.49 81.63,193.14 82.25,193.76 D3.1 87.07,193.76 87.19,193.63 87.19,191.14 87.43,190.9 88.21,190.9 88.47,190.65 R25370.2
LID#_C: length 8.7
  TOP w0.114: U37.118 157.46,112.22 157.58,112.34 157.58,114.25 158.52,115.19 159.1,115.19 v2(159.46,115.54) 159.61,115.54 160.25,114.9 D65.1 160.87,114.9 161.21,115.24 C6572.1 R25315.1
LID_OPEN_GMR: length 2
  TOP w0.114: R67864.2 139.09,210.21 v2(138.63,210.66) 138.35,210.94 138.35,211.32 138.48,211.45 U6525.4
LINE1-L: length 6.3
  BOTTOM w0.203: U20.22 18.71,28.72 17.93,27.94 17.93,27.56 17.78,27.4
  BOTTOM w0.381: 17.78,27.4 17.22,26.85 v2(17.22,26.49) 16.17,25.44 16.17,25.27 15.6,24.69 C589.1
LINE1-R: length 5.1
  BOTTOM w0.203: 18.03,26.74 18.47,27.19 v2(18.47,27.71) 18.47,27.97 19.11,28.61 U20.21
  BOTTOM w0.381: 18.03,26.74 17.91,26.62 17.91,26.27 17.72,26.08 17.72,25.81 17.07,25.15 C594.1
LINE1-VREFO-L: length 12.8
  IN3 w0.381: v2(16.38,23.12) 15.62,23.88 15.62,25.8 15.21,26.21 15.21,27.28 14.68,27.8 14.68,31.8 15.03,32.15 v2(15.29,32.15)
  BOTTOM w0.203: v2(16.38,23.12) 16.65,22.84 R476.1 ; v2(15.29,32.15) 15.62,32.48 15.92,32.48 16.04,32.61 U20.31
LINE1-VREFO-R: length 13.4
  TOP w0.381: v2(19.13,23.39) 18.88,23.64 v2(18.51,23.64)
  IN3 w0.381: v1(15.5,31.52) 15.5,31.43 16.05,30.88 16.05,27.84 17.12,26.76 17.12,24.43 18.16,23.39 v2(19.13,23.39)
  BOTTOM w0.203: U20.30 16.06,32.21 15.5,31.65 v1(15.5,31.52) ; v2(19.13,23.39) R477.1
LTE_BODY_SAR_ODL: length 56.8
  TOP w0.114: R67886.2 183.79,99.74 183.94,99.59 v2(183.99,99.59)
  IN3 w0.102: v2(183.99,99.59) 184.4,99.18 196.62,99.18 197.78,100.35 197.78,101.5 200.45,104.16 200.83,104.16 202.36,105.69 v2(202.36,106.07)
  BOTTOM w0.114: CN49.14 221.4,121.25 v2(220.62,120.47) 220.4,120.25 217.99,120.25 213.79,116.04 213.79,112.67 215.18,111.27 215.18,108.48 214.17,107.46 212.01,107.46 209.98,105.43 202.99,105.43 v2(202.36,106.07)
LTE_OFF_ODL: length 128.1
  TOP w0.114: v2(147.47,95.4) 147.95,95.88 148.31,95.88 148.92,95.27 150.54,95.27 150.79,95.53 150.79,96.42 150.85,96.47 150.85,97.36 151.03,97.54 U37.31
  IN1 w0.089: v1(196.13,99.59) 196.51,99.21 197.53,99.21 198.04,98.7 201.21,98.7 201.47,98.45 205.28,98.45 206.04,99.21 206.04,100 206.77,100.73 210.48,100.73 211.12,101.37 215.18,101.37 216.07,102.26 219.88,102.26 221.15,103.53 221.15,104.42 225.11,108.37 225.11,110.5 228.93,114.32 231.06,114.32 231.69,114.96 231.69,115.72 234.74,118.77 234.74,122.7 231.57,125.88 226.74,125.88 225.65,124.79 v2(225.19,124.79)
  BOTTOM w0.114: v2(225.19,124.79) 225.19,124.28 224.39,123.48 223.43,123.48 223.2,123.25 CN49.10 ; v1(196.13,99.59) 195.37,98.83 170.98,98.83 168.44,96.29 164.62,96.29 163.78,95.46 154.51,95.46 153.73,96.23 152.66,96.23 151.94,96.95 151.33,96.95 150.79,96.42 150.79,95.91 150.34,95.46 148.73,95.46 148.31,95.88 147.85,95.88 147.47,95.5 v2(147.47,95.4)
M.2_BT_PCMCLK: length 176.3
  TOP w0.114: v1(194.79,99.59) 194.79,100.51 192.83,102.47 192.83,102.77 v2(193.21,103.15) 192.6,103.76 192.6,112.39 191.64,113.36 191.64,117.65 192.02,118.03 192.02,122.45 191.76,122.7 189.81,122.7 189.76,122.65 R69030.2
  IN1 w0.089: v2(202.74,94.13) 202.33,94.54 201.68,94.54 201.09,95.12 154.12,95.12 153.51,95.73 151.23,95.73 150.64,95.15 149.3,95.15 148.41,96.03 147.11,96.03 146.73,95.65 144.83,95.65 144.06,96.42 137.64,96.42 137.41,96.64 121.66,96.64 120.29,95.27 119.96,95.27 v1(119.58,94.89)
  IN4 w0.089: v1(98.41,123.72) 98.41,123.51 98.04,123.14 98.04,122.75 98.22,122.58 98.22,120.67 93.52,115.97 93.52,112.42 92.88,111.78 92.88,110.77 96.69,106.96 96.69,106.19 98.34,104.54 100.05,104.54 105.18,99.41 116.84,99.41 117.65,98.6 117.65,97.18 119.58,95.25 v1(119.58,94.89) ; v1(194.79,99.59) 194.79,98.78 195.37,98.19 195.88,98.19 196.77,97.3 199.05,97.3 201.72,94.64 202.23,94.64 v2(202.74,94.13)
  BOTTOM w0.102: U6539.DL53 99.97,124.61 99.82,124.61 99.69,124.48 99.03,124.48 98.41,123.86 v1(98.41,123.72)
M.2_BT_PCMIN: length 174.3
  TOP w0.114: R69031.2 191.45,121.46 191.74,121.17 191.74,118.13 191.36,117.75 191.36,113.26 192.32,112.29 192.32,103.53 v2(191.94,103.15) 192.45,102.64 192.45,102.38 194.18,100.66 v1(194.18,99.59)
  IN1 w0.089: v1(120.19,94.89) 121.74,96.44 137.33,96.44 137.56,96.21 143.89,96.21 144.7,95.4 146.83,95.4 147.24,95.81 148.36,95.81 149.22,94.94 150.72,94.94 151.3,95.53 153.39,95.53 154,94.92 200.93,94.92 201.72,94.13 v2(201.98,94.13)
  IN4 w0.089: v1(194.18,99.59) 194.18,99.01 196.13,97.05 198.8,97.05 201.44,94.41 201.69,94.41 v2(201.98,94.13) ; v1(99.08,126.13) 99.08,124.96 98.8,124.69 98.8,122.27 98.6,122.07 98.6,120.67 93.77,115.85 93.77,112.29 93.14,111.66 93.14,111.02 98.09,106.07 98.8,106.07 105.25,99.62 116.99,99.62 117.9,98.7 117.9,97.3 119.68,95.53 119.96,95.53 120.19,95.3 v1(120.19,94.89)
  BOTTOM w0.102: U6539.DG50 101.55,127.02 99.36,127.02 99.08,126.74 v1(99.08,126.13)
M.2_UART_BT_WAKE: length 102.1
  TOP w0.114: R69033.1 116.5,112.16 116.2,111.86 v1(116.12,111.86) ; R69032.2 189.38,120.39 v2(188.64,120.39) 188.03,120.39 186.99,121.43 185.34,121.43 184.96,121.05 184.96,117.88 184.63,117.55 184.63,114.42 185.82,113.23 186.94,113.23 187.93,112.24 v1(187.93,112.04)
  IN4 w0.089: v1(187.93,112.04) 187.55,112.42 185.72,112.42 183.81,110.51 183.81,109.37 182.11,107.67 182.11,104.87 179.52,102.28 174.9,102.28 173.15,104.04 171.37,104.04 170.78,103.45 167.64,103.45 166.85,104.24 164.56,104.24 164.13,104.67 163.49,104.67 163.37,104.54 155.87,104.54 155.49,104.16 155.49,103.65 154.76,102.92 148.61,102.92 147.82,103.7 139.16,103.7 138.83,103.37 131.73,103.37 128.44,106.65 127.71,106.65 125.19,109.17 118.49,109.17 116.12,111.53 v1(116.12,111.86)
M_A_A0: length 66.3
  IN4 w0.102: v2(46.15,134.39) 46.15,134.01 46.96,133.2 48.89,133.2 49.83,134.13 53.39,134.13 53.51,134.26 57.45,134.26 57.95,134.76 61.12,134.76 61.72,135.35 68.64,135.35 68.95,135.66 75.59,135.66 76.1,135.15 82.21,135.15 83.13,136.07 96.78,136.07 99.63,138.91 102.49,138.91 102.74,139.16 104.13,139.16 104.82,139.85 105.11,139.85 v1(105.6,140.33)
  BOTTOM w0.102: U6539.BV41 v1(105.6,140.33)
  BOTTOM w0.152: v2(46.15,134.39) 46.15,135.53 45.86,135.82 JDIM1.144
M_A_A1: length 64.6
  IN4 w0.102: v2(49.16,138.79) 49.59,139.21 53.79,139.21 54.32,139.75 55.95,139.75 57.73,141.53 69.01,141.53 69.13,141.65 69.13,141.93 69.26,142.06 69.54,142.06 69.64,141.96 69.64,141.63 69.74,141.53 69.95,141.53 70.05,141.63 70.05,141.96 70.15,142.06 70.35,142.06 70.45,141.96 70.45,141.63 70.56,141.53 70.76,141.53 70.86,141.63 70.86,141.96 70.96,142.06 71.17,142.06 71.27,141.96 71.27,141.63 71.37,141.53 71.57,141.53 71.67,141.63 71.67,141.96 71.78,142.06 72.05,142.06 72.18,141.93 72.18,141.65 72.31,141.53 72.56,141.53 72.69,141.65 72.69,141.91 72.79,142.01 73.2,142.01 73.32,141.88 73.32,141.57 74.18,140.71 74.76,140.14 74.98,140.14 75.1,140.25 75.1,140.48 75.33,140.71 81.1,140.71 81.79,140.02 85.44,140.02 86.68,138.77 v1(87.64,138.77)
  BOTTOM w0.102: U6539.CE52 100.58,136.19 99.69,136.19
  BOTTOM w0.127: 94.86,136.24 99.65,136.24 99.69,136.19
  BOTTOM w0.152: JDIM1.133 51.07,138.57 50.82,138.33 49.58,138.33 49.16,138.74 v2(49.16,138.79) ; v1(87.64,138.77) 87.64,138.37 89.95,136.05 94.67,136.05 94.86,136.24
