# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A1: length 62.1
  IN3 w0.102: v2(61.86,139.12) 61.86,138.29 61.73,138.16 58.59,138.16 58.49,138.06 58.49,137.73 58.63,137.59 61.92,137.59 62.28,137.94 66.09,137.94 66.21,138.07 66.21,140.03 66.42,140.23 68.75,140.23 85.39,156.87 89.71,156.87 90.43,157.59 v1(91.83,157.59)
  BOTTOM w0.089: U6539.AC52 100.59,155.91 99.66,155.91
  BOTTOM w0.102: 95.73,155.91 99.66,155.91
  BOTTOM w0.152: 95.73,155.91 92.73,155.91 91.83,156.8 v1(91.83,157.59) ; JDIM02.133 62.68,138.57 62.33,138.22 62.13,138.22 61.86,138.49 v2(61.86,139.12)
M_B_A2: length 60.9
  IN3 w0.102: v1(102.79,159.67) 97.59,159.67 96.82,158.9 94.53,158.9 94.03,159.41 90.34,159.41 89.2,158.26 84.05,158.26 68.18,142.39 65.7,142.39 65.15,141.84 62.83,141.84 62.15,141.15 62.15,140.61 61.64,140.1 60.98,140.1 v2(59.96,139.08)
  BOTTOM w0.102: v1(102.79,159.67) 102.79,159.06 U6539.U47
  BOTTOM w0.152: JDIM02.132 58.04,138.82 58.18,138.68 58.18,137.94 58.33,137.8 58.54,137.8 58.68,137.93 58.68,138.61 58.79,138.73 59.01,138.73 59.25,138.48 59.25,137.96 59.34,137.87 59.51,137.87 59.83,137.55 60.05,137.55 60.24,137.73 60.24,137.99 59.77,138.45 59.77,138.89 v2(59.96,139.08)
M_B_A3: length 60.4
  IN3 w0.102: v1(92.47,157.59) 93.02,158.14 93.77,158.14 93.9,158.26 93.9,158.54 93.8,158.65 92.63,158.65 91.99,158.01 90.34,158.01 89.58,157.25 85.19,157.25 69.09,141.14 66.49,141.14 65.81,140.46 65.81,138.65 65.68,138.53 65.45,138.53 65.32,138.65 65.32,140.43 65.22,140.53 65.02,140.53 64.92,140.43 64.92,138.6 64.82,138.5 64.49,138.5 64.36,138.63 64.36,139.88 64.23,140.01 64.05,140.01 63.93,139.88 63.93,138.91 63.8,138.79 63.51,138.79 v2(63.18,139.12)
  BOTTOM w0.089: 99.67,156.25 99.8,156.13 100.34,156.13 U6539.AA53
  BOTTOM w0.127: 99.67,156.25 99.56,156.36 95.49,156.36
  BOTTOM w0.152: v2(63.18,139.12) 63.39,139.12 63.55,139.27 63.55,139.48 63.65,139.58 64.02,139.58 64.1,139.5 64.1,139.16 64.19,139.07 JDIM02.131 ; v1(92.47,157.59) 92.47,156.93 93.04,156.36 95.49,156.36
M_B_A4: length 62.1
  IN3 w0.102: v2(58.54,139.11) 59.07,138.58 60.62,138.58 60.75,138.71 60.75,139.21 61.13,139.6 61.74,139.6 62.11,139.96 63.43,139.96 64.41,140.94 65.58,140.94 66.19,141.55 68.92,141.55 79.77,152.4 79.77,152.55 79.7,152.62 79.7,152.76 79.85,152.9 79.99,152.9 80.06,152.83 80.2,152.83 80.35,152.98 80.35,153.12 80.28,153.19 80.28,153.34 80.42,153.48 80.56,153.48 80.63,153.41 80.78,153.41 80.92,153.55 80.92,153.7 80.85,153.77 80.85,153.91 80.99,154.05 81.14,154.05 81.21,153.98 81.35,153.98 81.5,154.13 81.5,154.27 81.43,154.34 81.43,154.49 81.57,154.63 81.71,154.63 81.78,154.56 81.93,154.56 82.07,154.7 82.07,154.85 82,154.92 82,155.06 82.14,155.2 82.29,155.2 82.36,155.13 82.5,155.13 82.65,155.28 82.65,155.42 82.58,155.49 82.58,155.64 82.72,155.78 82.86,155.78 82.93,155.71 83.08,155.71 83.22,155.85 83.22,156 83.15,156.07 83.15,156.21 83.29,156.35 83.44,156.35 83.51,156.28 83.65,156.28 83.8,156.43 83.8,156.57 83.73,156.64 83.73,156.78 83.87,156.93 84.01,156.93 84.08,156.86 84.23,156.86 84.87,157.5 89.45,157.5 90.34,158.39 91.85,158.39 92.48,159.03 93.9,159.03 94.28,158.65 95.58,158.65 95.69,158.53 95.69,158.28 95.55,158.14 94.34,158.14 v1(93.84,157.64)
  BOTTOM w0.089: 99.52,156.74 99.88,156.38 100.19,156.38 100.3,156.49 100.42,156.55 100.9,156.55 U6539.AA51
  BOTTOM w0.102: v1(93.84,157.64) 93.84,157.18 94.28,156.74 99.52,156.74
  BOTTOM w0.152: v2(58.54,139.11) 58.7,139.28 58.7,139.46 58.34,139.82 JDIM02.128
M_B_A5: length 61.8
  IN3 w0.102: v1(96.44,159.92) 96.44,159.89 95.83,159.28 94.53,159.28 94.15,159.66 90.09,159.66 88.95,158.52 83.73,158.52 68.49,143.28 65.96,143.28 64.92,142.24 62.66,142.24 61.39,140.97 v2(61.39,140.61)
  BOTTOM w0.102: v1(96.44,159.92) 96.95,159.41 97.58,159.41 98.12,158.87 100.23,158.87 100.59,158.51 101.18,158.51 U6539.U50
  BOTTOM w0.152: JDIM02.126 58.24,140.32 58.77,139.8 58.93,139.8 59.2,140.07 59.41,140.07 59.82,139.66 60.03,139.66 60.3,139.92 60.56,139.92 60.65,139.83 60.65,137.58 61.26,136.97 61.46,136.97 61.75,137.27 61.75,137.45 61.17,138.04 61.17,139.25 61.46,139.54 61.73,139.54 61.91,139.72 61.91,140.04 61.83,140.11 61.41,140.11 61.3,140.23 61.3,140.52 v2(61.39,140.61)
M_B_A6: length 61.1
  IN3 w0.102: v1(95.42,159.79) 94.79,159.79 94.66,159.92 89.83,159.92 88.69,158.77 83.23,158.77 68.75,144.29 66.34,144.29 64.7,142.65 62.28,142.65 61.85,142.22 59.27,142.22 59.14,142.08 59.14,141.82 59.22,141.74 59.76,141.74 59.87,141.63 59.87,141.38 59.76,141.27 59.42,141.27 59.31,141.15 59.31,140.94 59.39,140.85 59.73,140.85 59.87,140.71 v2(59.87,140.43)
  BOTTOM w0.102: U6539.U52 100.62,158.21 100.29,158.54 98.07,158.54 97.58,159.03 96.95,159.03 96.82,159.15 96.69,159.15
  BOTTOM w0.152: JDIM02.127 63.25,140.07 63.1,139.93 62.57,139.93 62.28,140.23 62.28,140.89 62.02,141.15 61.48,141.15 60.89,141.74 60.69,141.74 60.55,141.6 60.55,141.23 60.88,140.9 60.88,140.7 60.61,140.43 v2(59.87,140.43) ; 96.69,159.15 96.44,159.41 96.18,159.41 95.8,159.79 v1(95.42,159.79)
M_B_A7: length 62.7
  IN3 w0.102: v2(59.46,144.16) 59.46,144.68 59.33,144.8 58.34,144.8 58.21,144.68 58.21,143.66 58.41,143.46 64.24,143.46 65.98,145.21 68.4,145.21 78.02,154.83 78.02,155.46 81.84,159.28 88.18,159.28 89.58,160.68 v1(90.6,160.68)
  BOTTOM w0.089: U6539.W50 101.45,157.93 99.55,157.93
  BOTTOM w0.102: 97.79,157.93 99.55,157.93
  BOTTOM w0.152: JDIM02.122 59.18,141.32 60.62,142.77 60.62,143.28 60.46,143.44 59.9,143.44 59.46,143.88 v2(59.46,144.16) ; v1(90.6,160.68) 90.6,158.9 90.98,158.52 96.44,158.52 96.57,158.39 97.33,158.39 97.79,157.93
M_B_A8: length 60.5
  IN3 w0.102: v2(63.46,140.6) 62.94,141.12 62.94,141.3 63.07,141.43 65.38,141.43 65.91,141.96 68.32,141.96 68.69,142.32 68.83,142.32 68.9,142.25 69.05,142.25 69.19,142.4 69.19,142.54 69.12,142.61 69.12,142.75 69.26,142.9 69.41,142.9 69.48,142.83 69.62,142.83 69.77,142.97 69.77,143.12 69.7,143.19 69.7,143.33 69.84,143.47 69.98,143.47 70.05,143.4 70.2,143.4 70.34,143.55 70.34,143.69 70.27,143.76 70.27,143.9 70.41,144.05 70.56,144.05 70.63,143.98 70.77,143.98 70.92,144.12 70.92,144.27 70.85,144.34 70.85,144.48 70.99,144.62 71.13,144.62 71.2,144.55 71.35,144.55 71.49,144.7 71.49,144.84 71.42,144.91 71.42,145.05 71.56,145.2 71.71,145.2 71.78,145.13 71.92,145.13 72.07,145.27 72.07,145.42 72,145.49 72,145.63 72.14,145.77 72.28,145.77 72.35,145.7 72.5,145.7 72.64,145.85 72.64,145.99 72.57,146.06 72.57,146.2 72.71,146.35 72.86,146.35 72.93,146.28 73.07,146.28 73.22,146.42 73.22,146.57 73.15,146.64 73.15,146.78 73.29,146.92 73.43,146.92 73.5,146.85 73.65,146.85 73.79,147 73.79,147.14 73.72,147.21 73.72,147.36 73.86,147.5 74.01,147.5 74.08,147.43 74.22,147.43 74.37,147.57 74.37,147.72 74.3,147.79 74.3,147.93 74.44,148.07 74.58,148.07 74.65,148 74.8,148 74.94,148.15 74.94,148.29 74.87,148.36 74.87,148.51 75.01,148.65 75.16,148.65 75.23,148.58 75.37,148.58 75.52,148.72 75.52,148.87 75.45,148.94 75.45,149.08 75.59,149.22 75.73,149.22 75.8,149.15 75.95,149.15 76.09,149.3 76.09,149.44 76.02,149.51 76.02,149.66 76.16,149.8 76.31,149.8 76.38,149.73 76.52,149.73 76.67,149.87 76.67,150.02 76.6,150.09 76.6,150.23 76.74,150.37 76.88,150.37 76.95,150.3 77.1,150.3 77.24,150.45 77.24,150.59 77.17,150.66 77.17,150.81 77.31,150.95 77.46,150.95 77.53,150.88 77.67,150.88 77.82,151.02 77.82,151.17 77.75,151.24 77.75,151.38 77.89,151.52 78.03,151.52 78.1,151.45 78.25,151.45 78.39,151.6 78.39,151.74 78.32,151.81 78.32,151.96 78.46,152.1 78.61,152.1 78.68,152.03 78.82,152.03 79.11,152.32 79.11,152.46 79.04,152.53 79.04,152.67 84.25,157.88 89.3,157.88 90.44,159.03 v1(91.23,159.03)
  BOTTOM w0.102: 96.63,158.77 97.46,158.77 98.02,158.21 U6539.U53
  BOTTOM w0.152: v1(91.23,159.03) 91.23,159.15 91.61,159.53 93.52,159.53 94.03,159.03 96.38,159.03 96.63,158.77 ; v2(63.46,140.6) 63.46,141.06 63.15,141.38 62.52,141.38 61.76,142.13 61.76,142.34 61.98,142.55 62.18,142.55 62.83,141.9 63.34,141.9 64.1,141.13 64.1,140.72 64.25,140.57 JDIM02.125
M_B_A9: length 59.7
  IN3 w0.102: v2(60.87,143.92) 59.83,144.95 59.83,145.13 60.01,145.31 60.24,145.31 60.88,144.68 64.16,144.68 66.31,146.83 68.87,146.83 71.4,149.36 71.4,149.5 71.1,149.8 71.1,149.94 71.24,150.09 71.39,150.09 71.68,149.79 71.83,149.79 71.97,149.93 71.97,150.08 71.67,150.37 71.67,150.52 71.82,150.66 71.96,150.66 72.26,150.36 72.4,150.36 72.69,150.65 72.69,151.28 81.2,159.79 87.68,159.79 89.33,161.44 91.36,161.44 91.99,160.8 94.03,160.8 v1(94.28,161.06)
  BOTTOM w0.102: 95.27,160.3 97.24,160.3 98.34,159.19 101.2,159.19 U6539.P50
  BOTTOM w0.152: v1(94.28,161.06) 94.28,160.93 94.91,160.3 95.27,160.3 ; v2(60.87,143.92) 61.9,142.88 62.55,142.88 63.12,142.31 63.41,142.31 64.15,141.57 JDIM02.121
M_B_A10: length 62
  IN3 w0.102: v1(104.95,158.63) 103.94,157.63 101.01,157.63 100.76,157.88 99.11,157.88 97.33,156.11 92.37,156.11 91.49,155.22 87.17,155.22 70.02,138.07 70.02,136.23 68.51,134.72 61.78,134.72 61.43,134.36 59.58,134.36 59.45,134.24 59.45,134.02 59.61,133.86 v2(60.32,133.86)
  BOTTOM w0.102: U6539.U42 105.16,158.42 v1(104.95,158.63)
  BOTTOM w0.152: v2(60.32,133.86) 60.3,133.88 58.85,133.88 58.29,133.32 JDIM02.146
M_B_A11: length 58.3
  IN3 w0.102: v2(59.85,142.89) 60.02,143.06 64.43,143.06 66.18,144.8 68.63,144.8 78.63,154.8 78.63,154.95 78.42,155.15 78.42,155.29 78.57,155.43 78.71,155.43 78.91,155.23 79.06,155.23 79.2,155.38 79.2,155.52 79,155.72 79,155.86 79.14,156.01 79.29,156.01 79.49,155.81 79.63,155.81 79.78,155.95 79.78,156.09 79.57,156.3 79.57,156.44 79.72,156.58 79.86,156.58 80.06,156.38 80.21,156.38 80.35,156.53 80.35,156.67 80.15,156.87 80.15,157.01 80.29,157.16 80.44,157.16 80.64,156.96 80.78,156.96 80.92,157.1 80.92,157.24 80.72,157.44 80.72,157.59 80.87,157.73 81.01,157.73 81.21,157.53 81.36,157.53 81.5,157.68 81.5,157.82 81.3,158.02 81.3,158.16 81.44,158.31 81.59,158.31 81.79,158.11 81.93,158.11 82.07,158.25 82.07,158.39 81.87,158.59 81.87,158.74 82.02,158.88 82.16,158.88 82.36,158.68 82.51,158.68 82.85,159.03 88.44,159.03 89.58,160.17 95.93,160.17 v2(96.82,161.06)
  BOTTOM w0.102: v2(96.82,161.06) 96.87,161.06 97.38,161.57 99.09,161.57 99.74,160.92 99.74,160.74 100.07,160.41 100.69,160.41 101.05,160.05 U6539.N51
  BOTTOM w0.152: JDIM02.120 58.37,141.82 58.47,141.92 58.47,142.22 58.58,142.33 59.42,142.33 59.85,142.76 v2(59.85,142.89)
M_B_A12: length 57.9
  IN3 w0.102: v2(62.19,143.91) 64,143.91 66.52,146.43 69.04,146.43 73.29,150.68 73.29,150.82 73.15,150.96 73.15,151.1 73.29,151.25 73.44,151.25 73.58,151.11 73.72,151.11 74.01,151.39 74.01,151.54 73.84,151.71 73.84,151.85 73.98,152 74.12,152 74.3,151.83 74.44,151.83 74.58,151.97 74.58,152.11 74.41,152.28 74.41,152.43 74.56,152.57 74.7,152.57 74.87,152.4 75.01,152.4 75.16,152.54 75.16,152.69 74.99,152.86 74.99,153 75.13,153.15 75.27,153.15 75.44,152.97 75.59,152.97 75.73,153.12 75.73,153.26 75.56,153.43 75.56,153.58 75.71,153.72 75.85,153.72 76.02,153.55 76.16,153.55 76.31,153.69 76.31,153.84 76.14,154.01 76.14,154.15 76.28,154.29 76.42,154.29 76.59,154.12 76.74,154.12 76.88,154.27 76.88,154.41 76.71,154.58 76.71,154.73 76.86,154.87 77,154.87 77.17,154.7 77.31,154.7 77.46,154.84 77.46,154.99 77.29,155.16 77.29,155.3 81.52,159.53 87.93,159.53 89.58,161.19 91.26,161.19 91.89,160.55 95.68,160.55 96.69,161.57 97.71,161.57 98.06,161.21 98.06,160.27 v2(97.96,160.17)
  BOTTOM w0.102: U6539.P53 100.16,159.51 98.5,159.51 97.96,160.04 v2(97.96,160.17)
  BOTTOM w0.152: v2(62.19,143.91) 61.91,143.63 61.91,143.42 62.09,143.23 62.42,143.23 62.67,143.48 62.87,143.48 63.1,143.26 63.1,142.95 63.3,142.75 63.55,142.75 63.74,142.94 63.88,142.94 64.12,142.71 64.12,142.2 64.24,142.07 JDIM02.119
M_B_A13: length 62.8
  IN3 w0.102: v2(59.93,131.09) 59.93,131.37 60.16,131.6 60.92,131.6 64.44,131.6 65.13,132.29 69.45,132.29 72.56,135.4 72.56,137.18 80.79,145.41 80.94,145.41 81.17,145.18 81.32,145.18 81.46,145.32 81.46,145.47 81.23,145.7 81.23,145.84 81.37,145.99 81.51,145.99 81.75,145.75 81.89,145.75 82.03,145.9 82.03,146.04 81.8,146.28 81.8,146.42 82.09,146.71 82.84,146.71 89.19,153.06 96.69,153.06 99.18,155.55 100.61,155.55 100.94,155.88 103.01,155.88 103.33,155.56 105.02,155.56 105.6,154.99 v1(105.6,154.97)
  BOTTOM w0.102: v1(105.6,154.97) U6539.AE41
  BOTTOM w0.152: v2(59.93,131.09) 59.17,130.32 JDIM02.158
M_B_ACT#: length 57.9
  IN3 w0.102: v2(59.87,147.12) 59.87,147.99 60.11,148.23 62.78,148.23 62.98,148.03 62.98,146.89 63.14,146.73 64.34,146.73 66.3,148.7 68.08,148.7 77.26,157.88 77.26,158.02 77.15,158.13 77.15,158.27 77.29,158.42 77.44,158.42 77.54,158.31 77.69,158.31 77.83,158.45 77.83,158.6 77.73,158.7 77.73,158.85 77.87,158.99 78.01,158.99 78.12,158.88 78.26,158.88 78.41,159.03 78.41,159.17 78.3,159.28 78.3,159.42 78.44,159.57 78.59,159.57 78.69,159.46 78.84,159.46 78.98,159.6 78.98,159.75 78.88,159.85 78.88,160 79.02,160.14 79.16,160.14 79.27,160.03 79.41,160.03 79.93,160.55 87.04,160.55 88.82,162.33 95.17,162.33 95.61,161.88 97.9,161.88 98.47,161.31 v1(98.47,161.06)
  BOTTOM w0.102: v1(98.47,161.06) 99.11,161.06 99.7,160.47 99.7,160.34 99.95,160.08 100.47,160.08 U6539.N53
  BOTTOM w0.152: JDIM02.114 58.16,143.32 58.43,143.6 58.43,144.01 59.45,145.02 59.45,146.7 v2(59.87,147.12)
M_B_ALERT#: length 65.8
  IN3 w0.102: v2(58.43,142.82) 57.96,142.35 57.96,137.69 58.47,137.18 62.15,137.18 62.4,137.44 67.36,137.44 68.12,138.2 68.12,138.96 85.65,156.49 89.96,156.49 v1(90.47,156.99)
  BOTTOM w0.079: 99.13,149.21 U6539.AU53
  BOTTOM w0.102: 99.13,149.21 96.66,149.21 96.26,148.82 92.04,148.82 91.61,149.25 91.61,149.5
  BOTTOM w0.152: v1(90.47,156.99) 90.47,155.22 89.68,154.43 89.68,151.43 91.61,149.5 ; v2(58.43,142.82) JDIM02.116
M_B_BG#0: length 56.8
  IN3 w0.102: v2(62.51,147.14) 61.82,146.45 61.39,146.45 61.26,146.33 61.26,145.82 61.49,145.59 62.56,145.59 63.29,146.33 64.56,146.33 66.47,148.23 68.88,148.23 69.43,148.78 69.43,148.92 69.22,149.13 69.22,149.27 69.37,149.41 69.51,149.41 69.72,149.21 69.86,149.21 70.15,149.5 70.15,150.14 80.3,160.3 87.29,160.3 88.95,161.95 91.61,161.95 92.25,161.31 93.01,161.31 93.39,161.69 v1(93.39,161.82)
  BOTTOM w0.102: 95.27,161.82 96.87,161.82 97.12,162.07 99.55,162.07 99.94,161.69 100.5,161.69 U6539.J52
  BOTTOM w0.152: JDIM02.115 64.24,143.07 63.67,143.64 63.2,143.64 62.51,144.34 v2(62.51,147.14) ; v1(93.39,161.82) 95.27,161.82
M_B_BG#1: length 59.6
  IN3 w0.102: v1(95.55,161.06) 95.04,161.57 94.03,161.57 93.52,161.06 92.12,161.06 91.49,161.69 89.07,161.69 87.42,160.04 80.62,160.04 70.66,150.08 70.66,149.25 68.65,147.24 66.11,147.24 64.7,145.83 63.69,145.83 63.04,145.18 61.13,145.18 60.75,145.56 60.75,146.7 v2(61.19,147.14)
  BOTTOM w0.102: v1(95.55,161.06) 96.02,161.52 96.96,161.52 97.25,161.82 99.44,161.82 100.23,161.03 101.37,161.03 101.67,161.33 U6539.K50
  BOTTOM w0.152: JDIM02.113 64.31,143.57 63.84,144.04 63.42,144.04 62.96,144.5 62.96,147.42 62.66,147.72 61.77,147.72 v2(61.19,147.14)
M_B_BS#0: length 61
  IN3 w0.102: v1(104.28,158.63) 103.53,157.88 101.27,157.88 100.97,158.18 99.02,158.18 97.2,156.36 91.87,156.36 90.98,155.47 86.73,155.47 69.51,138.26 69.51,136.29 68.35,135.12 61.62,135.12 61.26,134.77 59.23,134.77 59.04,134.59 v2(59.04,133.45)
  BOTTOM w0.102: v1(104.28,158.63) 104.51,158.4 U6539.U44
  BOTTOM w0.152: v2(59.04,133.45) 59.04,132.81 58.56,132.32 JDIM02.150
M_B_BS#1: length 63.2
  IN3 w0.102: v1(104.95,156.8) 104.37,157.38 100.76,157.38 100.25,156.87 98.6,156.87 97.45,155.72 92.5,155.72 91.74,154.96 87.55,154.96 87.15,154.56 87.15,154.42 87.45,154.12 87.45,153.98 87.31,153.83 87.16,153.83 86.86,154.13 86.72,154.13 86.53,153.95 86.53,153.76 86.77,153.52 86.77,153.34 86.65,153.21 86.5,153.21 86.22,153.49 86.08,153.49 70.53,137.94 70.53,136.04 68.8,134.31 68.04,134.31 67.94,134.21 67.94,134.02 67.84,133.92 67.64,133.92 67.54,134.02 67.54,134.21 67.43,134.31 67.23,134.31 67.13,134.21 67.13,134.02 67.03,133.92 66.82,133.92 66.72,134.02 66.72,134.21 66.62,134.31 66.42,134.31 66.32,134.21 66.32,134.02 66.21,133.92 66.01,133.92 65.91,134.02 65.91,134.21 65.81,134.31 65.61,134.31 65.5,134.21 65.5,134.02 65.4,133.92 65.2,133.92 65.1,134.02 65.1,134.21 65,134.31 64.79,134.31 64.69,134.21 64.69,134.02 64.59,133.92 64.39,133.92 64.28,134.02 64.28,134.21 64.18,134.31 63.73,134.31 63.6,134.18 v2(63.6,133.84)
  BOTTOM w0.102: v1(104.95,156.8) 105.16,156.59 U6539.AA42
  BOTTOM w0.152: v2(63.6,133.84) 63.6,134.41 63.73,134.54 66.23,134.54 66.41,134.36 66.41,133.7 66.28,133.57 JDIM02.145
M_B_CAS#: length 62
  IN3 w0.102: v1(104.29,156.8) 103.85,156.36 103.38,156.36 103.15,156.12 100.8,156.12 100.6,155.93 99.06,155.93 97.73,154.6 93.15,154.6 92.5,153.95 89.51,153.95 82.78,147.22 81.96,147.22 72.05,137.31 72.05,135.53 69.22,132.69 64.9,132.69 64.23,132.03 60.7,132.03 60.28,132.44 59.99,132.44 59.86,132.32 59.86,132.1 59.74,131.98 59.35,131.98 59.23,132.1 59.23,132.74 59.1,132.86 58.85,132.86 58.72,132.74 58.72,131.2 v2(58.61,131.09)
  BOTTOM w0.102: v1(104.29,156.8) 104.51,156.59 U6539.AA44
  BOTTOM w0.152: v2(58.61,131.09) 58.35,130.82 JDIM02.156
M_B_CB0: length 2.1
  TOP w0.114: v2(58.41,149.03) 58.4,149.02 R25602.2
  BOTTOM w0.114: JDIM02.92 58.2,148.82 v2(58.41,149.03)
M_B_CB1: length 2.1
  TOP w0.114: v2(66.72,149.15) 66.7,149.12 R25603.2
  BOTTOM w0.114: JDIM02.91 66.65,149.07 v2(66.72,149.15)
M_B_CB2: length 2.5
  TOP w0.114: v2(66.66,145.89) 66.61,145.89 66.56,145.95 R25604.2
  BOTTOM w0.152: JDIM02.101 66.28,146.57 66.66,146.2 v2(66.66,145.89)
M_B_CB3: length 3.8
  TOP w0.114: R25605.2 68.24,145.72 v2(68.02,145.95)
  BOTTOM w0.152: JDIM02.105 66.28,145.57 66.46,145.39 67.49,145.39 68.02,145.92 v2(68.02,145.95)
M_B_CB4: length 3.5
  TOP w0.114: v2(59.11,149) 59.78,149 59.79,149.02 R25606.2
  BOTTOM w0.114: v2(59.11,149) 58.29,149.82 JDIM02.88
M_B_CB5: length 2.5
  TOP w0.114: v2(66.72,150.8) 66.7,150.77 R25608.2
  BOTTOM w0.114: v2(66.72,150.8) 66.72,150.52 66.28,150.07 JDIM02.87
M_B_CB6: length 3.2
  TOP w0.114: R25609.2 54.81,147.31 v2(54.91,147.22)
  BOTTOM w0.114: JDIM02.100 56.18,146.82 56.04,146.96 55.16,146.96 v2(54.91,147.22)
M_B_CB7: length 2.3
  TOP w0.114: v2(55.7,146.15) 55.75,146.2 R25610.2
  BOTTOM w0.114: JDIM02.104 55.93,145.82 55.8,145.95 55.8,146.02 55.7,146.12 v2(55.7,146.15)
M_B_CKE0: length 56.9
  IN3 w0.102: v2(64.05,147.22) 66.58,149.76 68.56,149.76 71.76,152.96 71.76,153.1 71.49,153.37 71.49,153.51 71.64,153.65 71.78,153.65 72.05,153.39 72.19,153.39 72.33,153.53 72.33,153.67 72.07,153.94 72.07,154.08 72.21,154.23 72.35,154.23 72.62,153.96 72.77,153.96 72.91,154.11 72.91,154.25 72.64,154.52 72.64,154.66 72.79,154.8 72.93,154.8 73.2,154.54 73.34,154.54 73.48,154.68 73.48,154.82 73.22,155.09 73.22,155.23 73.36,155.38 73.5,155.38 73.77,155.11 73.92,155.11 74.06,155.26 74.06,155.4 73.79,155.67 73.79,155.81 73.94,155.95 74.08,155.95 74.35,155.69 74.49,155.69 74.63,155.83 74.63,155.97 74.37,156.24 74.37,156.39 74.51,156.53 74.65,156.53 74.92,156.26 75.07,156.26 75.21,156.41 75.21,156.55 74.94,156.82 74.94,156.96 75.09,157.1 75.23,157.1 75.5,156.84 75.64,156.84 75.78,156.98 75.78,157.12 75.52,157.39 75.52,157.54 75.66,157.68 75.81,157.68 76.07,157.41 76.22,157.41 76.56,157.76 76.56,157.9 76.45,158.01 76.45,158.15 79.11,160.8 86.79,160.8 88.56,162.58 95.68,162.58 v2(95.93,162.33)
  BOTTOM w0.102: U6539.J50 101.22,162.31 99.72,162.31 99.57,162.46 97.45,162.46 97.07,162.84 96.44,162.84 v2(95.93,162.33)
  BOTTOM w0.152: v2(64.05,147.22) 63.4,146.58 63.4,144.93 63.75,144.57 JDIM02.109
M_B_CKE1: length 59
  IN3 w0.102: v2(58.43,147.12) 59.98,148.68 64.88,148.68 66.37,150.16 68.39,150.16 69.45,151.22 69.45,151.36 69.15,151.66 69.15,151.8 69.29,151.95 69.44,151.95 69.74,151.65 69.88,151.65 70.02,151.79 70.02,151.94 69.73,152.23 69.73,152.38 69.87,152.52 70.01,152.52 70.31,152.22 70.45,152.22 70.6,152.37 70.6,152.51 70.3,152.81 70.3,152.95 70.44,153.1 70.59,153.1 70.88,152.8 71.03,152.8 71.17,152.94 71.17,153.09 70.87,153.38 70.87,153.53 78.53,161.19 86.66,161.19 88.31,162.84 97.59,162.84 99.23,161.2 v2(99.23,160.17)
  BOTTOM w0.102: U6539.P52 100.68,159.48 100.38,159.79 99.61,159.79 v2(99.23,160.17)
  BOTTOM w0.152: JDIM02.110 57.98,144.32 58.94,145.28 58.94,146.62 v2(58.43,147.12)
M_B_CLKN0: length 60.3
  IN1 w0.089: v2(63.19,136.24) 63.17,136.22 62.49,136.22 62.27,136.44 62.27,136.67 65.58,139.98 65.58,140.61 66.67,141.7 70.73,141.7 81.48,152.45 81.48,152.78 80.83,153.43 80.83,153.84 80.96,153.97 81.27,153.97 81.9,153.34 82.17,153.34 82.62,153.8 82.62,154.12 82,154.75 82,155.1 82.13,155.22 82.4,155.22 83.17,154.46 83.49,154.46 83.95,154.92 83.95,155.19 83.29,155.85 83.29,156.03 83.48,156.23 95.42,156.23 96.11,156.92 96.11,157.55 v1(96.31,157.76)
  BOTTOM w0.079: U6539.Y53 99.93,156.93 99.69,157.18 99.19,157.18 99.15,157.21 99.13,157.21
  BOTTOM w0.114: 99.13,157.21 96.16,157.21 96.05,157.33 96.05,157.49 v1(96.31,157.76) ; v2(63.19,136.24) 62.71,136.24 62.35,136.6 62.35,136.93 62.76,137.34 64.15,137.34 64.42,137.07 JDIM02.139
M_B_CLKN1: length 62.2
  IN1 w0.089: v2(58.65,136.62) 59.2,137.16 59.2,137.42 59.44,137.66 60.52,137.66 61.26,136.93 61.26,136.04 61.68,135.62 64.9,135.62 66.77,137.49 67.53,137.49 85.64,155.6 99.74,155.6 103.33,159.18 104.92,159.18 105,159.26 105,159.44 v1(104.88,159.56)
  BOTTOM w0.102: v1(104.88,159.56) 105.16,159.28 U6539.R42
  BOTTOM w0.114: JDIM02.140 58.09,136.82 58.56,137.29 58.92,137.29 59.19,137.02 59.19,136.8 59.01,136.62 v2(58.65,136.62)
M_B_CLKP0: length 60.4
  IN1 w0.089: v2(61.91,136.24) 62.1,136.42 62.1,136.75 65.4,140.05 65.4,140.68 66.6,141.88 70.66,141.88 81.3,152.52 81.3,152.7 80.65,153.35 80.65,153.92 80.88,154.15 81.34,154.15 81.97,153.52 82.1,153.52 82.45,153.87 82.45,154.05 81.82,154.68 81.82,155.17 82.05,155.4 82.48,155.4 83.24,154.64 83.42,154.64 83.77,154.99 83.77,155.12 83.11,155.78 83.11,156.11 83.41,156.41 95.35,156.41 95.93,156.99 95.93,157.47 v1(95.65,157.75)
  BOTTOM w0.079: U6539.Y52 100.45,156.74 100.25,156.69 100.22,156.69 99.95,156.69 99.62,157.02 99.19,157.02 99.15,156.98 99.13,156.98
  BOTTOM w0.114: v2(61.91,136.24) 62.12,136.44 62.12,137.03 62.67,137.57 JDIM02.137 ; 99.13,156.98 96.07,156.98 95.82,157.24 95.82,157.58 v1(95.65,157.75)
M_B_CLKP1: length 62.4
  IN1 w0.089: v1(105.54,159.55) 105.34,159.35 104.99,159.01 103.4,159.01 99.82,155.42 85.72,155.42 67.61,137.31 66.85,137.31 64.98,135.44 61.61,135.44 61.08,135.97 61.08,136.85 60.45,137.49 59.52,137.49 59.37,137.34 59.37,137.16 v2(59.92,136.62)
  BOTTOM w0.102: v1(105.54,159.55) 105.54,159.55 105.54,159.37 U6539.R41
  BOTTOM w0.114: JDIM02.138 58.27,137.32 58.46,137.52 59.02,137.52 v2(59.92,136.62)
M_B_CS#0: length 62.5
  IN3 w0.102: v2(61.93,131.11) 60.6,131.11 60.48,130.98 60.48,130.76 60.58,130.65 69.08,130.65 73.48,135.05 73.48,136.89 76.4,139.81 76.54,139.81 76.73,139.62 76.91,139.62 77.08,139.79 77.08,139.93 76.87,140.14 76.87,140.28 77.02,140.43 77.16,140.43 77.36,140.22 77.51,140.22 88.82,151.53 93.26,151.53 94.28,152.55 97.2,152.55 99.57,154.92 100.86,154.92 101.35,155.4 102.55,155.4 v1(102.94,155)
  BOTTOM w0.102: v1(102.94,155) 103.21,154.74 U6539.AE47
  BOTTOM w0.152: JDIM02.149 64.19,132.57 63.8,132.97 62.3,132.97 61.85,132.52 61.85,131.19 v2(61.93,131.11)
M_B_CS#1: length 62.8
  IN3 w0.102: v2(63.63,131.11) 63.66,131.08 65.13,131.08 65.26,131.21 65.26,131.73 65.41,131.88 65.65,131.88 65.78,131.75 65.78,131.19 65.9,131.06 66.13,131.06 66.23,131.16 66.23,131.72 66.39,131.88 68.36,131.88 68.47,131.78 68.47,131.22 68.57,131.12 68.77,131.12 68.87,131.22 68.87,131.78 68.97,131.88 69.68,131.88 73.07,135.28 73.07,137.06 77.16,141.14 77.3,141.14 77.51,140.94 77.65,140.94 77.79,141.08 77.79,141.23 77.59,141.43 77.59,141.58 77.73,141.72 77.88,141.72 78.08,141.52 78.23,141.52 78.37,141.66 78.37,141.8 78.17,142.01 78.17,142.15 78.31,142.29 78.45,142.29 78.66,142.09 78.8,142.09 78.94,142.23 78.94,142.38 78.74,142.58 78.74,142.72 78.88,142.87 79.03,142.87 79.23,142.66 79.38,142.66 79.52,142.81 79.52,142.95 79.32,143.16 79.32,143.3 79.46,143.44 79.6,143.44 79.81,143.24 79.95,143.24 80.09,143.38 80.09,143.53 79.89,143.73 79.89,143.87 80.03,144.02 80.18,144.02 80.38,143.81 80.53,143.81 80.67,143.96 80.67,144.1 80.47,144.31 80.47,144.45 80.75,144.74 80.9,144.74 81.1,144.53 81.25,144.53 88.73,152.02 93.37,152.02 94.15,152.8 96.95,152.8 99.39,155.24 100.75,155.24 101.13,155.63 102.86,155.63 103.14,155.36 104.56,155.36 v1(104.95,154.97)
  BOTTOM w0.102: v1(104.95,154.97) 105.16,154.76 U6539.AE42
  BOTTOM w0.152: v2(63.63,131.11) 64.17,130.57 JDIM02.157
M_B_DIM0_ODT0: length 63.4
  IN3 w0.102: v2(61.7,129.66) 62.29,130.25 69.31,130.25 73.88,134.82 73.88,136.6 74.06,136.77 74.24,136.77 74.51,136.51 74.68,136.51 74.83,136.65 74.83,136.82 74.55,137.1 74.55,137.26 74.69,137.4 74.83,137.4 75.07,137.16 75.21,137.16 75.35,137.31 75.35,137.45 75.12,137.69 75.12,137.83 75.26,137.98 75.4,137.98 75.64,137.74 75.79,137.74 75.93,137.88 75.93,138.03 75.69,138.26 75.69,138.41 75.84,138.55 75.98,138.55 76.22,138.31 76.36,138.31 76.5,138.46 76.5,138.6 76.27,138.84 76.27,138.98 76.41,139.12 76.55,139.12 76.79,138.89 76.94,138.89 89.09,151.04 93.15,151.04 94.41,152.3 97.45,152.3 99.78,154.62 101,154.62 101.55,155.17 102.18,155.17 102.73,154.62 103.23,154.62 v1(103.57,154.96)
  BOTTOM w0.102: U6539.AE45 103.86,154.67 v1(103.57,154.96)
  BOTTOM w0.152: v2(61.7,129.66) 62.4,130.36 62.4,131.31 62.81,131.72 63.77,131.72 64.42,131.07 JDIM02.155
M_B_DIM0_ODT1: length 63.4
  IN3 w0.102: v1(104.31,154.96) 104.3,154.95 104.28,154.95 103.7,154.36 100.03,154.36 97.58,151.91 96.69,151.91 95.8,151.03 94.28,151.03 94.15,150.9 94.15,150.39 93.97,150.21 89.02,150.21 74.47,135.66 74.47,134.83 68.57,128.93 63.42,128.93 62.91,128.42 59.99,128.42 59.86,128.55 59.86,128.83 59.96,128.93 62.32,128.93 v2(63.05,129.66)
  BOTTOM w0.102: U6539.AE44 104.51,154.76 v1(104.31,154.96)
  BOTTOM w0.152: JDIM02.161 64.46,129.57 63.84,130.2 63.59,130.2 v2(63.05,129.66)
M_B_DQ0: length 67.6
  IN1 w0.089: v1(95.4,151.43) 94.66,152.17 93.77,152.17 93.24,151.63 90.44,151.63 82.21,143.41 82.21,141.12 81.33,140.23 80.69,140.23 75.51,135.05 75.51,134.93 75.96,134.48 75.96,134.36 75.77,134.17 75.64,134.17 75.2,134.61 75.07,134.61 74.88,134.42 74.88,134.3 75.33,133.85 75.33,133.73 75.14,133.54 75.02,133.54 74.57,133.98 74.44,133.98 74.26,133.79 74.26,133.67 74.7,133.22 74.7,133.1 74.51,132.91 74.39,132.91 73.94,133.35 73.82,133.35 73.63,133.17 73.63,133.04 74.07,132.59 74.07,132.47 73.88,132.28 73.07,132.28 72.94,132.15 72.94,128.8 69.51,125.37 67.36,125.37 64.36,122.38 59.61,122.38 v2(59.07,121.83)
  BOTTOM w0.089: U6539.AP49 102.14,151.08 102.1,151.12 102.1,151.31 101.88,151.53 101.66,151.53 101.61,151.48 99.83,151.48 99.72,151.59 95.56,151.59 v1(95.4,151.43)
  BOTTOM w0.114: v2(59.07,121.83) 58.57,122.32 JDIM02.190
M_B_DQ1: length 67.3
  IN1 w0.089: v1(94.79,149.21) 95.26,148.74 95.55,148.74 96.95,147.34 96.95,145.44 96.69,145.18 96.69,142.52 94.53,140.36 93.9,140.36 93.62,140.08 93.62,139.19 91.61,137.18 87.42,137.18 71.17,120.93 69.45,120.93 67.42,118.89 66.47,118.89 64.69,117.12 61.21,117.12 v2(60.39,117.94)
  BOTTOM w0.089: U6539.AP50 101.31,150.55 101.01,150.25 100.6,150.25 100.05,149.71 99.13,149.71
  BOTTOM w0.102: v1(94.79,149.21) 94.79,149.25 95.25,149.71 99.13,149.71
  BOTTOM w0.114: v2(60.39,117.94) 60.68,118.23 60.68,118.7 60.55,118.82 JDIM02.204
M_B_DQ2: length 66.6
  IN1 w0.089: v1(93.46,149.21) 93.46,148.67 93.64,148.49 95.17,148.49 96.57,147.09 96.57,145.82 96.35,145.6 96.35,142.68 94.53,140.87 93.9,140.87 93.28,140.24 93.28,139.35 91.61,137.69 87.42,137.69 71.04,121.31 69.13,121.31 67.23,119.4 66.34,119.4 64.41,117.48 62.24,117.48 v2(61.77,117.94)
  BOTTOM w0.089: 99.13,149.93 99.95,149.93 100.57,150.55 U6539.AP52
  BOTTOM w0.102: v1(93.46,149.21) 94.18,149.93 99.13,149.93
  BOTTOM w0.114: v2(61.77,117.94) 62.39,117.32 63.75,117.32 64.5,118.07 JDIM02.207
M_B_DQ3: length 65.9
  IN1 w0.089: v1(92.2,149.22) 91.84,149.22 90.6,147.98 90.6,147.22 85.52,142.14 85.52,138.71 85.27,138.46 85.27,138.34 86.23,137.38 86.23,137.26 86.04,137.07 85.91,137.07 84.96,138.02 84.83,138.02 84.65,137.83 84.65,137.71 85.6,136.76 85.6,136.63 85.41,136.44 85.28,136.44 84.33,137.39 84.21,137.39 84.02,137.21 84.02,137.08 84.94,136.15 84.94,135.97 84.72,135.75 84.54,135.75 83.64,136.65 83.46,136.65 82.6,135.79 82.6,133.37 71.04,121.82 69.01,121.82 66.97,119.78 66.21,119.78 65.07,118.64 63.29,118.64 63.09,118.44 v2(63.09,117.94)
  BOTTOM w0.089: U6539.AP53 99.78,150.14 99.13,150.14
  BOTTOM w0.102: v1(92.2,149.22) 92.48,149.5 ; 94.16,150.14 99.13,150.14
  BOTTOM w0.114: JDIM02.203 64.22,119.07 v2(63.09,117.94) ; 92.48,149.5 93.12,150.14 94.16,150.14
M_B_DQ4: length 67.8
  IN1 w0.089: v1(91.17,150.63) 83.61,143.07 83.61,139.6 77.67,133.65 77.67,133.52 78.3,132.89 78.3,132.76 78.11,132.57 77.99,132.57 77.35,133.21 77.23,133.21 77.04,133.02 77.04,132.89 77.67,132.26 77.67,132.13 77.48,131.94 77.36,131.94 76.72,132.58 76.6,132.58 76.41,132.39 76.41,132.27 77.04,131.63 77.04,131.5 76.86,131.32 76.73,131.32 76.09,131.95 75.97,131.95 75.78,131.76 75.78,131.64 76.42,131 76.42,130.88 76.23,130.69 76.1,130.69 75.47,131.32 75.34,131.32 75.15,131.13 75.15,131.01 75.79,130.37 75.79,130.25 75.6,130.06 75.47,130.06 74.9,130.63 74.77,130.63 74.49,130.35 74.49,130.17 74.72,129.94 74.72,128.67 69.9,123.85 67.74,123.85 65.02,121.13 v2(63.34,121.13)
  BOTTOM w0.079: v1(91.17,150.63) 92.59,152.04 93.32,152.04 93.76,152.49 99.22,152.49 99.23,152.48 100.32,152.48 100.61,152.19 101.23,152.19 101.29,152.13 101.65,152.13 102.01,151.77 U6539.AL49
  BOTTOM w0.114: JDIM02.191 63.78,122.07 63.34,121.64 v2(63.34,121.13)
M_B_DQ5: length 67.3
  IN1 w0.089: v2(62.04,121.3) 62.35,121.61 64.83,121.61 67.57,124.36 69.77,124.36 73.96,128.55 73.96,130.96 79.4,136.4 79.4,136.52 78.95,136.97 78.95,137.09 79.14,137.28 79.27,137.28 79.84,136.71 79.96,136.71 80.15,136.9 80.15,137.02 79.58,137.6 79.58,137.72 79.77,137.91 79.89,137.91 80.47,137.34 80.59,137.34 80.84,137.58 80.84,137.71 80.26,138.28 80.26,138.41 80.45,138.59 80.58,138.59 81.15,138.02 81.28,138.02 81.52,138.26 81.52,138.39 80.88,139.03 80.88,139.15 81.07,139.34 81.2,139.34 81.83,138.7 81.96,138.7 82.2,138.95 82.2,139.07 81.96,139.31 81.96,139.47 82.98,140.48 82.98,143.15 90.83,151.01 92.01,151.01 v1(92.39,150.63)
  BOTTOM w0.079: v1(92.39,150.63) 92.39,150.91 93.25,151.78 93.48,151.78 93.88,152.18 94.18,152.18 94.28,152.28 98.95,152.28 98.98,152.26 100.3,152.26 100.56,152 101.1,152 101.25,151.84 101.41,151.84 U6539.AL50
  BOTTOM w0.114: v2(62.04,121.3) 62.04,121.26 62.58,120.71 63.71,120.71 64.07,121.07 JDIM02.195
M_B_DQ6: length 65.8
  IN1 w0.089: v1(93.02,150.63) 92.38,151.27 90.59,151.27 82.6,143.28 82.6,140.87 81.58,139.85 80.94,139.85 78.15,137.05 78.15,136.93 78.4,136.67 78.4,136.55 78.22,136.36 78.09,136.36 77.83,136.61 77.71,136.61 77.52,136.42 77.52,136.3 78.03,135.79 78.03,135.66 77.84,135.48 77.72,135.48 77.21,135.98 77.08,135.98 76.89,135.8 76.89,135.67 77.4,135.16 77.4,135.04 77.21,134.85 77.09,134.85 76.58,135.36 76.45,135.36 76.21,135.11 76.21,134.93 76.63,134.52 76.63,134.26 73.45,131.09 73.45,128.67 69.64,124.86 67.46,124.86 64.63,122.03 60.59,122.03 v2(60.39,121.83)
  BOTTOM w0.079: U6539.AL52 100.56,151.77 100.28,152.04 94.41,152.04 94.2,151.84 94,151.84 93.02,150.86 v1(93.02,150.63)
  BOTTOM w0.114: JDIM02.194 58.45,121.32 58.72,121.05 60.19,121.05 60.5,121.36 60.5,121.72 v2(60.39,121.83)
M_B_DQ7: length 65
  IN1 w0.089: v2(59.07,117.94) 58.11,118.9 58.11,120.44 58.59,120.93 61.51,120.93 61.98,120.46 64.98,120.46 67.86,123.34 70.15,123.34 79.17,132.36 79.17,132.74 78.4,133.5 78.4,133.75 84.12,139.47 84.12,142.77 91.52,150.17 93.8,150.17 94.14,150.51 v1(94.14,151.44)
  BOTTOM w0.089: v1(94.14,151.44) 94.53,151.83 99.86,151.83 99.93,151.77 U6539.AL53
  BOTTOM w0.114: v2(59.07,117.94) 58.62,117.5 58.28,117.5 57.96,117.82 JDIM02.208
M_B_DQ8: length 64.1
  IN1 w0.089: v1(94.63,154.17) 94.09,154.71 87.19,154.71 66.74,134.26 64.43,134.26 64.31,134.13 64.31,133.8 64.4,133.72 65.24,133.72 65.32,133.63 65.32,133.36 65.24,133.27 64.4,133.27 64.31,133.18 64.31,129.44 63.93,129.05 59.74,129.05 59.09,128.41 v2(59.09,126.83)
  BOTTOM w0.089: 99.13,154.7 99.4,154.7 99.58,154.52 100.07,154.03 101.47,154.03 101.85,154.06 101.95,154.03 102.14,153.84 U6539.AH49
  BOTTOM w0.102: 99.13,154.7 95.07,154.7 94.63,154.27 v1(94.63,154.17)
  BOTTOM w0.114: JDIM02.174 58.96,126.32 59.09,126.45 v2(59.09,126.83)
M_B_DQ9: length 63.7
  IN1 w0.089: v1(93.16,152.45) 92.54,151.83 89.75,151.83 80.84,142.92 80.84,142.74 81.55,142.03 81.55,141.71 81.43,141.59 81.16,141.59 80.46,142.29 80.34,142.29 80.15,142.1 80.15,141.97 80.85,141.27 80.85,141.09 80.72,140.96 80.53,140.96 79.83,141.66 79.71,141.66 79.52,141.47 79.52,141.34 80.09,140.77 80.09,140.65 72.25,132.8 72.25,129.12 69.26,126.13 67.23,126.13 64.08,122.99 62.45,122.99 v2(61.96,123.48)
  BOTTOM w0.079: U6539.AH50 101.23,153.1 100.99,152.87 100.69,152.87 100.49,152.67 99.38,152.67 99.33,152.72 93.43,152.72 v1(93.16,152.45)
  BOTTOM w0.114: v2(61.96,123.48) 62.4,123.04 64.13,123.04 64.17,123.07 JDIM02.187
M_B_DQ10: length 62.7
  IN1 w0.089: v1(91.87,152.42) 91.51,152.06 89.47,152.06 78.86,141.44 78.86,141.32 79.21,140.96 79.21,140.78 79.05,140.62 78.92,140.62 78.54,141 78.42,141 78.17,140.76 78.17,140.64 78.56,140.25 78.56,140.13 78.37,139.94 78.24,139.94 77.86,140.32 77.73,140.32 77.55,140.13 77.55,140.01 77.93,139.62 77.93,139.5 77.74,139.31 77.61,139.31 77.23,139.69 77.11,139.69 76.92,139.5 76.92,139.38 77.3,139 77.3,138.87 77.11,138.68 76.98,138.68 76.6,139.06 76.48,139.06 76.29,138.87 76.29,138.75 76.67,138.37 76.67,138.24 76.48,138.05 76.36,138.05 75.97,138.43 75.85,138.43 75.66,138.25 75.66,138.12 76.04,137.74 76.04,137.61 75.85,137.42 75.73,137.42 75.34,137.81 75.22,137.81 74.98,137.56 74.98,137.31 75.2,137.08 75.2,136.9 71.8,133.5 71.8,129.31 69.13,126.64 67.06,126.64 64.9,124.48 64.29,124.48 v2(63.28,123.48)
  BOTTOM w0.079: v1(91.87,152.42) 92.37,152.93 99.47,152.93 99.51,152.88 100.38,152.88 100.61,153.1 U6539.AH52
  BOTTOM w0.114: JDIM02.183 63.76,124.07 63.28,123.59 v2(63.28,123.48)
M_B_DQ11: length 62.5
  IN1 w0.089: v1(90.6,152.45) 89.23,152.45 74.12,137.34 74.12,137.21 74.43,136.89 74.43,136.77 74.25,136.58 74.12,136.58 73.8,136.9 73.68,136.9 73.49,136.71 73.49,136.58 73.81,136.26 73.81,136.14 73.62,135.95 73.49,135.95 73.17,136.27 73.05,136.27 72.8,136.03 72.8,135.9 73.06,135.65 73.06,135.52 72.87,135.33 72.75,135.33 72.49,135.59 72.36,135.59 72.18,135.4 72.18,135.27 72.43,135.02 72.43,134.89 72.24,134.7 72.12,134.7 71.86,134.96 71.74,134.96 71.42,134.64 71.42,129.56 68.88,127.02 66.85,127.02 64.82,124.99 63.48,124.99 62.71,124.23 60.24,124.23 v2(59.48,123.47)
  BOTTOM w0.079: v1(90.6,152.45) 91.3,153.15 99.52,153.15 99.57,153.1 U6539.AH53
  BOTTOM w0.114: v2(59.48,123.47) 59.06,123.06 58.5,123.06 58.23,123.32 JDIM02.186
M_B_DQ12: length 64.3
  IN1 w0.089: v1(90.34,153.49) 88.11,153.49 69.9,135.28 69.9,134.44 69.81,134.35 68.97,134.35 68.88,134.26 68.88,133.99 68.97,133.91 69.81,133.91 69.9,133.82 69.9,130.07 68.37,128.55 66.39,128.55 64.31,126.46 60.67,126.46 60.34,126.13 59.74,126.13 59.2,125.59 v2(59.2,124.99)
  BOTTOM w0.089: U6539.AF49 102.17,154.35 102.17,155.14 101.99,155.32 100.12,155.32 99.78,155.66 99.13,155.66
  BOTTOM w0.102: 92.73,155.66 99.13,155.66
  BOTTOM w0.114: v2(59.2,124.99) 58.53,124.32 JDIM02.182 ; v1(90.34,153.49) 92.51,155.66 92.73,155.66
M_B_DQ13: length 63.4
  IN1 w0.089: v2(63.36,126.89) 63.36,127.53 63.61,127.78 64.94,127.78 66.15,128.99 68.31,128.99 68.63,129.31 68.63,129.93 68.14,130.42 68.14,130.6 68.33,130.8 69.26,130.8 69.39,130.92 69.39,131.43 69.3,131.52 68.59,131.52 68.5,131.61 68.5,131.87 68.59,131.96 69.3,131.96 69.39,132.05 69.39,132.32 69.3,132.41 68.21,132.41 68.12,132.5 68.12,132.76 68.21,132.85 69.3,132.85 69.39,132.94 69.39,133.25 69.26,133.37 68.24,133.37 68.12,133.5 68.12,134.01 88,153.89 91.43,153.89 91.61,153.71 91.61,153.53 v1(91.6,153.52)
  BOTTOM w0.079: U6539.AF50 101.24,154.32 100.85,154.71 100.58,154.71 100.33,154.96 100.12,154.96 99.68,155.4 93.07,155.4 91.76,154.09
  BOTTOM w0.114: v2(63.36,126.89) 63.36,126.62 63.6,126.38 64.17,126.38 64.37,126.57 JDIM02.173 ; v1(91.6,153.52) 91.6,153.94 91.76,154.09
M_B_DQ14: length 62.6
  IN1 w0.089: v2(62.02,126.92) 62.02,128.03 62.15,128.17 64.56,128.17 65.32,128.93 65.32,130.28 65.41,130.37 67.14,130.37 67.23,130.46 67.23,130.72 67.14,130.81 65.41,130.81 65.32,130.9 65.32,131.89 65.67,132.23 67.23,132.23 67.61,132.61 67.61,134.01 87.7,154.09 92.39,154.09 v1(92.91,153.57)
  BOTTOM w0.079: U6539.AF52 100.63,154.32 100.24,154.71 100.05,154.71 99.58,155.18 93.72,155.18 92.91,154.37 92.91,154.04
  BOTTOM w0.114: v1(92.91,153.57) 92.91,154.04 ; v2(62.02,126.92) 62.02,127.4 62.36,127.74 63.71,127.74 63.88,127.57 JDIM02.169
M_B_DQ15: length 61.9
  IN1 w0.089: v2(60.42,126.87) 60.42,127.48 60.23,127.67 59.62,127.67 59.48,127.81 59.48,128.29 59.86,128.67 64.31,128.67 64.82,129.18 64.82,132.61 65.07,132.86 65.94,132.86 66.03,132.95 66.03,133.66 66.12,133.75 66.39,133.75 66.47,133.66 66.47,132.95 66.56,132.86 66.97,132.86 67.1,132.99 67.1,133.99 87.44,154.32 93.22,154.32 v1(93.38,154.16)
  BOTTOM w0.079: U6539.AF53 100.11,154.32 99.51,154.92 94.14,154.92 v1(93.38,154.16)
  BOTTOM w0.114: v2(60.42,126.87) 59.97,127.32 JDIM02.170
M_B_DQ16: length 77.7
  IN3 w0.089: v1(102.91,149.41) 102.39,148.9 102.39,148.49 102.11,148.21 101.49,148.21 100.87,147.58 100.87,143.01 100.63,142.77 100.63,139.6 96.82,135.79 88.56,135.79 86.41,133.63 86.41,129.3 76.78,119.67 76.78,118.92 76.45,118.59 76.02,118.59 74.26,116.84 72.28,116.84 71.57,116.13 71.57,113.71 68.54,110.68 68.54,109.64 66.74,107.85 61.77,107.85 61.13,107.21 59.1,107.21 58.59,107.72 57.83,107.72 57.7,107.59 57.7,106.93 v2(58.61,106.02)
  BOTTOM w0.102: U6539.AV47 103.21,149.11 102.91,149.41 v1(102.91,149.41)
  BOTTOM w0.114: JDIM02.250 58.1,107.32 58.61,106.81 v2(58.61,106.02)
M_B_DQ17: length 77.5
  IN3 w0.089: v1(102.97,150.4) 101.99,150.4 100.25,148.66 100.25,144.55 99.49,143.79 99.49,140.36 96.57,137.44 88.31,137.44 84.88,134.01 84.88,129.64 76.68,121.43 74.98,121.43 70.32,116.77 70.32,114.18 67.03,110.89 66.47,110.89 66.09,110.51 66.09,109.5 65.7,109.12 61.51,109.12 60.5,110.13 57.32,110.13 56.94,110.51 56.94,111.53 57.39,111.98 v2(58.48,111.98)
  BOTTOM w0.102: v1(102.97,150.4) 103.21,150.16 U6539.AR47
  BOTTOM w0.114: JDIM02.232 58.32,111.82 v2(58.48,111.98)
M_B_DQ18: length 78.8
  IN3 w0.089: v2(59.99,105.94) 59.99,106.19 59.86,106.32 59.7,106.32 59.57,106.45 59.57,106.69 59.71,106.83 60.37,106.83 60.5,106.7 60.5,106.45 60.62,106.32 61.01,106.32 61.13,106.45 61.13,106.7 61.26,106.83 61.64,106.83 61.77,106.7 61.77,106.41 61.86,106.32 62.28,106.32 62.4,106.45 62.4,107.3 62.57,107.46 66.87,107.46 68.88,109.47 68.88,110.51 71.93,113.56 71.93,115.97 72.44,116.48 74.42,116.48 76.14,118.21 76.58,118.21 77.13,118.77 77.13,119.53 86.79,129.18 86.79,133.37 88.69,135.28 96.95,135.28 101.14,139.47 101.14,147.47 101.65,147.98 102.16,147.98 102.64,148.46 102.64,148.6 103.45,149.41 v1(103.56,149.41)
  BOTTOM w0.102: v1(103.56,149.41) 103.86,149.11 U6539.AV45
  BOTTOM w0.114: v2(59.99,105.94) 59.99,105.94 58.21,107.72 58.21,108.09 57.97,108.32 JDIM02.246
M_B_DQ19: length 78.2
  IN3 w0.089: v1(103.64,150.39) 103.51,150.39 103.11,150.79 102.07,150.79 99.99,148.71 99.99,145.82 99.11,144.93 99.11,140.74 96.95,138.58 93.26,138.58 92.5,137.82 88.18,137.82 84.5,134.13 84.5,129.75 76.56,121.82 74.72,121.82 69.9,116.99 69.9,114.32 66.99,111.41 66.45,111.41 64.53,109.48 61.65,109.48 60.62,110.51 58.21,110.51 57.96,110.77 57.96,111.02 58.21,111.27 59.48,111.27 59.82,111.61 v2(59.82,111.95)
  BOTTOM w0.102: v1(103.64,150.39) 103.65,150.39 103.86,150.17 U6539.AR45
  BOTTOM w0.114: JDIM02.236 58.7,110.82 v2(59.82,111.95)
M_B_DQ20: length 80.8
  IN3 w0.089: v1(105.6,149.48) 105.96,149.11 105.96,147.6 105.71,147.34 102.79,147.34 102.41,146.96 102.41,139.21 97.45,134.26 92.3,134.26 91.99,133.96 91.99,133.63 91.74,133.37 88.06,133.37 87.55,132.86 87.55,128.8 78.02,119.28 78.02,118.41 74.82,115.21 72.77,115.21 72.64,115.08 72.64,113.26 69.64,110.26 69.64,109.24 67.1,106.7 64.69,106.7 64.43,106.45 64.43,105.66 64.2,105.43 61.51,105.43 v2(61.05,105.9)
  BOTTOM w0.102: U6539.AV41 105.81,149.27 v1(105.6,149.48)
  BOTTOM w0.114: JDIM02.245 62.88,108.57 61.05,106.74 v2(61.05,105.9)
M_B_DQ21: length 81.6
  IN3 w0.089: v1(104.95,150.4) 104.58,150.76 103.4,150.76 103.17,150.99 101.97,150.99 99.74,148.76 99.74,146.07 98.72,145.06 98.72,140.87 96.82,138.96 93.01,138.96 92.37,138.33 87.68,138.33 83.99,134.64 83.99,130.07 81.31,127.39 81.18,127.39 80.61,127.96 80.49,127.96 80.3,127.77 80.3,127.65 80.87,127.07 80.87,126.95 80.63,126.7 80.5,126.7 79.87,127.34 79.74,127.34 79.55,127.15 79.55,127.03 80.19,126.39 80.19,126.26 80,126.08 79.87,126.08 79.24,126.71 79.11,126.71 78.92,126.52 78.92,126.4 79.56,125.76 79.56,125.64 78.57,124.65 78.45,124.65 77.81,125.29 77.69,125.29 77.5,125.1 77.5,124.97 78.13,124.34 78.13,124.21 77.94,124.02 77.82,124.02 77.18,124.66 77.06,124.66 76.87,124.47 76.87,124.34 77.5,123.71 77.5,123.58 77.01,123.09 75.33,123.09 69.51,117.27 69.51,114.45 66.85,111.78 66.34,111.78 64.38,109.83 63.09,109.83 v2(62.57,110.34)
  BOTTOM w0.102: U6539.AR42 105.16,150.18 v1(104.95,150.4)
  BOTTOM w0.114: JDIM02.233 64.33,111.57 63.79,111.03 63.26,111.03 v2(62.57,110.34)
M_B_DQ22: length 79.7
  IN3 w0.089: v1(104.95,149.48) 104.57,149.11 103.93,149.11 103.82,148.99 103.31,148.99 102.98,148.67 102.98,148.53 102.23,147.78 101.95,147.78 101.39,147.22 101.39,138.96 97.2,134.77 91.56,134.77 91.47,134.68 91.47,133.97 91.38,133.88 91.12,133.88 91.03,133.97 91.03,134.68 90.94,134.77 90.67,134.77 90.58,134.68 90.58,133.97 90.5,133.88 90.23,133.88 90.14,133.97 90.14,134.68 90.05,134.77 89.78,134.77 89.7,134.68 89.7,133.97 89.61,133.88 89.34,133.88 89.25,133.97 89.25,134.68 89.16,134.77 88.82,134.77 88.69,134.64 88.69,134.13 88.56,134.01 88.06,134.01 87.17,133.12 87.17,129.05 77.64,119.53 77.64,118.74 76.73,117.83 76.27,117.83 74.56,116.11 72.7,116.11 72.28,115.69 72.28,113.41 69.26,110.39 69.26,109.37 66.97,107.08 63.56,107.08 v2(62.37,105.9)
  BOTTOM w0.102: v1(104.95,149.48) 105.16,149.27 U6539.AV42
  BOTTOM w0.114: v2(62.37,105.9) 62.37,106.15 63.79,107.57 JDIM02.249
M_B_DQ23: length 79.3
  IN3 w0.089: v2(63.92,110.34) 64.41,110.34 66.56,112.49 66.69,112.49 66.8,112.37 66.93,112.37 67.12,112.56 67.12,112.69 67,112.8 67,112.93 67.19,113.12 67.32,113.12 67.43,113 67.56,113 67.75,113.19 67.75,113.32 67.63,113.43 67.63,113.56 67.82,113.75 67.94,113.75 68.06,113.63 68.19,113.63 68.38,113.82 68.38,113.94 68.26,114.06 68.26,114.19 69.13,115.06 69.13,117.37 75.81,124.04 75.93,124.04 76.38,123.6 76.5,123.6 76.69,123.78 76.69,123.91 76.25,124.36 76.25,124.71 80.18,128.65 80.54,128.65 81.11,128.07 81.23,128.07 81.42,128.26 81.42,128.39 80.85,128.96 80.85,129.09 81.04,129.28 81.16,129.28 81.74,128.7 81.86,128.7 82.05,128.89 82.05,129.02 81.48,129.59 81.48,129.72 81.67,129.9 81.79,129.9 82.37,129.33 82.49,129.33 82.68,129.52 82.68,129.65 82.11,130.22 82.11,130.34 82.3,130.53 82.42,130.53 83,129.96 83.12,129.96 83.31,130.15 83.31,130.27 82.74,130.85 82.74,130.97 83.36,131.59 83.36,135.15 87.68,139.47 88.76,139.47 88.85,139.56 88.85,140.01 88.94,140.1 89.21,140.1 89.29,140.01 89.29,139.56 89.38,139.47 89.65,139.47 89.74,139.56 89.74,139.88 89.96,140.1 90.98,140.1 91.36,140.48 95.12,140.48 95.76,141.12 97.84,141.12 98.47,141.75 98.47,145.18 99.49,146.2 99.49,148.86 101.82,151.2 103.24,151.2 103.48,150.95 105.04,150.95 v1(105.6,150.4)
  BOTTOM w0.102: U6539.AR41 105.81,150.18 v1(105.6,150.4)
  BOTTOM w0.114: JDIM02.237 64.15,110.57 63.92,110.34 v2(63.92,110.34)
M_B_DQ24: length 73
  IN3 w0.089: v2(60.6,114.12) 61.88,112.84 64.48,112.84 66.85,115.2 66.85,118.26 69.39,120.8 69.39,121.94 79,131.56 79.13,131.56 79.38,131.3 79.51,131.3 79.7,131.49 79.7,131.61 79.44,131.87 79.44,132 79.63,132.18 79.76,132.18 80.07,131.87 80.2,131.87 80.39,132.05 80.39,132.18 80.07,132.5 80.07,132.62 80.26,132.81 80.38,132.81 80.83,132.37 80.96,132.37 81.2,132.61 81.2,136.8 87.42,143.02 95.55,143.02 96.44,143.91 96.44,144.93 98.47,146.96 98.47,149.32 101.24,152.09 102.75,152.09 v1(102.92,152.25)
  BOTTOM w0.102: U6539.AL47 103.21,151.96 v1(102.92,152.25)
  BOTTOM w0.114: v2(60.6,114.12) 59.3,112.82 JDIM02.228
M_B_DQ25: length 73.5
  IN3 w0.089: v2(59.28,114.14) 60.92,112.49 64.62,112.49 67.23,115.1 67.23,118.01 69.77,120.55 69.77,121.69 77.64,129.56 77.9,129.56 78.15,129.31 78.28,129.31 78.52,129.55 78.52,129.68 78.27,129.93 78.27,130.06 78.46,130.25 78.58,130.25 78.9,129.93 79.03,129.93 79.21,130.12 79.21,130.24 78.9,130.56 78.9,130.69 79.08,130.88 79.21,130.88 79.51,130.58 79.93,130.58 81.83,132.48 81.83,135.79 88.69,142.64 96.31,142.64 97.58,143.91 97.58,145.69 98.72,146.83 98.72,149.22 101.36,151.86 103.05,151.86 103.46,152.27 v1(103.6,152.27)
  BOTTOM w0.102: U6539.AL45 103.86,152.02 103.61,152.27 v1(103.6,152.27)
  BOTTOM w0.114: JDIM02.224 58.08,113.82 58.34,113.56 58.7,113.56 v2(59.28,114.14)
M_B_DQ26: length 72.7
  IN3 w0.089: v2(61.51,115.36) 61.99,114.88 64.61,114.88 65.45,115.72 65.45,120.55 77.43,132.52 77.43,132.64 76.98,133.09 76.98,133.22 77.17,133.41 77.29,133.41 77.74,132.96 77.87,132.96 78.05,133.15 78.05,133.27 77.61,133.72 77.61,133.85 77.8,134.03 77.92,134.03 78.37,133.59 78.49,133.59 78.68,133.78 78.68,133.9 78.24,134.35 78.24,134.47 78.43,134.66 78.55,134.66 79.03,134.18 79.21,134.18 79.39,134.36 79.39,134.54 78.94,135 78.94,135.18 79.42,135.66 79.42,137.06 89.27,146.9 96.5,146.9 97.71,148.1 97.71,149.7 101.36,153.35 102.78,153.35 v1(102.88,153.26)
  BOTTOM w0.102: v1(102.88,153.26) 103.21,152.93 U6539.AJ47
  BOTTOM w0.114: v2(61.51,115.36) 62.89,116.74 63.84,116.74 64.18,117.07 JDIM02.211
M_B_DQ27: length 73.3
  IN3 w0.089: v1(103.54,153.25) 103.54,153.26 103.15,153.64 101.17,153.64 97.45,149.93 97.45,148.36 96.34,147.24 88.97,147.24 78.91,137.18 78.91,135.91 76.29,133.29 76.29,133.17 76.87,132.59 76.87,132.47 76.68,132.28 76.55,132.28 75.98,132.85 75.85,132.85 75.66,132.66 75.66,132.54 76.24,131.96 76.24,131.84 76.05,131.65 75.92,131.65 75.35,132.22 75.22,132.22 75.04,132.03 75.04,131.91 75.61,131.34 75.61,131.21 75.42,131.02 75.29,131.02 74.72,131.59 74.59,131.59 74.41,131.41 74.41,131.28 74.98,130.71 74.98,130.58 74.74,130.34 74.61,130.34 74.04,130.91 73.91,130.91 73.72,130.72 73.72,130.6 74.3,130.02 74.3,129.9 74.05,129.66 73.93,129.66 73.55,130.04 73.42,130.04 73.23,129.85 73.23,129.72 73.61,129.34 73.61,129.22 64.69,120.29 64.69,117.2 v2(62.84,115.35)
  BOTTOM w0.102: U6539.AJ45 103.86,152.93 103.54,153.25 v1(103.54,153.25)
  BOTTOM w0.114: v2(62.84,115.35) 63.56,116.07 JDIM02.215
M_B_DQ28: length 74.1
  IN3 w0.089: v1(104.95,152.23) 104.61,151.89 103.36,151.89 103.09,151.63 101.52,151.63 98.98,149.09 98.98,146.58 97.84,145.44 97.84,143.66 96.44,142.26 88.95,142.26 82.21,135.53 82.21,132.1 78.81,128.69 77.54,128.69 77.35,128.5 77.35,128.38 77.86,127.87 77.86,127.74 77.61,127.5 77.49,127.5 77.04,127.95 76.92,127.95 76.67,127.7 76.67,127.58 77.12,127.13 77.12,127.01 76.93,126.82 76.81,126.82 76.36,127.26 76.23,127.26 75.99,127.02 75.99,126.9 76.18,126.7 76.18,126.58 75.99,126.39 75.87,126.39 75.68,126.58 75.55,126.58 70.4,121.43 70.4,120.29 67.74,117.62 67.74,115.12 64.07,111.45 62.81,111.45 v2(62.38,111.88)
  BOTTOM w0.102: U6539.AL42 105.16,152.01 v1(104.95,152.23)
  BOTTOM w0.114: v2(62.38,111.88) 63.64,113.14 64.05,113.14 64.48,113.57 JDIM02.225
M_B_DQ29: length 73.4
  IN3 w0.089: v2(61.06,111.89) 61.84,111.11 64.21,111.11 68.24,115.14 68.24,117.56 82.72,132.04 82.72,135.4 88.56,141.25 95.04,141.25 95.55,141.75 96.57,141.75 98.09,143.28 98.09,145.31 99.23,146.45 99.23,148.96 101.67,151.4 103.14,151.4 103.44,151.7 105.07,151.7 v1(105.6,152.23)
  BOTTOM w0.102: v1(105.6,152.23) 105.81,152.01 U6539.AL41
  BOTTOM w0.114: v2(61.06,111.89) 61.54,111.4 63.31,111.4 64.48,112.57 JDIM02.229
M_B_DQ30: length 70.3
  IN3 w0.089: v1(104.95,153.14) 104.55,153.54 104,153.54 103.66,153.87 100.89,153.87 97.24,150.23 97.24,148.59 96.9,148.25 89.35,148.25 78.4,137.31 78.4,135.91 72.69,130.2 72.69,129.56 72.95,129.31 72.95,129.18 72.76,128.99 72.63,128.99 72.44,129.19 72.25,129.19 72.12,129.06 72.12,128.87 72.32,128.68 72.32,128.55 64.31,120.55 64.31,117.75 62.53,115.97 60.38,115.97 v2(59.78,115.37)
  BOTTOM w0.102: v1(104.95,153.14) 105.15,152.71 U6539.AJ42
  BOTTOM w0.114: v2(59.78,115.37) 58.33,116.82 JDIM02.212
M_B_DQ31: length 72.5
  IN3 w0.089: v1(105.6,153.14) 105.2,153.54 104.88,153.54 104.68,153.74 104.07,153.74 103.72,154.09 100.76,154.09 96.69,150.02 96.69,149.24 96.06,148.61 88.95,148.61 77.9,137.56 77.9,135.91 71.14,129.15 71.14,129.03 71.58,128.58 71.58,128.46 71.4,128.27 71.27,128.27 70.82,128.71 70.7,128.71 70.51,128.52 70.51,128.4 70.96,127.95 70.96,127.83 70.77,127.64 70.64,127.64 70.2,128.08 70.07,128.08 69.83,127.84 69.83,127.72 70.21,127.33 70.21,127.21 70.02,127.02 69.89,127.02 69.51,127.4 69.39,127.4 69.14,127.16 69.14,127.03 69.53,126.65 69.53,126.43 59.45,116.35 58.72,116.35 58.47,116.1 58.47,115.37 v2(58.46,115.37)
  BOTTOM w0.102: v1(105.6,153.14) 105.81,152.93 U6539.AJ41
  BOTTOM w0.114: v2(58.46,115.37) 58,115.82 JDIM02.216
M_B_DQ32: length 54.6
  IN3 w0.089: v2(60.39,162.11) 60.8,161.69 70.49,161.69 74.41,165.62 86.39,165.62 86.53,165.75 102.02,165.75 103.17,166.9 v1(103.17,167.43)
  BOTTOM w0.079: 103.65,166.8 104.39,166.07 104.39,165.89 104.34,165.84 104.34,163.85 104.16,163.68 103.34,163.68 U6539.E47
  BOTTOM w0.102: v1(103.17,167.43) 103.42,167.18 103.42,167.03 103.65,166.8
  BOTTOM w0.114: v2(60.39,162.11) 59.84,162.65 58.31,162.65 57.98,162.32 JDIM02.38
M_B_DQ33: length 54.2
  IN3 w0.089: v2(61.5,162.67) 62.7,163.86 68.92,163.86 69,163.78 69,163 69.09,162.91 69.36,162.91 69.45,163 69.45,163.78 69.54,163.86 69.8,163.86 69.89,163.78 69.89,163 69.98,162.91 70.25,162.91 70.34,163 70.34,163.78 70.43,163.86 71.13,163.86 73.91,166.65 89.2,166.65 89.33,166.51 98.57,166.51 98.7,166.64 v1(98.7,167.41)
  BOTTOM w0.079: U6539.D46 103.06,164.61 103.06,165.06 102.87,165.25 102.87,165.65 102.66,165.85
  BOTTOM w0.102: 102.66,165.85 102.65,165.86 102.05,165.86 101.52,166.39 99.82,166.39
  BOTTOM w0.114: 99.82,166.39 99.49,166.39 98.7,167.18 v1(98.7,167.41) ; v2(61.5,162.67) 61.5,162.43 62.36,161.57 JDIM02.41
