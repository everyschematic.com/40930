# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_THM on BOTTOM (solid shape): 200.7,126.03 200.91,126.03 200.95,125.99 201.33,125.99 201.37,125.98 201.4,125.98 201.79,125.98 201.81,125.98 202.15,125.64 202.15,125.63 202.2,125.55 202.28,125.5 202.29,125.5 202.86,124.92 202.86,124.74 202.71,124.58 202.48,124.58 202.4,124.66 202.39,124.68 202.35,124.77 202.25,124.81 202.23,124.81 201.93,125.11 201.93,125.12 201.87,125.19 201.79,125.22 201.74,125.22 201.56,125.4 201.03,125.4 200.78,125.65 199.31,125.65 199.27,125.69 199.27,125.99 199.32,126.04 200.69,126.04
+3V_WLAN_P on TOP (solid shape): outline of 407 points within 191.98,104.12 196.51,122.83
+3V_WLAN_P on BOTTOM (solid shape): 193.33,105.69 194.74,105.69 194.86,105.56 194.86,104.3 195.12,104.04 196,104.04 196.13,103.91 196.13,103.65 195.96,103.48 191.45,103.48 191.14,103.79 191.14,105.55 192.7,105.55 192.7,105.75 191.14,105.75 191.14,105.97 191.21,106.04 192.97,106.04
+3V_WLAN_P on BOTTOM (solid shape): 193.9,123.56 193.88,123.53 193.85,123.44 193.83,123.34 193.91,123.11 194.1,122.96 194.1,122.7 194.48,122.32 195.88,122.32 196.26,122.7 196.54,122.7 196.67,122.58 196.67,122.15 196.89,121.93 198.43,121.93 198.67,121.69 198.67,118.26 198.42,118.01 197.66,118.01 197.53,118.13 197.53,119.95 197.11,120.38 193.32,120.38 193.19,120.51 193.19,122.29 192.73,122.74 192.7,122.74 192.7,122.75 191.26,122.75 191.14,122.87 191.14,123.05 192.7,123.05 192.7,123.25 191.14,123.25 191.14,123.51 191.24,123.62 193.24,123.62 193.34,123.72 193.9,123.72
+3VLCD_CON on TOP (solid shape): 77.06,194.35 77.13,194.3 77.2,194.26 77.21,194.26 77.52,193.95 77.5,193.89 77.5,193.85 77.5,193.55 77.56,193.38 77.72,193.3 77.74,193.29 78.25,192.78 78.25,190.27 78.05,190.06 76.37,190.06 76.26,190.18 76.26,191.03 76.26,191.23 76.21,191.34 76.1,191.39 75.94,191.39 75.94,191.67 75.86,191.67 75.86,191.88 75.93,191.94 76.27,191.94 76.37,191.99 76.42,192.1 76.42,192.91 76.37,193.02 76.27,193.06 75.74,193.06 75.74,194.33 75.81,194.41 77.01,194.41
+3VLCD_CON_R on TOP (solid shape): 75.35,193.11 75.43,193.07 75.44,192.97 75.43,192.94 75.43,192.91 75.43,192.59 74.96,192.12 74.87,191.99 74.84,191.83 74.95,191.54 75.24,191.42 75.3,191.43 75.35,191.44 75.38,191.41 75.69,191.41 75.69,190.32 75.66,190.29 75.15,190.29 74.52,190.92 74.05,190.92 73.97,191 73.97,191.53 73.78,191.72 73.72,191.8 73.63,191.84 73.15,191.84 73.05,191.94 73.05,192.94 73.22,193.11
+3VLCD_CON_R on BOTTOM (solid shape): 73.3,192.51 73.5,192.51 73.5,193.34 73.8,193.34 73.8,192.51 74,192.51 74,193.34 74.3,193.34 74.3,193.33 74.3,193.15 74.24,193.09 74.24,192 74.32,191.93 74.32,190.73 74.14,190.55 73.43,190.55 73.37,190.6 73.37,191.68 73.06,192 73.06,193.34 73.3,193.34
+3VPCU on TOP (solid shape): 31.67,69.36 31.67,68.73 31.54,68.6 31.03,68.6 30.91,68.73 27.73,68.73 27.6,68.86 27.6,69.49 27.73,69.62 31.41,69.62
+3VPCU on TOP (solid shape): 79.8,98.32 80.06,98.32 80.18,98.19 80.18,97.05 79.8,96.67 79.8,96.16 79.17,95.53 78.4,95.53 78.28,95.65 78.28,96.03 78.36,96.12 78.94,96.12 78.94,96.18 79.04,96.29 79.04,97.18 79.17,97.3 79.17,98.19 78.91,98.45 78.91,98.7 79.04,98.83 79.29,98.83
+3VPCU on TOP (solid shape): 31.27,174.46 31.27,173.93 31.9,173.29 36.81,173.29 39.39,170.7 39.39,166.77 39.14,166.52 38.27,166.52 37.89,166.9 37.89,169.82 35.72,171.99 31.13,171.99 30.83,172.29 30.83,173.03 30.75,173.1 30.68,173.24 30.56,173.31 30.54,173.32 30.28,173.58 30.28,174.49 30.33,174.55 31.18,174.55
+3VPCU on BOTTOM (solid shape): 55.65,100.38 55.65,99.39 54.22,97.96 52.29,97.96 52.17,98.09 52.17,99.59 52.37,99.79 53.36,99.79 53.59,100.02 53.59,100.16 53.61,100.23 53.62,100.3 53.61,100.34 53.6,100.4 53.82,100.62 55.41,100.62
+3VPCU on BOTTOM (solid shape): 197.21,131.2 197.24,131.17 197.34,131.07 197.39,131.07 197.46,131.05 197.53,131.05 197.6,131.05 197.67,131.07 198.16,131.07 198.32,130.91 198.32,130.68 198.52,130.48 200.08,130.48 200.13,130.47 200.18,130.46 200.21,130.46 200.27,130.47 200.48,130.27 200.48,130.02 199.78,130.02 199.78,129.83 200.48,129.83 200.48,129.62 199.78,129.62 199.78,129.59 199.74,129.58 199.71,129.56 199.67,129.54 199.58,129.54 199.57,129.56 199.42,129.73 199.2,129.8 198.92,129.69 198.76,129.36 198.7,129.33 198.41,129.21 198.3,128.93 198.41,128.65 198.67,128.52 198.74,128.49 198.77,128.43 198.9,128.16 199.17,128.06 199.39,128.12 199.54,128.29 199.55,128.32 199.67,128.32 199.71,128.29 199.74,128.28 199.78,128.27 199.78,128.23 200.48,128.23 200.48,128.02 199.78,128.02 199.78,127.83 200.48,127.83 200.48,127.6 200.43,127.55 198.43,127.55 198.31,127.43 198.31,126.93 198.22,126.83 196.02,126.83 195.6,127.26 195.6,131.62 195.66,131.69 196.72,131.69
+3VPCU on IN1 (solid shape): outline of 576 points within 16.05,113.91 42.91,117.96
+3VPCU on IN2 (solid shape): outline of 557 points within 38.78,99.97 55.49,167.94
+3VPCU on IN2 (solid shape): outline of 1639 points within 11.86,68.73 29,116.74
+3VPCU on IN2 (solid shape): outline of 7982 points within 72.74,95.93 216.11,130.49
+3VPCU on IN4 (solid shape): outline of 207 points within 53.61,98.55 74.85,102.62
+3VPCU_EC on TOP (solid shape): 170.75,109.6 170.75,108.41 170.7,108.35 169.59,108.35 169.46,108.23 169.46,108.18 169.44,108.18 169.01,108.18 168.77,107.94 168.68,107.95 168.61,107.94 168.54,107.92 168.5,107.92 168.45,107.97 168.45,108.4 168.7,108.66 168.72,108.66 168.95,108.77 169.06,109 169.06,109.01 169.08,109.04 169.08,109.19 169.2,109.31 169.91,109.31 169.97,109.37 169.97,109.62 170.73,109.62
+5V on TOP (solid shape): 22.19,136.89 22.19,136.02 20.52,134.36 19.19,134.36 18.7,133.87 17.75,133.87 17.64,133.97 17.64,135.86 18.92,137.13 21.95,137.13
+5V on TOP (solid shape): 23.06,151.06 23.06,149.71 22.63,149.28 20.56,149.28 19.72,148.45 19.69,148.48 19.56,148.57 19.4,148.6 19.18,148.54 19.03,148.36 19.02,148.33 18.18,148.33 17.03,147.18 15.14,147.18 15.03,147.29 15.03,148.19 15.09,148.25 16.64,148.25 16.64,148.25 16.76,148.25 16.82,148.32 16.94,148.32 17.4,148.78 18.3,148.78 18.42,148.9 18.57,148.9 19.8,150.13 19.8,150.62 20.58,151.4 22.71,151.4
+5V on TOP (solid shape): 30.78,161.57 31.67,161.57 31.77,161.46 31.77,161.12 32.02,160.87 32.02,160.49 32.04,160.46 32.11,160.34 32.23,160.28 32.25,160.27 32.46,160.27 32.46,158.17 32.3,158.01 31.45,158.01 31.43,158.03 31.03,158.03 30.94,158.17 30.8,158.26 30.67,158.39 30.65,158.39 30.65,159.39 30.83,159.56 30.83,160.14 30.42,160.55 30.14,160.55 30.02,160.68 30.02,160.96 30.26,161.2 30.4,161.2 30.53,161.33 30.59,161.37 30.63,161.43 30.77,161.57
+5V on TOP (solid shape): 73.58,190.27 73.58,190.01 73.83,189.76 74.21,189.76 74.26,189.7 74.28,189.7 74.34,189.63 74.34,189.22 74.5,189.06 75.41,189.06 75.47,189 75.47,188.35 75.36,188.24 71.93,188.24 71.93,188.74 72.05,188.87 72.2,188.87 73.2,188.87 73.27,188.94 73.39,189.08 73.43,189.25 73.39,189.43 73.27,189.56 73.2,189.63 72.94,189.63 72.82,189.76 72.82,190.27 72.9,190.35 73.5,190.35
+5V on TOP (solid shape): outline of 410 points within 214.27,107.59 224.2,124.2
+5V on BOTTOM (solid shape): 25.45,40.92 25.45,40.5 25.04,40.09 23.38,40.09 23.25,40.23 23.25,41.14 23.3,41.2 25.17,41.2
+5V on BOTTOM (solid shape): 38.12,192.95 38.4,192.35 38.4,191.92 38.27,191.79 35.86,191.79 35.48,191.41 34.84,191.41 34.72,191.54 34.72,192.3 34.84,192.42 36.36,192.42 37,193.06 38.02,193.06
+5V on BOTTOM (solid shape): 11.6,34.31 11.6,33.68 10.44,32.51 10.44,31.23 10.21,31.01 9.64,31.01 9.57,31.01 9.14,31.01 8.98,31.18 8.98,31.67 8.79,31.86 7.96,31.86 7.82,32 7.82,32.82 7.91,32.91 9.17,32.91 9.81,33.56 10.6,33.56 10.86,33.83 10.86,34.31 10.99,34.44 11.48,34.44
+5V on BOTTOM (solid shape): outline of 172 points within 166.5,110.9 171.17,116.98
+5V on IN1 (solid shape): outline of 1043 points within 29.89,175.66 64.36,196.26
+5V on IN1 (solid shape): outline of 1241 points within 166.92,116.02 214.89,124.58
+5V on SVCC (solid shape): outline of 833 points within 20.98,89.94 226.87,162.19
+5V on IN2 (solid shape): outline of 522 points within 60.26,189 74.17,196.23
+5V on IN2 (solid shape): outline of 693 points within 3.03,44.73 16.67,76.6
+5V on IN2 (solid shape): outline of 831 points within 26.46,159.03 32.43,177.47
+5V on IN3 (solid shape): outline of 539 points within 3.03,32.66 25.45,46.5
+5V on IN4 (solid shape): 22.27,136.78 22.27,136.05 21,134.77 19.92,134.77 19.52,135.17 19.52,135.88 20.68,137.03 22.03,137.03
+5V_FAN on BOTTOM (solid shape): outline of 405 points within 168.45,110.73 181.9,119.19
+5V_HDD on TOP (solid shape): 228.52,109.47 228.52,104.92 228.89,104.55 228.91,104.51 228.9,104.48 228.82,104.36 228.8,104.21 228.89,103.96 229.11,103.82 229.15,103.81 229.15,103.4 229.03,103.27 225.22,103.27 225.09,103.4 225.09,109.55 225.5,109.95 228.04,109.95
+5V_HDD on BOTTOM (solid shape): 227.76,105 227.76,102.26 227.51,102 226.26,102 226.01,102.26 226.01,102.6 227.51,102.6 227.51,103.74 227.26,103.74 227.26,102.6 227.01,102.6 227.01,103.74 226.76,103.74 226.76,102.6 226.51,102.6 226.51,103.74 226.26,103.74 226.26,102.6 226.01,102.6 226.01,103.91 225.85,104.07 225.85,105.11 226.01,105.26 227.5,105.26
+5V_HDMIC on TOP (solid shape): 19.15,133.19 19.15,131.44 18.94,131.24 17.74,131.24 17.67,131.17 17.67,130.2 17.67,130.16 17.64,130.13 17.26,129.74 15.98,129.74 15.98,129.95 17.18,129.95 17.47,130.24 17.47,131.87 17.37,131.97 16.47,131.97 16.35,131.85 16.35,131.39 16.3,131.34 16.05,131.34 15.95,131.44 15.95,131.82 15.79,131.97 13.53,131.97 13.1,132.4 13.01,132.46 12.91,132.5 12.89,132.5 12.8,132.59 12.8,133.17 13.13,133.5 18.84,133.5
+5V_HDMIC on BOTTOM (solid shape): 14.94,132.1 16.2,132.1 16.43,131.87 16.43,130.06 16.3,129.93 13.6,129.93 13.35,130.18 13.35,130.63 12.91,131.07 12.32,131.07 12.09,131.29 12.09,131.52 13.41,131.52 13.42,131.46 13.43,131.41 13.45,131.35 13.48,131.3 13.51,131.26 13.55,131.22 13.59,131.18 13.64,131.15 13.7,131.13 13.75,131.12 13.81,131.11 13.87,131.11 13.92,131.12 13.98,131.14 14.03,131.17 14.07,131.2 14.12,131.23 14.15,131.28 14.18,131.33 14.21,131.38 14.22,131.43 14.23,131.49 14.23,131.55 14.22,131.6 14.21,131.66 14.18,131.71 14.15,131.76 14.12,131.8 14.07,131.84 14.03,131.87 13.98,131.9 13.92,131.91 13.87,131.92 13.81,131.93 13.75,131.92 13.7,131.91 13.64,131.88 13.59,131.86 13.55,131.82 13.51,131.78 13.48,131.73 13.45,131.68 13.43,131.63 13.42,131.57 13.41,131.52 12.09,131.52 12.09,132.26 12.87,133.03 14.01,133.03
+5V_KB on BOTTOM (solid shape): 218.28,122.96 218.33,122.86 218.44,122.82 219.25,122.82 219.35,122.86 219.4,122.96 220.41,122.96 220.41,122.47 220.31,122.37 220.24,122.34 220.17,122.37 220.04,122.45 219.89,122.48 219.6,122.36 219.48,122.07 219.5,121.95 219.55,121.85 219.55,121.6 219.45,121.51 219.45,121.14 219.39,121.08 218.01,121.08 218,121.08 217.65,121.08 217.52,121.2 217.52,121.64 217.12,122.04 217.12,122.61 217.47,122.96
+5V_PVDD on BOTTOM (solid shape): 22.76,41.2 22.76,39.86 22.6,39.69 22.6,37.63 22.55,37.59 22.55,36.75 22.4,36.6 22.14,36.6 22.02,36.73 22.02,37.8 21.93,37.88 21.9,37.91 21.87,37.94 21.79,38.02 21.79,40.37 21.49,40.66 20.53,40.66 20.25,40.39 20.25,38.36 19.86,37.97 19.64,37.97 19.51,38.1 19.51,41.1 20.25,41.1 20.31,41.17 20.35,41.17 20.46,41.21 20.5,41.32 20.5,41.65 21.61,41.65 21.63,41.67 21.73,41.67 21.78,41.67 21.82,41.69 21.83,41.7 22.26,41.7
+5V_S5 on TOP (solid shape): 36.49,159.28 36.49,158.77 36.75,158.52 37.13,158.52 37.14,158.53 38.28,158.53 38.42,158.39 38.42,157.44 38.35,157.37 34.67,157.37 34.32,157.73 34.32,159.26 34.59,159.53 36.24,159.53
+5V_S5 on BOTTOM (solid shape): 23.54,93.88 23.54,92.61 23.29,92.35 22.4,92.35 22.27,92.48 21,92.48 20.87,92.61 20.87,93.49 21.25,93.88 22.02,93.88 22.27,94.13 23.29,94.13
+5V_S5 on BOTTOM (solid shape): 220.7,110.77 220.7,109.99 220.49,109.78 219.81,109.78 219.73,109.69 219.73,109.14 219.07,108.48 218.21,108.48 217.34,109.36 217.34,109.76 217.23,109.87 217.08,109.87 216.89,110.06 216.89,110.31 217.03,110.45 217.23,110.45 217.47,110.41 217.71,110.39 218.11,110.39 218.5,110.42 218.71,110.46 218.91,110.5 219.36,110.64 219.79,110.83 220.63,110.83
+5V_S5 on BOTTOM (solid shape): outline of 1471 points within 24.74,98.85 46.86,113.48
+5V_S5 on IN1 (solid shape): outline of 252 points within 21.74,92.61 28.24,101.07
+5V_S5 on SVCC (solid shape): outline of 589 points within 42.8,96.03 220.77,110.77
+5V_S5 on IN2 (solid shape): outline of 3535 points within 28.7,108.92 37.57,159.86
+5V_S5 on IN4 (solid shape): 28.62,100.86 28.62,100.23 28.68,100.17 28.67,100.1 28.68,100.03 28.7,99.97 28.68,99.91 28.67,99.84 28.77,99.61 29,99.51 29.07,99.52 29.13,99.54 29.13,98.25 28.84,97.96 28,97.96 23.9,93.86 23.9,92.71 23.54,92.35 22.52,92.35 22.3,92.58 22.3,94.38 23.65,94.38 24.1,94.84 24.1,95.42 24.14,95.49 24.22,95.51 24.26,95.5 24.3,95.5 24.55,95.6 24.66,95.86 24.66,95.88 24.69,95.95 24.77,95.98 24.79,95.98 25.04,96.09 25.14,96.34 25.12,96.45 25.07,96.55 25.07,97.99 26.53,99.44 26.53,100.8 26.83,101.1 28.38,101.1
+5VA on BOTTOM (solid shape): 13.47,31.53 13.47,30.73 14.07,30.12 14.81,30.12 14.89,30.2 15.57,30.2 16.07,30.71 17.01,30.71 17.11,30.61 17.01,30.51 16.51,30.51 16.35,30.35 16.35,29.89 16.61,29.64 16.61,29.2 16.11,28.71 16.11,27.16 15.77,26.82 15.77,26.51 15.84,26.44 15.84,26.16 15.69,26.01 14.94,26.01 14.77,26.18 14.77,27.05 13.54,28.27 13.54,28.39 12.91,29.03 12.03,29.03 11.74,29.32 11.74,30.2 11.11,30.83 11.11,32.39 11.2,32.48 12.52,32.48
+5VPCU on TOP (solid shape): 9.94,13.75 9.95,13.72 9.95,13.36 10.21,13.1 10.21,11.2 10.08,11.07 9.7,11.07 9.44,11.33 9.44,11.71 9.7,11.96 9.7,12.98 9.44,13.23 9.44,13.74 9.57,13.87 9.82,13.87
+5VPCU on TOP (solid shape): 34.46,166.39 34.46,165.43 34.49,165.4 34.58,165.2 34.77,165.06 34.77,164.34 34.77,164.1 34.75,164.08 34.64,164.06 34.58,164.16 34.58,164.7 34.38,164.7 34.38,163.97 32.83,163.97 32.68,164.11 32.68,165 32.81,165.12 33.32,165.12 33.57,165.38 33.57,166.39 33.7,166.52 34.34,166.52
+5VPCU on TOP (solid shape): 39.06,166.11 39.06,165.21 39.02,165.17 38.35,165.17 38.35,164.88 38.34,164.83 38.34,164.79 38.34,164.51 38.34,164.47 38.35,164.43 38.35,164.4 37.95,164 37.74,164 37.69,163.99 37.64,163.96 37.63,163.95 36.79,163.95 36.58,163.95 36.58,164.7 36.38,164.7 36.38,163.95 36.18,163.95 36.18,164.1 36.19,164.11 36.19,164.34 36.19,164.98 36.24,165.03 36.45,165.14 36.56,165.35 36.61,165.39 36.62,165.39 36.82,165.59 37.42,165.59 38.02,166.19 38.98,166.19
+5VPCU on TOP (solid shape): 24.94,100.86 25.19,100.61 25.19,98.96 24.94,98.7 23.85,98.7 23.84,98.71 22.36,98.71 22.21,98.57 22.2,98.57 21.96,98.45 21.84,98.22 21.84,98.2 21.76,98.12 20.19,98.12 20.06,98.24 20.06,98.31 20.14,98.39 20.14,99.4 20.51,99.78 21.37,100.25 23.15,100.25 23.16,100.24 23.25,100.21 23.34,100.2 23.63,100.32 23.74,100.61 23.74,100.63 23.75,100.71 23.9,100.86 24.94,100.86
+5VPCU on BOTTOM (solid shape): 30.02,113.94 30.02,113.31 29.64,112.93 29.26,112.93 28.49,112.16 28.11,112.16 27.6,112.67 27.6,113.31 28.37,114.07 29.89,114.07
+5VPCU on BOTTOM (solid shape): 8.68,49.04 8.68,46.12 8.55,46 4.74,46 4.55,46.19 4.55,46.81 4.62,46.88 4.62,47.51 5.3,47.51 5.38,47.59 6.91,47.59 7.03,47.71 7.09,47.71 7.41,48.03 7.41,49.04 7.54,49.17 8.55,49.17
+5VPCU on BOTTOM (solid shape): 23.24,43.78 23.98,43.78 24.56,43.2 25.7,43.2 26.44,42.46 26.44,42.42 26.52,42.24 26.69,42.16 26.74,42.16 26.97,41.93 26.97,41.31 26.58,40.92 26.27,40.92 25.41,41.77 23.83,41.77 23.03,42.57 23.03,43.58 23.23,43.78
+5VPCU on BOTTOM (solid shape): 224.43,127.81 224.43,126.24 224.3,126.12 222.22,126.12 222.16,126.18 222.16,126.4 222.99,126.4 222.99,126.6 222.16,126.6 222.16,126.9 222.99,126.9 222.99,127.1 222.16,127.1 222.16,127.4 222.99,127.4 222.99,127.6 222.36,127.6 222.28,127.64 222.27,127.73 222.29,127.81 222.32,127.9 224.34,127.9
+5VPCU on BOTTOM (solid shape): 103.96,187.16 104.38,187.16 104.43,187.2 104.66,187.2 104.83,187.03 104.83,186.4 104.81,186.34 104.8,186.28 104.8,186 104.81,185.94 104.83,185.87 104.83,185.65 104.92,185.56 105.4,185.56 105.4,185.15 105.34,185.09 104.59,185.09 104.44,185.24 103.27,185.24 103.22,185.29 103.22,185.79 103.64,186.2 103.64,187.04 103.8,187.2 103.92,187.2
+5VPCU on BOTTOM (solid shape): outline of 434 points within 32.68,163.73 43.23,184.88
+5VPCU on IN1 (solid shape): 169.08,131.47 169.08,130.32 168.32,129.56 168.19,129.56 167.3,130.45 167.3,131.85 167.69,132.23 168.32,132.23
+5VPCU on IN1 (solid shape): outline of 612 points within 4.11,38.76 27.1,48.54
+5VPCU on IN1 (solid shape): outline of 756 points within 196.82,124.1 224.29,130.88
+5VPCU on SVCC (solid shape): outline of 913 points within 3.03,43.46 94.28,190.52
+5VPCU on IN2 (solid shape): 168.7,131.85 168.7,130.58 168.45,130.32 166.8,130.32 166.67,130.45 166.67,131.85 167.05,132.23 168.32,132.23
+5VPCU on IN2 (solid shape): outline of 1907 points within 41.57,174.8 105.16,189.51
+V3.3DX_RT_TCP0 on TOP (solid shape): 30.91,66.19 30.91,64.92 30.78,64.79 30.27,64.79 29.89,64.41 28.87,64.41 28.75,64.54 28.75,66.82 29.13,67.21 29.89,67.21
+V3A_LX on BOTTOM (solid shape): 181.53,134.36 181.53,133.11 182.74,131.9 182.74,125.61 182.34,125.21 181.57,125.21 181.38,125.4 181.38,126.03 179.45,127.96 179.45,130.98 179.22,131.21 177.39,131.21 177.21,131.21 177.21,132.58 180.08,132.58 180.95,133.45 180.95,134.41 181.05,134.5 181.39,134.5
+V3A_OUT on BOTTOM (solid shape): 188.77,132.71 188.77,130.98 189.23,130.53 189.3,130.52 190.11,130.52 190.16,130.53 190.67,130.53 190.72,130.52 191.53,130.52 191.58,130.53 192.12,130.53 192.17,130.52 192.98,130.52 193.03,130.53 193.09,130.53 193.34,130.78 193.34,131.26 193.75,131.67 194.64,131.67 194.74,131.57 194.74,127.83 194.66,127.76 189.23,127.76 188.5,127.03 187.89,127.03 187.29,126.44 184.39,126.44 184.39,133.78 184.41,133.85 184.42,133.91 184.42,134.21 184.42,134.26 184.55,134.39 185.86,134.39
+V5P5A_LX on BOTTOM (solid shape): 54.48,182.52 54.49,182.52 55.37,182.52 55.7,182.52 55.7,181.2 54.81,180.31 54.81,179.19 54.68,179.07 54.45,179.07 54.38,179.1 54.35,179.17 54.35,179.19 54.24,179.46 53.97,179.58 53.71,179.48 53.59,179.23 53.59,179.21 53.44,179.07 52.97,179.07 52.9,179.09 52.83,179.09 52.76,179.09 52.68,179.07 51.23,179.07 50.87,179.42 50.87,183.51 53.49,183.51
+V5P5A_OUT on BOTTOM (solid shape): 49.42,188.79 49.42,179.57 48.01,178.17 45.76,178.17 45.62,178.31 45.62,178.79 45.44,178.97 44.95,178.97 44.34,179.57 43.4,179.57 43.28,179.7 43.28,185.33 43.55,185.33 43.56,185.28 43.57,185.22 43.59,185.17 43.62,185.12 43.65,185.07 43.69,185.03 43.73,185 43.78,184.97 43.84,184.95 43.89,184.93 43.95,184.93 44,184.93 44.06,184.94 44.11,184.96 44.17,184.98 44.21,185.01 44.25,185.05 44.29,185.09 44.32,185.14 44.34,185.19 44.36,185.25 44.37,185.31 44.37,185.36 44.36,185.42 44.34,185.47 44.32,185.52 44.29,185.57 44.25,185.62 44.21,185.65 44.17,185.69 44.11,185.71 44.06,185.73 44,185.74 43.95,185.74 43.89,185.73 43.84,185.72 43.78,185.7 43.73,185.67 43.69,185.64 43.65,185.6 43.62,185.55 43.59,185.5 43.57,185.45 43.56,185.39 43.55,185.33 43.28,185.33 43.28,185.65 43.29,185.66 43.29,186.11 43.43,186.25 43.81,186.25 43.91,186.15 44.9,186.15 45.28,186.53 47.67,186.53 48.08,186.94 48.08,188.84 48.42,189.17 49.04,189.17
+VCC0V9_SVR_TCP0 on TOP (solid shape): 25.32,75.59 25.32,75.21 25.57,74.95 26.72,74.95 26.84,74.83 26.84,74.06 26.72,73.94 24.81,73.94 24.56,73.68 21.89,73.68 21.76,73.81 21.76,74.32 21.89,74.44 23.16,74.44 23.29,74.57 23.29,75.08 23.39,75.18 23.39,75.18 23.42,75.21 23.92,75.21 23.95,75.23 23.97,75.23 24.25,75.34 24.38,75.6 24.49,75.71 25.19,75.71
+VCC0V9_SVR_TCP0 on IN4 (solid shape): outline of 606 points within 18.77,61.63 22.73,67.2
+VCC0V9_SVR_TCP0_PHASE on TOP (solid shape): 26.84,72.67 26.84,72.03 26.83,71.99 26.8,71.95 26.7,71.99 26.59,72.01 26.3,71.89 26.18,71.6 26.18,71.55 26.21,71.41 26.28,71.28 26.3,71.26 26.3,71.23 26.21,71.1 26.18,70.94 26.18,70.89 26.3,70.6 26.59,70.48 26.65,70.49 26.71,70.5 26.8,70.48 26.84,70.4 26.84,67.97 25.57,66.7 25.21,66.7 25.2,66.7 25.1,66.73 25,66.74 24.92,66.73 24.84,66.71 24.81,66.71 24.78,66.74 24.31,66.74 24.27,66.7 24.18,66.7 23.89,66.41 23.86,66.41 23.57,66.34 23.46,66.06 23.46,66.04 23.28,65.86 23.08,65.86 22.98,65.96 22.98,66.7 23.12,66.85 23.17,66.86 23.22,66.88 23.73,66.88 23.88,67.04 23.96,67.04 24.2,67.27 24.73,67.27 24.82,67.36 24.83,67.37 25.16,67.56 25.36,67.88 25.37,67.89 25.4,67.92 25.47,67.95 25.52,67.97 25.74,68.11 25.83,68.35 25.83,68.37 25.83,69.14 25.55,69.42 25.55,71.67 24.81,72.41 24.81,72.67 25.06,72.92 26.59,72.92
+VCC1.05_OUT_FET on BOTTOM (solid shape): 124.66,141.35 124.66,141.03 124.57,140.93 123.39,140.93 122.42,140.93 122.27,140.78 122.27,140.42 122.22,140.37 121.84,140.37 121.82,140.37 121.81,140.38 121.77,140.42 121.77,140.78 121.78,140.8 121.79,140.82 121.87,140.97 121.87,141.16 121.89,141.19 122.17,141.47 124.54,141.47
+VCC1.05_OUT_PCH on BOTTOM (solid shape): 110.31,129.35 110.31,128.67 109.97,128.34 109.26,128.34 109.06,128.54 109.06,128.69 109.53,129.17 109.76,129.17 110.03,129.44 110.22,129.44
+VCC3V3_SX_TCP0 on TOP (solid shape): 28.87,67.59 28.87,67.33 28.49,66.95 28.49,66.57 28.37,66.44 27.6,66.44 27.48,66.57 27.48,67.46 27.73,67.71 28.75,67.71
+VCC3V3_SX_TCP0 on IN2 (solid shape): outline of 1407 points within 15.85,57.93 29,69.36
+VCC_XD on BOTTOM (solid shape): 34.51,43.43 34.51,42.16 34.27,41.92 33.41,41.92 33.12,41.63 31.39,41.63 31.16,41.86 31.16,42.81 31.45,43.1 31.45,43.1 31.95,43.6 34.35,43.6
+VCC_XD on BOTTOM (solid shape): 34.27,66.62 34.31,66.61 34.36,66.62 34.41,66.62 34.43,66.62 34.56,66.5 34.56,64.89 34.48,64.82 31.14,64.82 30.71,64.39 30.52,64.39 30.26,64.64 30.26,65.43 30.65,65.81 33.22,65.81 34.03,66.62 34.22,66.62
+VCC_XD on IN1 (solid shape): 34.53,66.46 34.53,65.19 34.31,64.97 32,64.97 31.95,65.02 31.95,65.55 32.97,66.57 34.41,66.57
+VCC_XD on IN1 (solid shape): 33.68,43.71 34.21,43.71 34.32,43.6 34.32,42.21 33.97,41.86 33.27,41.86 33.08,42.05 32.47,42.05 32.14,42.38 32.14,43.79 32.42,44.07 33.32,44.07
+VCCFPGM on BOTTOM (solid shape): 118.78,154.19 118.79,154.18 118.84,154.1 118.92,154.05 118.98,154.03 119.02,154.03 119.06,154.03 119.1,154.04 119.22,154.04 119.23,154.05 119.58,154.05 119.67,153.97 119.67,153.64 119.58,153.54 119.23,153.54 119.21,153.54 119.11,153.6 119.02,153.62 118.97,153.62 118.91,153.6 118.88,153.6 118.85,153.61 118.71,153.75 118.54,153.8 118.46,153.79 118.38,153.76 118.35,153.76 118.32,153.77 118.27,153.83 118.27,154.26 118.34,154.33 118.64,154.33
+VCCIN on TOP (solid shape): outline of 1521 points within 107,139.18 118.74,172.36
+VCCIN on BOTTOM (solid shape): outline of 642 points within 122.52,153.64 149.79,167.36
+VCCIN on BOTTOM (solid shape): outline of 630 points within 106.01,140.19 107.56,148.01
+VCCIN on BOTTOM (solid shape): outline of 813 points within 108.38,157.38 115.36,174.39
+VCCIN on BOTTOM (solid shape): outline of 1144 points within 118.24,137.65 120.34,147.86
+VCCIN on SVCC (solid shape): outline of 296 points within 106.47,138.71 145.33,172.87
+VCCIN on IN2 (solid shape): outline of 5977 points within 106.98,139.09 137.85,169.82
+VCCIN_AUX on TOP (solid shape): 139.24,151.53 139.24,150.64 140.63,149.25 140.63,147.47 140.51,147.34 136.66,147.34 135.7,148.49 134.41,149.25 134.41,150.64 134.42,150.69 134.46,150.73 134.5,150.72 134.54,150.72 134.83,150.84 134.95,151.13 134.94,151.2 134.92,151.28 135.43,151.79 138.98,151.79
+VCCIN_AUX on TOP (solid shape): outline of 3962 points within 106.85,129.94 141.9,155.9
+VCCIN_AUX on BOTTOM (solid shape): 144.83,139.47 144.83,139.16 144.82,139.12 144.8,139.1 144.78,139.08 144.76,139.07 144.67,139.06 144.61,139.05 144.56,139.04 144.5,139.01 144.45,138.98 144.41,138.94 144.37,138.9 144.34,138.85 144.32,138.8 144.3,138.74 144.29,138.68 144.29,138.63 144.3,138.57 144.32,138.51 144.34,138.46 144.37,138.41 144.41,138.37 144.45,138.33 144.5,138.3 144.56,138.27 144.61,138.26 144.67,138.25 144.76,138.24 144.78,138.23 144.8,138.21 144.82,138.19 144.83,138.15 144.83,134.9 145.46,134.26 145.46,131.85 145.08,131.47 132.13,131.47 131.87,131.72 131.87,134.27 132.2,134.6 132.2,135.63 132.17,135.66 134.03,135.66 134.03,133.12 134.28,132.86 139.62,132.86 139.75,132.99 139.75,135.4 139.36,135.79 134.16,135.79 134.03,135.66 132.17,135.66 131.69,136.14 131,136.14 130.91,136.24 130.91,137.77 132.22,139.09 134.16,139.09 134.28,138.96 139.24,138.96 140.25,139.98 144.32,139.98
+VCCIN_AUX on BOTTOM (solid shape): 107.45,139.98 107.45,139 107.33,138.87 107.09,138.87 107.02,138.9 106.91,139.15 106.74,139.22 106.59,139.18 106.5,139.05 106.42,138.99 106.33,139.01 106.32,139.02 106.3,139.11 106.36,139.19 106.48,139.28 106.53,139.43 106.45,139.61 106.27,139.68 106.23,139.68 106.16,139.66 106.13,139.67 106.11,139.71 106.11,139.73 106.31,139.93 106.42,139.95 106.48,139.86 106.56,139.7 106.74,139.63 106.92,139.7 106.99,139.88 106.99,139.93 107.01,140.02 107.08,140.06 107.38,140.06
+VCCIN_AUX on BOTTOM (solid shape): 119.72,156.76 119.8,156.68 119.8,156.33 119.71,156.23 119.69,156.15 119.69,156.11 119.69,156.07 119.71,155.99 119.66,155.91 119.57,155.89 119.53,155.91 119.48,155.91 119.23,155.66 119.48,155.4 119.53,155.4 119.57,155.42 119.66,155.4 119.71,155.32 119.69,155.24 119.69,155.2 119.69,155.15 119.71,155.07 119.66,154.99 119.57,154.98 119.53,154.99 119.48,154.99 119.45,154.99 119.37,155.02 119.34,155.09 119.34,155.22 119.25,155.31 119.2,155.38 119.13,155.42 119.1,155.46 118.75,155.46 118.7,155.41 118.43,155.41 118.28,155.56 118.28,156.12 118.39,156.23 118.76,156.23 118.78,156.21 118.77,156.16 118.76,156.11 119.02,155.86 119.27,156.11 119.26,156.18 119.24,156.23 119.39,156.38 119.39,156.69 119.46,156.72 119.52,156.76
+VCCIN_AUX on BOTTOM (solid shape): outline of 167 points within 118.31,148.57 119.7,150.64
+VCCIN_AUX on BOTTOM (solid shape): outline of 402 points within 118.24,131.34 119.63,137.12
+VCCIN_AUX on SVCC (solid shape): 144.32,152.82 144.32,147.98 144.34,147.88 144.39,147.8 144.57,147.62 144.57,139.01 144.39,138.88 144.32,138.66 144.39,138.44 144.57,138.3 144.57,130.18 144.21,129.82 140.51,129.82 140.37,130 140.15,130.07 139.93,130 139.79,129.82 119.02,129.82 116.56,132.28 116.48,132.34 116.38,132.36 107.21,132.36 106.98,132.59 106.98,138.2 106.96,138.3 106.91,138.38 106.47,138.81 106.47,140.23 106.94,140.23 107.07,140.13 107.22,140.1 107.37,140.13 107.5,140.23 111.07,140.23 113.02,138.27 113.11,138.22 113.2,138.2 119.43,138.2 119.52,138.22 119.61,138.27 120.17,138.83 120.22,138.83 120.47,138.93 120.57,139.18 120.57,139.24 123.8,142.46 123.85,142.55 123.87,142.64 123.87,144.44 125.58,146.15 125.68,146.11 125.78,146.1 126.03,146.2 126.13,146.45 126.12,146.55 126.07,146.65 128.1,148.68 128.21,148.63 128.32,148.61 128.59,148.72 128.7,148.99 128.68,149.1 128.63,149.2 129.77,150.34 129.82,150.42 129.84,150.52 129.84,151.25 129.93,151.38 129.97,151.53 129.97,151.55 130.94,152.53 131.12,152.63 131.22,152.81 131.47,153.06 144.09,153.06
+VCCIN_AUX on IN2 (solid shape): outline of 6698 points within 106.98,129.94 141.52,156.74
+VCCPRIM_3P3 on TOP (solid shape): 112.44,129.05 112.44,128.8 112.31,128.67 111.68,128.67 111.55,128.55 111.55,128.17 111.42,128.04 111.17,128.04 111.04,128.17 111.04,129.05 111.17,129.18 112.31,129.18
+VCCST on BOTTOM (solid shape): 127.25,143.15 127.25,143.06 127.19,143 127.17,143 126.92,142.89 126.82,142.64 126.92,142.39 127.17,142.29 127.19,142.29 127.27,142.26 127.3,142.19 127.3,141.63 127.02,141.35 127.02,140.59 126.8,140.37 125.28,140.37 125.11,140.2 122.64,140.2 122.59,140.23 122.52,140.25 122.45,140.33 122.45,140.73 122.54,140.83 123.39,140.83 124.61,140.83 125.53,141.75 125.85,141.75 126.36,142.27 126.36,143.18 126.46,143.28 127.12,143.28
+VCCSTG on BOTTOM (solid shape): 125.94,142.95 125.94,142.39 125.73,142.18 125.06,142.18 124.61,141.73 124.29,141.73 124.17,141.61 122.51,141.61 122.47,141.65 122.47,141.83 122.95,142.31 123.62,142.31 124.46,143.15 125.73,143.15
+VCCSTG_FUSE on BOTTOM (solid shape): 119.24,155.16 119.24,155.11 119.24,155 119.24,154.82 119.23,154.78 119.23,154.74 119.23,154.7 119.24,154.62 119.25,154.61 119.25,154.21 119.18,154.14 118.97,154.14 118.79,154.32 118.76,154.35 118.62,154.5 118.38,154.5 118.31,154.57 118.31,154.97 118.63,155.28 118.87,155.28 118.94,155.36 119.04,155.36
+VCCSTG_S2 on BOTTOM (solid shape): 209.09,120.29 209.09,118.89 208.73,118.54 208.73,118.08 208.58,117.93 207.72,117.93 207.51,118.13 207.51,118.64 207.87,119 207.87,119.91 208.07,120.11 208.07,120.55 208.2,120.67 208.71,120.67
+VDD_IO on TOP (solid shape): 69.13,98.32 69.77,98.32 70.15,97.94 70.15,97.3 69.9,97.05 68.37,97.05 67.99,97.43 67.99,98.32 68.21,98.54 68.64,98.54 68.67,98.57 68.88,98.57
+VDD_IO on BOTTOM (solid shape): 66.85,99 67.05,99 67.05,100.29 67.35,100.29 67.35,99.02 67.35,99 67.37,99 67.4,98.98 67.43,98.9 67.51,98.85 67.52,98.85 67.61,98.76 68.94,98.76 69.26,98.45 69.26,98.07 69.01,97.81 67.1,97.81 66.66,98.25 66.66,98.77 66.55,98.88 66.55,100.23 66.61,100.29 66.85,100.29
+VDDQ on TOP (solid shape): 90.06,172.64 90.06,172.2 89.86,172 89.86,171.93 89.75,171.82 89.75,171.72 89.76,171.71 89.76,171.55 89.52,171.31 88.95,171.31 88.59,170.96 88.17,170.96 88.17,170.96 88.07,171.06 88.07,171.42 88.71,172.05 89.48,172.05 89.57,172.13 89.57,172.13 89.63,172.19 89.65,172.21 89.78,172.34 89.78,172.57 89.86,172.66 90.04,172.66
+VDDQ_VTT on TOP (solid shape): 83.79,176.63 83.79,176.24 84.88,175.16 84.88,173.63 85.52,173 86.28,173 86.66,172.62 86.66,172.11 86.53,171.98 85.14,171.98 83.1,174.01 83.1,175.28 83.08,175.31 83.08,175.33 82.6,175.81 82.6,176.68 82.72,176.81 83.62,176.81
+VDDQ_VTT on TOP (solid shape): 55.93,107.08 56.77,107.08 56.81,107.03 56.81,106.48 57.1,106.19 57.87,106.19 58.03,106.03 58.03,104.68 58,104.65 55.01,104.65 54.77,104.89 54.77,105.13 54.79,105.15 54.9,105.18 55,105.24 55.37,105.61 55.38,105.61 55.38,105.63 55.4,105.64 55.44,105.64 55.45,105.64 56,106.04 55.41,106.38 55.31,106.38 55.27,106.47 55.27,107.15 55.33,107.21 55.8,107.21
+VDDQ_VTT on TOP (solid shape): 49.08,105.59 49.08,105.01 48.56,104.48 48.47,104.45 48.4,104.5 48.25,104.64 48.05,104.7 47.76,104.58 47.64,104.29 47.71,104.06 47.89,103.91 47.9,103.91 47.95,103.87 47.86,103.78 46.4,103.78 46.27,103.91 45.47,103.91 45.35,104.04 45.35,104.63 45.49,104.78 45.66,104.78 45.82,104.83 45.91,104.97 45.92,105.01 46.76,105.01 46.82,105.01 46.89,105.04 47.01,105.04 47.64,105.66 49.01,105.66
+VDDQ_VTT on BOTTOM (solid shape): 82.95,176.7 83.77,176.7 83.83,176.68 83.87,176.63 83.83,176.55 83.81,176.43 83.82,176.33 83.86,176.25 83.86,176.24 83.86,175.66 83.87,175.66 83.87,174.77 82.72,174.77 82.64,174.81 82.62,174.89 82.62,174.93 82.62,174.96 82.5,175.25 82.21,175.37 82.07,175.35 81.95,175.27 81.75,175.47 80.25,175.47 79.8,175.92 79.8,176.81 80,177.01 82.65,177.01
+VDDQ_VTT on BOTTOM (solid shape): outline of 396 points within 44.29,101.19 58.17,105.74
+VIN on TOP (solid shape): outline of 5324 points within 53.74,119.48 175.71,205.72
+VIN on BOTTOM (solid shape): 54.98,188.27 54.98,187.89 55.4,187.47 55.52,187.47 55.7,187.3 55.93,187.3 55.95,187.27 55.95,185.69 55.94,185.63 55.94,185.58 55.94,184.58 55.94,184.53 55.95,184.47 55.95,182.78 55.72,182.78 55.39,183.11 55.39,185.06 54.76,185.7 52.62,185.7 52.57,185.75 52.57,189 52.73,189.15 54.1,189.15
+VIN on BOTTOM (solid shape): 177.48,130.77 177.48,128.17 177.85,127.8 177.85,126.77 177.72,126.64 174.6,126.64 174.1,126.14 174.09,126.13 174.03,126.1 173.99,126.04 173.99,126.03 173.81,125.85 169.41,125.85 169.39,125.88 169.39,129.87 169.46,129.94 171.11,129.94 172.84,128.22 175.64,128.22 175.94,128.52 176.73,128.52 176.96,128.75 176.96,130.96 177.29,130.96
+VIN on BOTTOM (solid shape): 152.98,122.81 153.02,122.7 153.13,122.65 153.89,122.65 154.1,122.45 154.1,122.34 154.08,122.33 154.03,122.29 154,122.22 154,122.2 153.65,122.2 153.37,121.88 153.34,121.72 153.46,121.43 153.75,121.31 153.83,121.32 153.9,121.34 153.97,121.35 154.02,121.31 154.05,121.27 154.1,121.24 154.1,119.78 153.72,119.4 149.27,119.4 148.64,120.04 148.64,122.58 149.52,123.47 152.98,123.47
+VIN on BOTTOM (solid shape): 80.31,201.49 80.31,193.5 80.39,193.42 80.39,193.21 80.37,193.13 80.32,193.07 80.24,193.05 80.2,193.06 80.16,193.06 79.75,192.66 80.16,192.25 80.21,192.25 80.26,192.26 80.35,192.24 80.39,192.16 80.39,192.1 80.33,192.1 80.27,192.12 80.21,192.12 79.83,191.74 80.21,191.36 80.27,191.36 80.35,191.34 80.39,191.26 80.39,190.2 80.39,188.85 80.26,188.72 78.18,188.72 78.1,188.79 78.1,194.46 78.51,194.87 78.51,196.31 78.52,196.32 78.52,201.48 78.99,201.95 79.85,201.95
+VIN_BLIGHT on BOTTOM (solid shape): 75.8,192.51 76,192.51 76,193.34 76.98,193.34 77.59,192.73 77.59,190.34 77.39,190.14 75.48,190.14 75.48,191.5 75.51,191.52 75.54,191.56 75.58,191.6 75.61,191.65 75.62,191.69 75.81,191.69 75.82,191.63 75.83,191.58 75.85,191.53 75.88,191.48 75.91,191.44 75.95,191.4 76,191.36 76.05,191.34 76.1,191.32 76.15,191.31 76.21,191.31 76.26,191.31 76.32,191.33 76.37,191.35 76.42,191.38 76.46,191.42 76.5,191.46 76.53,191.5 76.55,191.55 76.57,191.61 76.58,191.66 76.58,191.72 76.57,191.77 76.55,191.83 76.53,191.88 76.5,191.92 76.46,191.97 76.42,192 76.37,192.03 76.32,192.05 76.26,192.07 76.21,192.07 76.15,192.07 76.1,192.06 76.05,192.04 76,192.02 75.95,191.98 75.91,191.95 75.88,191.9 75.85,191.85 75.83,191.8 75.82,191.75 75.81,191.69 75.62,191.69 75.64,191.75 75.65,191.8 75.65,191.86 75.64,191.91 75.63,191.96 75.61,192.01 75.58,192.06 75.54,192.1 75.51,192.14 75.48,192.16 75.48,192.51 75.5,192.51 75.5,193.34 75.8,193.34
+VIN_VCCIN_AUX on BOTTOM (solid shape): 156.26,136.67 157.53,136.67 157.81,136.39 157.81,135.68 158.64,134.85 158.64,132.93 158.91,132.66 158.91,132.62 159.7,131.84 159.7,128.63 159.84,128.5 163.88,128.5 164.43,129.05 166.16,129.05 167.05,129.94 168.19,129.94 168.32,129.82 168.32,126.39 168.07,126.13 167.05,126.13 166.8,126.39 163.88,126.39 163.24,125.75 154.96,125.75 154.68,126.03 154.68,130.81 154.96,131.09 155.85,131.09 156.15,131.39 156.15,132.23 155.57,132.81 153.67,132.81 153.28,133.19 153.28,136.45 153.87,137.03 155.9,137.03
+VIN_VCORE on TOP (solid shape): 160.95,160.68 160.95,155.72 159.56,154.33 156.89,154.33 156.64,154.58 156.64,156.61 156.89,156.87 158.8,156.87 159.05,157.12 159.05,160.8 159.18,160.93 160.7,160.93
+VIN_VCORE on BOTTOM (solid shape): 155.95,165.07 155.95,163.22 156.31,162.86 157.45,162.86 158.06,162.25 158.06,159.23 159.3,157.98 159.3,154.96 159.1,154.76 159.1,151.89 157.53,150.31 156.99,150.31 155.29,148.61 155.29,144.4 155.09,144.19 155.09,143.94 154.98,143.83 154.93,143.83 154.88,143.84 154.62,143.73 154.5,143.46 154.51,143.39 154.53,143.32 154.53,143.25 154.48,143.2 154.33,143.05 154.27,142.85 154.28,142.76 154.31,142.68 154.33,142.64 153.23,141.55 147.19,141.55 147.01,141.37 147.01,140.69 146.88,140.56 140.99,140.56 140.62,140.93 140.62,141.86 140.9,142.13 144.62,142.13 145.23,142.74 151.68,142.74 152.37,143.43 152.37,147.27 151.84,147.8 151.81,147.8 151.81,149.25 152.27,149.7 152.27,150.31 154.66,152.7 154.66,165.22 154.76,165.33 155.7,165.33
+VIN_VGPU_CORE1 on TOP (solid shape): 99.11,204.75 99.11,201.44 98.72,201.06 97.71,201.06 97.45,200.81 95.68,200.81 94.41,199.54 94.41,198.52 93.9,198.02 93.14,198.02 93.01,198.14 93.01,201.57 93.14,201.7 93.64,201.7 93.9,201.95 93.9,203.48 94.03,203.6 95.55,203.6 95.93,203.98 95.93,204.37 96.06,204.49 97.58,204.49 97.96,204.87 98.98,204.87
+VIN_VGPU_CORE1 on BOTTOM (solid shape): 99.46,205.57 99.46,205.34 99.46,205.3 99.48,205.27 99.58,205.1 99.74,204.99 99.76,204.97 99.76,204.51 99.77,204.5 99.77,200.73 99.56,200.53 98.55,200.53 98.5,200.58 98.5,202.51 98.32,202.69 97.45,202.69 97.35,202.59 97.33,202.59 97.33,200.94 97.2,200.81 96.31,200.81 96.06,201.06 96.06,205.51 96.27,205.72 99.31,205.72
+VIN_VGPU_CORE2 on TOP (solid shape): 108.96,191.67 110.54,191.67 111.17,191.03 111.17,189.7 111.15,189.69 111.1,189.63 111.08,189.56 111.08,189.54 110.03,188.49 108.5,188.49 108.25,188.74 107.23,188.74 107.05,188.93 107.05,192.49 107.14,192.58 108.05,192.58
+VIN_VGPU_CORE2 on BOTTOM (solid shape): 112.75,191.93 112.71,191.81 112.69,191.69 112.71,191.58 112.74,191.47 112.75,191.46 112.75,191.31 112.67,191.23 111.15,191.23 110.99,191.07 110.89,191.03 110.84,190.92 110.84,190.31 110.89,190.2 111.03,190.14 111.04,190.11 111.04,189.92 111.03,189.91 110.96,189.85 110.93,189.77 110.93,189.06 110.94,189.02 110.23,188.31 108.17,188.31 108.09,188.39 108.07,188.39 107.94,188.52 106.29,188.52 106.17,188.64 106.17,191.21 106.57,191.61 107.95,191.61 108.5,192.17 108.5,192.3 108.59,192.39 112.75,192.39
GND on TOP (solid shape): 106.47,115.13 106.47,113.56 102.92,113.56 102.92,115.21 106.39,115.21
GND on TOP (solid shape): 110.21,168.81 110.1,168.7 109.22,168.7 109.11,168.81 109.11,170.36 110.21,170.36
GND on TOP (solid shape): 138.98,153.06 138.98,152.42 138.6,152.04 135.3,152.04 135.3,153.06 135.55,153.31 138.73,153.31
GND on TOP (solid shape): 8.81,11.96 8.81,11.58 8.68,11.45 7.92,11.45 7.67,11.71 7.67,12.21 7.79,12.34 8.43,12.34
GND on TOP (solid shape): 150.18,184.1 150.18,183.36 149.93,183.11 146.37,183.11 146.2,183.28 146.2,183.75 146.72,184.27 150.01,184.27
GND on TOP (solid shape): 230.42,102.79 230.42,101.32 229.97,100.86 225.5,100.86 225.09,101.27 225.09,102.79 225.34,103.04 230.17,103.04
GND on TOP (solid shape): 230.78,108.57 230.78,106.04 230.42,105.69 229,105.69 228.75,105.94 228.75,109.6 228.85,109.7 229.65,109.7
GND on TOP (solid shape): 233.41,119.68 233.41,119.18 233.39,119.16 231.59,119.16 231.55,119.19 231.55,119.95 231.99,120.39 232.7,120.39
GND on TOP (solid shape): 22.72,195 22.72,193.59 22.35,193.22 17.66,193.22 17.44,193.44 17.44,195.58 17.77,195.9 21.82,195.9
GND on TOP (solid shape): 31.54,132.99 31.54,131.47 30.4,130.32 29.89,130.32 29.76,130.45 29.76,132.48 29.89,132.61 30.27,132.61 30.78,133.12 31.41,133.12
GND on TOP (solid shape): 48.14,103.56 48.14,102.63 47.94,102.43 46.1,102.43 45.51,103.02 45.51,103.5 45.64,103.63 47.92,103.63 47.94,103.65 48.05,103.65
GND on TOP (solid shape): 101,200.3 101,199.78 100.76,199.54 100.45,199.54 100.02,199.11 98.32,199.11 97.99,199.44 97.99,200.63 98.08,200.73 100.57,200.73
GND on TOP (solid shape): 153.54,117.88 153.72,117.88 153.97,117.62 153.97,116.07 153.6,115.7 152.5,115.7 152.44,115.7 151.02,117.12 151.02,119.25 152.17,119.25
GND on TOP (solid shape): 25.45,96.42 25.45,94.24 25.25,94.04 23.99,94.04 23.92,94.1 23.92,96.54 24.05,96.67 25.19,96.67
GND on TOP (solid shape): 130.47,125.12 131.36,125.12 131.74,124.74 131.74,121.94 131.36,121.56 129.2,121.56 128.95,121.82 128.95,125.12 129.2,125.37 130.22,125.37
GND on TOP (solid shape): 85.9,178.2 85.9,177.57 85.16,176.83 85.16,176.17 85.05,176.07 84.22,176.07 83.95,176.34 83.95,176.69 83.68,176.96 83.63,176.96 83.36,177.23 83.36,178.2 83.48,178.33 85.77,178.33
GND on TOP (solid shape): 35.61,77.75 35.61,76.58 35.5,76.48 34.36,76.48 33.7,75.82 33.7,74.32 33.19,73.81 29.26,73.81 28.91,74.16 28.91,75.47 28.87,75.5 28.87,76.98 29,77.11 33.32,77.11 34.21,78 35.35,78
GND on TOP (solid shape): 39.45,135.94 39.45,134.03 39.31,133.89 39.11,133.89 39.05,133.94 38.34,133.94 38.02,134.26 38.02,135 38.16,135.14 38.72,135.14 38.73,135.15 38.83,135.15 39.03,135.35 39.03,135.98 39.08,136.03 39.35,136.03
GND on TOP (solid shape): 58.05,104.42 58.05,104.13 57.91,103.99 57.91,103.23 57.68,103 54.43,103 54.15,103.27 54.15,103.84 54.27,103.97 54.79,103.97 55.28,104.45 55.32,104.45 58.02,104.45
GND on TOP (solid shape): 116.38,190.27 116.38,189.89 116.27,189.78 116.2,189.79 116.13,189.78 116.06,189.76 114.85,189.76 114.22,190.4 114.22,190.65 114.35,190.78 115.87,190.78
GND on TOP (solid shape): 150.79,134.26 150.79,132.23 149.91,131.34 149.91,129.44 149.78,129.31 148.89,129.31 148.64,129.56 148.64,131.59 148.51,131.72 147.49,131.72 147.24,131.98 147.24,134.13 147.49,134.39 150.67,134.39
GND on TOP (solid shape): 221.55,111.67 221.55,108.28 221.15,107.88 221.15,106.63 220.19,106.63 219.78,107.04 219.77,107.04 218.99,107.82 218.99,108.86 220.19,110.05 220.19,110.93 221.13,111.87 221.35,111.87
GND on TOP (solid shape): 107.71,140.96 113,140.96 113.09,140.86 113.09,140.61 113.29,140.42 117.02,140.42 117.12,140.32 117.12,139.79 117.03,139.7 113.17,139.7 112.92,139.95 107.62,139.95 107.33,140.25 107.07,140.25 107.02,140.31 107.02,141.19 107.06,141.23 107.43,141.23
GND on TOP (solid shape): 54.14,135.15 54.14,134.77 54.15,134.76 54.15,134.26 54.4,134.01 54.4,133.63 54.31,133.54 52.67,133.54 52.25,133.96 52.25,134.65 52.12,134.78 52.12,135.28 52.24,135.4 53.89,135.4
GND on TOP (solid shape): 116.89,138.07 118.54,138.07 118.68,137.93 118.68,137.83 119.12,137.38 119.12,137.29 118.55,136.71 117.75,136.71 117.07,136.04 113.96,136.04 113.84,136.17 113.84,136.55 113.32,137.06 113.32,137.85 113.42,137.94 115.62,137.94 116,138.33 116.63,138.33
GND on TOP (solid shape): 162.7,188.21 162.7,186.06 162.7,186.04 162.7,184.53 162.45,184.27 162.23,184.27 160.23,186.27 160.23,187.08 160.14,187.17 160.14,188.01 159.99,188.16 159.99,188.72 160.11,188.83 160.36,188.83 160.37,188.84 162.07,188.84
GND on TOP (solid shape): 168.57,165.66 168.86,163.16 169.31,160.7 169.32,160.67 169.27,160.62 167.16,160.62 166.77,161.01 166.77,161.6 167.15,161.99 167.15,165.6 167.26,165.71 168.53,165.71
GND on TOP (solid shape): 19.51,111.17 19.51,111.12 19.56,111.01 19.67,110.97 19.72,110.97 19.78,110.91 20.12,110.91 20.21,110.82 20.21,108.71 20.09,108.58 18.76,108.58 18.64,108.71 18.64,111.19 18.76,111.32 19.37,111.32
GND on TOP (solid shape): 60.94,179.58 60.94,178.2 60.49,177.75 60.49,176.9 59.28,175.69 58.47,175.69 58.24,175.91 58.24,177.74 58.33,177.83 58.77,177.83 59.16,178.22 59.16,178.76 59.49,179.09 59.93,179.09 60.21,179.37 60.21,179.71 60.35,179.84 60.68,179.84
GND on TOP (solid shape): 165.09,157.22 165.09,155 164.77,154.68 164.77,152.02 164.58,151.84 162.06,151.84 161.46,152.44 161.46,155.08 161.47,155.08 161.47,155.73 161.72,155.98 163.11,155.98 163.36,155.73 163.74,155.73 164.28,156.27 164.28,156.82 164.02,157.08 164.02,157.52 164.18,157.68 164.63,157.68
GND on TOP (solid shape): 33.26,136.65 33.36,136.61 33.47,136.6 33.58,136.61 33.68,136.66 34.01,136.66 34.16,136.51 34.16,135.72 34.72,135.16 34.72,134.3 34.59,134.18 33.36,134.18 33.09,134.45 33.09,136.55 33.2,136.66 33.25,136.66
GND on TOP (solid shape): 55.49,185.24 55.49,182.7 55.09,182.3 55.09,181.32 55.16,181.25 56.69,181.25 56.94,181 56.94,178.84 56.93,178.83 56.93,178.62 56.54,178.23 54.62,178.23 54.45,178.4 54.45,179.36 53.58,180.24 51.35,180.24 51.23,180.36 51.23,182.39 50.08,183.54 50.08,185.06 50.41,185.39 55.34,185.39
GND on TOP (solid shape): 227.38,112.59 227.38,112.29 227.48,112.18 227.53,112.12 227.58,112.07 227.58,112.04 227.88,111.73 227.88,110.26 227.76,110.13 227.3,110.13 227.27,110.16 225.14,110.16 224.79,110.51 224.79,112.54 224.84,112.59 226.06,112.59 226.11,112.65 226.12,112.65 226.17,112.7 227.27,112.7
GND on TOP (solid shape): 179.06,130.72 179.06,128.17 179.24,127.99 179.24,125.39 177.7,123.85 172.77,123.85 172.51,124.1 172.51,124.74 172.7,124.93 175.7,124.93 175.92,125.14 175.92,128.01 176,128.1 177.69,128.1 177.99,128.39 177.99,130.7 178.21,130.93 178.86,130.93
GND on TOP (solid shape): 47.8,99.21 47.8,98.07 47.42,97.69 46.4,97.69 45.89,97.18 45.89,96.54 45.77,96.42 45.51,96.42 45.26,96.67 43.1,96.67 42.84,96.42 42.84,96.03 42.72,95.91 42.34,95.91 42.34,96.92 44.11,98.7 45.64,98.7 45.77,98.83 45.77,99.46 46.02,99.72 47.29,99.72
GND on TOP (solid shape): 107.53,144.05 107.53,143.86 107.74,143.65 111.15,143.65 111.35,143.85 117.04,143.85 117.13,143.76 117.13,142.38 117.01,142.26 112.06,142.26 111.97,142.17 109.81,142.17 109.65,142.01 108,142.01 107.74,142.27 107.74,143 107.52,143.21 107.09,143.21 107.01,143.29 107.01,144.13 107.09,144.21 107.37,144.21
GND on TOP (solid shape): 114.81,203.87 114.81,202.84 114.46,202.5 114.33,202.5 113.88,202.04 113.88,200.76 114.05,200.59 114.37,200.59 114.67,200.3 114.67,199.53 114.58,199.44 113.78,199.44 113.6,199.61 113.6,200.35 113.22,200.74 113.22,202.18 113.01,202.4 112.87,202.4 112.52,202.75 112.52,203.42 112.67,203.58 114.06,203.58 114.4,203.92 114.75,203.92
GND on TOP (solid shape): 21.06,176.81 21.06,176.2 20.5,175.64 20.5,174.79 20.07,174.36 20.05,174.36 19.88,174.28 19.81,174.12 19.81,174.08 19.73,174 19.73,173.66 19.39,173.33 19.37,173.33 17.97,173.33 17.6,173.69 17.6,175.37 19.22,176.99 20.88,176.99
GND on TOP (solid shape): 25.83,157.76 25.83,156.29 25.7,156.17 24.23,156.17 24.09,156.3 24.09,157.41 24.11,157.45 24.15,157.47 24.19,157.46 24.47,157.57 24.59,157.84 24.6,157.88 25.7,157.88
GND on TOP (solid shape): 58.59,129.94 58.59,129.63 57.98,129.02 57.98,128.34 58.51,127.81 59.36,127.81 59.99,127.18 59.99,126.74 59.88,126.63 59.64,126.63 59.51,126.75 59.51,127.05 59.29,127.28 58.76,127.28 58.59,127.12 58.59,126.66 58.45,126.52 57.31,126.52 57.18,126.65 57.18,128.88 57.48,129.19 57.48,129.69 57.57,129.77 58.11,129.77 58.11,129.84 58.34,130.07 58.47,130.07
GND on TOP (solid shape): 172.51,98.45 173.65,98.45 173.65,97.96 173.54,97.85 173.54,97.43 173.42,97.3 172.48,97.3 172.39,97.39 172.39,97.86 172,98.26 171.74,98.26 171.62,98.37 171.61,98.37 171.45,98.53 171.36,98.53 170.44,98.53 170.38,98.59 170.38,98.73 170.43,98.78 172.18,98.78
GND on TOP (solid shape): 36.14,142.32 36.14,141.32 36.23,141.24 37.49,141.24 37.71,141.03 37.71,139.2 37.64,139.13 37.35,139.13 37.35,140.03 37.31,140.03 37.3,140.07 37.24,140.15 37.15,140.19 37.01,140.19 36.87,140.32 35.76,140.32 35.44,140.64 35.44,140.95 35.15,141.23 34.21,141.23 34.08,141.36 34.08,142.31 34.21,142.44 36.02,142.44
GND on TOP (solid shape): 90.01,99.77 90.01,96.34 89.96,96.28 86.24,96.28 86.24,96.47 86.2,96.56 86.12,96.62 86.08,96.63 86.08,96.66 85.08,96.66 85.08,96.97 86.08,96.97 86.08,97.01 86.12,97.02 86.17,97.04 86.21,97.07 86.23,97.07 86.4,97.24 86.4,98.09 86.39,98.09 86.39,99.9 89.88,99.9
GND on TOP (solid shape): 168.08,147.23 168.08,147 168.05,146.92 168.04,146.83 168.11,146.61 168.29,146.46 168.32,146.45 168.32,145.95 168.19,145.82 168.19,144.8 167.94,144.55 167.69,144.55 167.56,144.68 167.56,145.18 167.43,145.31 167.18,145.31 167.05,145.44 167.05,145.69 167.18,145.82 167.43,145.82 167.56,145.95 167.56,147.34 167.69,147.47 167.83,147.47
GND on TOP (solid shape): 93.01,99.97 93.52,99.97 93.77,99.72 93.77,99.21 93.98,99.01 93.98,97.74 93.67,97.43 92.93,97.43 92.83,97.53 92.85,97.56 92.86,97.59 92.86,97.62 92.86,98 92.85,98.05 92.83,98.1 92.81,98.11 92.81,98.19 92.81,98.25 92.81,99.11 92.73,99.18 92.17,99.18 92.1,99.26 92.1,100.12 92.1,100.3 92.2,100.4 92.58,100.4
GND on TOP (solid shape): 130.81,189.79 130.81,188.95 129.97,188.11 128.44,188.11 128.32,187.98 128.32,187.73 128.19,187.6 127.83,187.6 127.83,187.92 127.7,188.06 127.25,188.06 127.22,188.08 127.22,188.97 127.33,189.07 129.28,189.07 129.5,189.29 129.54,189.29 129.75,189.36 129.86,189.53 129.87,189.55 130.14,189.82 130.15,189.82 130.22,189.87 130.27,189.93 130.28,189.96 130.63,189.96
GND on TOP (solid shape): 201.44,131.16 202.05,131.09 202.05,130.6 201.17,129.72 200.65,129.72 200.6,129.74 200.56,129.74 200.26,129.74 200.21,129.74 200.16,129.72 200.01,129.72 199.82,129.91 199.83,129.98 199.83,130.26 199.76,130.44 199.58,130.51 199.34,130.51 199.14,130.71 199.14,131.24 200.82,131.24
GND on TOP (solid shape): 111.55,198.9 111.55,198.14 112.06,197.63 113.08,197.63 113.33,197.38 113.33,196.75 113.2,196.62 112.57,196.62 111.93,195.98 111.93,193.57 110.79,192.43 108.76,192.43 108.39,192.79 106.11,192.79 105.96,192.94 105.96,193.29 105.98,193.36 105.99,193.42 105.98,193.47 105.96,193.54 105.96,193.88 106.02,193.99 106.04,194.1 106.04,194.11 106.04,194.37 106.19,194.52 106.19,194.95 106.38,195.14 106.78,195.14 107.49,195.86 107.49,198.52 108,199.03 111.42,199.03
GND on TOP (solid shape): 175.05,98.75 175.1,98.71 175.17,98.7 175.55,98.7 175.61,98.71 175.66,98.75 175.79,98.75 175.84,98.71 175.9,98.7 176.27,98.7 176.27,97.78 176.23,97.69 176.22,97.58 176.23,97.49 176.07,97.33 175.05,97.33 174.89,97.5 174.9,97.56 174.9,97.6 174.89,97.7 174.85,97.79 174.85,97.8 174.85,98.02 174.69,98.17 174.67,98.22 174.64,98.26 174.42,98.48 174.42,98.7 174.81,98.7 174.88,98.71 174.93,98.75
GND on TOP (solid shape): 28.16,165.57 28.19,165.57 28.23,165.57 28.27,165.58 28.42,165.58 28.6,165.4 28.6,164.63 28.17,164.21 28.14,164.21 27.84,164.21 27.67,164.15 27.59,164 27.58,163.98 27.46,163.86 26.99,163.86 26.89,163.93 26.77,163.95 26.65,163.93 26.54,163.86 25.74,163.86 25.62,163.97 25.62,164.31 25.63,164.32 26.37,164.32 26.66,164.6 26.67,164.66 26.7,164.71 26.75,164.74 26.81,164.75 26.85,164.79 27.19,164.79 27.43,165.03 27.43,165.07 27.5,165.15 27.5,165.45 27.63,165.58 28.12,165.58
GND on TOP (solid shape): 136.1,212.02 136.79,212.02 136.95,211.86 136.95,210.87 138.34,209.48 138.34,208.12 138.15,207.93 137.38,207.93 137.14,208.17 137.14,209.48 137.03,209.58 137,209.64 136.95,209.67 136.86,209.76 135.82,209.76 135.81,209.77 135.67,209.79 135.53,209.77 135.52,209.76 134.2,209.76 134.19,209.77 134.1,209.8 134.01,209.81 133.92,209.8 133.83,209.77 133.82,209.76 133.54,209.76 133.53,209.77 133.44,209.8 133.35,209.81 133.26,209.8 133.17,209.77 133.16,209.76 131.24,209.76 131.15,209.82 131.05,209.85 130.93,209.96 130.93,211.58 131.22,211.87 131.52,211.87 131.55,211.86 131.58,211.86 132.14,211.86 132.16,211.86 132.2,211.87 134.89,211.87 135.05,212.03 136.09,212.03
GND on TOP (solid shape): 79.2,193.15 79.2,192.48 79.18,192.46 79.18,190.14 78.29,189.25 74.65,189.25 74.52,189.38 74.52,189.59 74.5,189.61 74.5,189.7 74.45,189.8 74.34,189.85 74.34,189.85 74.25,189.94 74.13,190.01 74.12,190.01 73.8,190.33 73.78,190.33 73.78,190.35 73.74,190.46 73.63,190.5 72.82,190.5 72.79,190.5 72.64,190.65 72.56,190.65 72.44,190.78 72.44,191.84 72.23,192.05 72.23,192.88 72.42,193.06 72.82,193.06 72.85,193.03 72.85,191.93 72.94,191.83 72.94,191.82 73.1,191.67 73.11,191.67 73.13,191.64 73.41,191.64 73.81,191.24 73.81,190.94 73.98,190.77 74.45,190.77 75.08,190.14 75.29,190.14 75.44,189.98 76.24,189.98 76.31,189.91 78.11,189.91 78.41,190.2 78.41,192.85 78.33,192.92 78.33,193.57 78.79,193.57
