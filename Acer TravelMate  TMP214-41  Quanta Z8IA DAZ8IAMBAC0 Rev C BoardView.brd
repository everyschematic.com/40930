# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VNN_EXT: length 12.2
  TOP w0.254: R68498.1 123.19,129.1 v2(122.97,129.32) 122.92,129.37 122.92,130.64 122.73,130.83 122.09,130.83 121.78,130.52 117.97,130.52 117.65,130.2 117.65,129.56 116.45,128.37 116.32,128.37 v1(116.29,128.34) v1(116.29,127.61)
  BOTTOM w0.2: U6539.DD17 116.34,127.61 v1(116.29,127.61)
  BOTTOM w0.254: U6539.DD18 116.28,128.3 116.29,128.34 v1(116.29,128.34)
+VREF06_RT3612: length 2.4
  TOP w0.178: v2(162.65,143.91) 162.2,143.91 PR7013.1
  BOTTOM w0.178: PU7000.12 162.17,143.95 162.62,143.95 v2(162.65,143.91)
  vias: v2(161.59,142.64)
A_A0: length 3.4
  BOTTOM w0.114: U6556.3 138.73,122.45 138.86,122.32 138.86,122.09 138.98,121.97 R68808.1 139.27,122.27 139.39,122.4 140.28,122.4 140.41,122.27 R68804.2
A_A1: length 3
  BOTTOM w0.114: U6556.2 138.72,122.95 138.86,123.09 R68807.1 139.27,122.83 139.42,122.68 140.23,122.68 140.41,122.86 R68803.2
A_A2: length 3.9
  BOTTOM w0.114: U6556.1 138.46,123.45 R68806.1 139.27,124.64 139.62,124.99 v2(140.25,124.99) 140.41,124.83 R68802.2
A_INT: length 20.3
  TOP w0.114: v1(137.17,106.47) 137.17,106.07 R69080.2
  BOTTOM w0.114: v1(137.17,106.47) 137.17,107.75 136.72,108.2 136.72,109.98 136.22,110.49 135.4,110.49 134.45,111.44 134.45,115.12 135.1,115.77 135.1,116.28 135.96,117.14 137.87,117.14 138.09,117.37 v2(138.09,117.67) 138.09,118.72 R69012.1 137.91,118.91 137.77,118.91 137.67,119.01 137.67,119.01 137.54,119.13 137.54,119.14 137.05,119.63 136.6,119.63 136.44,119.79 U6556.7
A_SCL: length 11.4
  TOP w0.114: v1(134.79,128.29) 135.81,127.28 135.81,126.77 137.33,125.24 v2(137.71,125.24)
  BOTTOM w0.114: v1(134.79,128.29) 134.92,128.29 135.4,128.77 R68814.1 135.68,129.56 136.03,129.91 C96913.2 R68866.1 136.94,130.06 136.53,129.65 Q6606.6 ; U6556.19 136.44,125.11 136.62,125.29 137.66,125.29 v2(137.71,125.24)
A_SDA: length 8.9
  TOP w0.114: v2(137.71,126.9) 138.22,126.39 138.22,124.86 v1(137.71,124.36)
  BOTTOM w0.114: R68865.1 137.46,127.36 137.46,127.53 137.88,127.95 Q6606.3 138.82,127.95 138.96,127.81 R68813.1 C96912.2 138.07,127.25 v2(137.71,126.9) ; v1(137.71,124.36) 137.52,124.55 U6556.20
AC_PRESENT_EC: length 81.5
  TOP w0.114: R68461.2 110.95,112.13 v1(111.04,112.04) R68471.2 ; U37.84 166.42,104.74 165.91,105.25 165.48,105.25 165.3,105.08 165.3,104.19 164.76,103.65 v1(164.51,103.65)
  IN4 w0.089: v1(104.53,125.73) 104.53,125.7 104.9,125.33 104.9,123.14 106.23,121.8 106.23,121.57 107.49,120.32 107.49,119.86 109.67,117.67 109.67,116.96 110.38,116.25 110.38,115.24 111.04,114.58 111.43,114.58 111.55,114.46 111.55,113.31 111.04,112.8 v1(111.04,112.04) 111.04,111.88 111.65,111.27 112.31,111.27 114.73,108.86 117.42,108.86 118.49,107.79 125.73,107.79 127.48,106.04 128.21,106.04 131.46,102.8 139.4,102.8 139.62,103.02 147.24,103.02 147.95,102.31 155.67,102.31 156.43,103.07 163.93,103.07 v1(164.51,103.65)
  BOTTOM w0.102: U6539.DK43 104.59,125.73 v1(104.53,125.73)
ACCEL_INTA: length 176.4
  TOP w0.114: Q6540.3 131.86,213.13 v2(131.86,213.14) 131.85,213.14 131.49,213.49 131.49,215.03 131.17,215.35 R25639.1
  IN1 w0.089: v1(85.26,192.33) 85.26,192.05 86.28,191.03 87.8,191.03 88.44,191.67 93.26,191.67 95.07,193.47 100.02,193.47 101.04,192.45 101.65,192.45 103.07,191.03 106.09,191.03 106.6,191.54 111.55,191.54 112.21,190.88 113.94,190.88 115.11,192.05 117.14,192.05 118.92,193.82 118.92,198.9 118.54,199.29 118.54,202.08 119.04,202.59 119.04,205.51 121.15,207.62 121.15,208.78 122.47,210.11 126.94,210.11 128.82,211.99 130.71,211.99 v2(131.86,213.14)
  IN3 w0.089: 114.6,163.01 114.42,162.84 114.42,159.64 114.47,159.59
  IN3 w0.102: v1(101.52,180.87) 105.2,180.87 106.01,181.68 107.06,181.68 108,180.74 108,180.13 110.41,177.72 110.41,176.84 114.19,173.06 114.19,169.83 114.63,169.4 114.63,167 115.26,166.37 115.26,163.88 114.6,163.22 114.6,163.01 ; v1(114.75,120.67) 114.73,120.67 113.2,122.2 113.2,123.59 113.08,123.72 113.08,127.53 112.57,128.04 112.57,130.96 113.2,131.59 113.2,153.82 113.71,154.33 113.71,157.1 114.12,157.5 114.12,159.1 114.47,159.46 114.47,159.59
  IN4 w0.089: v1(101.52,180.87) 101.14,181.25 101.14,181.38 100.12,182.39 100.12,183.54 99.11,184.55 99.11,186.79 94.1,191.79 90.9,191.79 89.66,190.55 87.14,190.55 86.41,191.28 86.15,191.28 85.26,192.17 v1(85.26,192.33)
  BOTTOM w0.102: 114.6,115.82 114.6,117.27 113.99,117.88 113.99,118.67 114.73,119.4 114.73,119.66 114.85,119.78 114.85,120.57 v1(114.75,120.67) 114.56,120.86 114.56,121.69 U6539.DV21
  BOTTOM w0.114: R68747.1 114.42,113.99 114.15,114.27 114.15,115.01 114.6,115.47 114.6,115.82
ACIN: length 98.5
  TOP w0.114: v1(163.11,116.38) 163.11,116.67 163.09,116.69 163.09,118.61 162.81,118.89 161.82,118.89 161.25,119.46 161.25,120.94 160.98,121.22 160.11,121.22 159.96,121.07 PR30.2 ; U37.72 169.56,99.94 169.72,100.1 173.15,100.1 173.43,99.82 173.43,99.44 173.86,99.01 173.86,97.62 175.63,95.84 191.37,95.84 v2(191.69,96.16) 192.01,95.84 196.32,95.84 197.78,97.3 197.78,103.27 198.45,103.93 198.45,106.3 197.66,107.08 197.66,109.62 197.35,109.93 v1(197.35,110.28)
  TOP w0.203: PR39.2 156.88,120.17 157.3,120.59 157.3,120.89 158.21,121.81 PR40.1 158.58,121.81 159,121.39 159,121.2 159.13,121.07 159.54,121.07 PR30.2
  IN3 w0.102: v1(163.11,116.38) 163.52,115.97 165.15,115.97 165.4,115.72 168.96,115.72 170.86,117.62 173.53,117.62 174.54,116.61 174.54,115.97 174.8,115.72 178.35,115.72 178.48,115.85 184.83,115.85 186.86,113.81 189.02,113.81 189.28,113.56 192.2,113.56 194.74,111.02 197.02,111.02 197.35,110.69 v1(197.35,110.28)
ACZ_BCLK: length 8.5
  BOTTOM w0.102: U6539.DR38 106.69,122.97 106.69,121.39 106.62,121.32 106.62,120.71 107.01,120.32 107.01,119.3 106.47,118.77 106.09,118.77 105.68,118.36 R68451.1 105.68,117.27 105.96,116.99 105.96,116.35 105.81,116.2 R68938.1
ACZ_RST#: length 6.6
  BOTTOM w0.102: U6539.DV41 105.65,121.78 106.41,121.02 106.41,120.6 106.8,120.21 106.8,119.4 106.42,119.02 105.96,119.02 105.47,118.53 104.84,118.53 104.67,118.36 R68455.1 R68454.1
ACZ_SDOUT: length 14.7
  BOTTOM w0.102: U6539.DT37 107.25,122.56 107.25,120.76 107.42,120.58 107.42,119.11 106.57,118.26 106.34,118.26 106.25,118.16 R68453.1 106.25,117.65 106.73,117.17 106.73,115.59 106.85,115.47 106.85,113.31
  BOTTOM w0.114: 106.85,113.31 v2(106.17,112.63) 105.71,112.16 105.71,110.77 105.27,110.33 Q6649.1
ACZ_SPKR: length 253.8
  TOP w0.114: R69103.1 157.31,114.83 157.31,115.2 156.99,115.52 v1(156.87,115.52)
  IN2 w0.102: v1(97.15,126.31) 97.18,126.34 97.18,126.36 98.04,127.23 99.66,127.23 103.13,130.69 103.99,130.69 104.01,130.71 105.64,130.71 106.34,131.42 106.34,134.65 106.9,135.21 107.52,135.21 107.91,134.83 107.91,132.21 108.53,131.59 117.5,131.59 118.57,130.52 121.73,130.52 122.09,130.88 122.97,130.88 124.17,129.69 136.98,129.69 140.13,126.54 140.89,126.54 142.34,125.09 145.61,125.09 147.04,123.67 156.28,123.67 156.66,123.29 156.66,118.64 157.02,118.28 157.02,116.15 156.87,116 v1(156.87,115.52) ; v2(25.32,24.03) 25.32,24.11 28.53,27.33 31.6,27.33 32.66,28.39 32.66,48.18 32.11,48.73 32.11,64.73 32.56,65.17 32.56,77.51 34.09,79.04 34.09,88.24 36.62,90.78 73.6,90.78 75.3,92.48 v2(75.74,92.48)
  IN3 w0.102: v1(78.91,110) 80.56,110 82.21,111.66 83.1,111.66 85.67,114.22 88.22,114.22 88.69,114.69 v1(88.69,114.7)
  BOTTOM w0.102: U6539.DC50 101.13,128.37 100.63,128.37 100.21,128.09 99.18,128.09 97.4,126.31 v1(97.15,126.31) 96.82,126.31 96.72,126.41 95.19,126.41 95.08,126.31 R68371.1 94.17,126.31 93.97,126.1 R68364.2 93.78,126.1 93.58,125.89 93.41,125.89 92.12,124.61 91.54,124.61 90.34,123.42 90.34,122.45
  BOTTOM w0.114: v2(75.74,92.48) 73.71,94.51 73.71,97.84 73.27,98.27 73.27,98.35 72.69,98.93 72.69,99.97 73.2,100.48 73.2,101.49 74.09,102.38 77.39,102.38 78.28,103.27 78.28,105.56 79.42,106.7 79.42,107.67 78.81,108.28 78.81,109.9 v1(78.91,110) ; 90.34,122.45 90.34,121.56 89.3,120.52 89.3,115.31 v1(88.69,114.7) ; D11.2 24.93,23.64 v2(25.32,24.03)
ACZ_SYNC: length 4.2
  BOTTOM w0.102: U6539.DU37 107.89,122.01 107.89,121.52 107.79,121.27 107.79,120.88 107.87,120.8 R68452.1
ADDR_SEL: length 5.2
  TOP w0.114: U6515.1 140.65,214.03 140.38,213.76 140.38,212.87 140.89,212.37 141.27,212.37 141.5,212.14 R25624.1 141.78,211.45 v2(141.78,210.84) R25623.2
ADOGND: length 18.2
  TOP w0.203: v2(19.55,24.17) 19.1,24.62 C96268.2 ; v2(8.26,14.75) C590.1
  TOP w0.381: v2(16.45,26.58) 15.98,26.58 C564.2 ; 17.56,27.36 17.56,27.82 v2(17.3,28.08)
  BOTTOM w0.203: v2(17.34,29.67) 17.01,29.99 U20.25 ; v2(16.45,26.58) 16.4,26.63 C568.2 ; C599.2 15.06,25.71 14.9,25.55 v2(14.9,25.14) ; v1(18.13,36.57) 18.13,36.23 18.31,36.04 U20.38
  BOTTOM w0.381: C598.1 12.63,28.49 v2(14.27,26.84) ; v2(13.97,31.14) 13.97,30.93 14.28,30.62 14.6,30.62 C563.1 ; R469.1 17.89,38.12 v2(17.32,38.12) 17.32,38.38 16.9,38.79 C845.2 ; C569.2 17,28.08 v2(17.3,28.08) ; v1(18.13,36.57) 17.98,36.57 17.64,36.91 C572.1
  BOTTOM w0.508: v2(13.89,35.71) 13.89,36.1 R463.2 ; R467.2 13.89,33.92 v2(13.89,34.57)
  vias: v1(22.28,28.18) v2(5.26,28.33) v2(5.54,29.25) v2(7.67,25.63) v2(8.05,29.49) v2(8.71,29.49) v2(9.44,29.49) v2(11.53,16.79) v2(13.25,22.9) v2(13.25,21.42) v2(13.25,20.44) v2(13.48,19.15) v2(13.75,17.91) v2(14.6,15.44) v2(15.39,18.83) v2(16.43,21.49) v2(16.57,17.29) v2(16.82,20.14) v2(17.8,21.13) v2(18.05,18.75) v2(20.24,21.1) v2(21.51,22.37) v2(22.42,26.46) v2(22.55,25.01)
ADP_DET: length 199.1
  TOP w0.114: v2(60.09,195.02) 60.09,193.7 60.21,193.58 v2(60.21,193.28) 59.73,192.8 PR8025.1 58.74,192.8 58.7,192.76 PR8026.2 ; v1(19.98,76.73) 17.83,76.73 v2(16.81,75.71)
  IN1 w0.089: v1(19.98,76.73) 19.98,75.33 15.29,70.63 15.29,68.22 14.32,67.26 14.32,65.25 15.16,64.41 15.16,61.11 15.51,60.75 v1(15.54,60.75) ; v2(20.05,139.53) 20.62,138.96 20.62,138.71 17.32,135.4 15.15,135.4 14.6,134.86 14.6,133.75 14.93,133.42 14.93,128.8 13.94,127.82 13.94,123.52 14.93,122.53 14.93,121.08 14.32,120.47 14.32,117.27 15.79,115.8 15.79,115.11 18.73,112.17 18.73,104.16 17,102.43 17,100.16 16.66,99.82 16.66,90.63 16.58,90.56 16.58,88.45 16.58,83.98 17.11,83.46 17.11,76.01 v2(16.81,75.71)
  IN4 w0.089: v2(60.09,195.02) 60.09,194.54 59.25,193.7 52.12,193.7 51.25,192.83 51.25,191.52 48.23,188.5 45.37,188.5 41.96,185.08 41.96,180.85 40.56,179.45 31.18,179.45 29.96,178.23 25.32,178.23 20.73,173.64 20.73,171.06 17.97,168.3 15.94,168.3 13.9,166.27 11.73,166.27 10.65,165.19 10.65,160.5 11.11,160.04 13.63,160.04 14.4,159.28 14.4,155.88 15.97,154.31 15.97,151.5 15.33,150.86 15.33,145.44 18.86,141.91 18.86,140.72 v2(20.05,139.53)
  BOTTOM w0.114: Q6602.1 14.77,60.46 15.06,60.75 v1(15.54,60.75) 15.57,60.73 15.79,60.73 15.92,60.6 R68760.2
ADP_EN: length 203.5
  TOP w0.114: v1(19.98,77.37) 17.57,77.37 v2(16.68,76.48) ; PR8013.2 48.79,196.94 48.13,196.28 v2(48.13,195.96) 48.13,195.35 42.63,189.85 42.63,187.76 42.07,187.21 42.07,179.94 39.46,177.33 34.52,177.33 33.56,178.29 24.82,178.29 v2(24.7,178.18)
  IN1 w0.089: v2(20.11,138.83) 17.04,135.76 15.23,135.76 14.4,134.92 14.4,133.68 14.74,133.34 14.74,128.88 13.75,127.9 13.75,123.44 14.74,122.46 14.74,121.16 14.13,120.55 14.13,117.19 15.6,115.72 15.6,115.03 18.54,112.09 18.54,104.29 16.81,102.56 16.81,100.35 16.47,100.01 16.47,90.71 16.39,90.64 16.39,83.91 16.92,83.38 16.92,76.71 v2(16.68,76.48) ; v1(23.67,49.43) 22.14,49.43 17.57,54 17.57,55.65 15.16,58.06 15.16,59.46 15.92,60.22 15.92,64.03 14.52,65.43 14.52,67.08 15.54,68.09 15.54,70.38 20.37,75.21 20.37,76.98 v1(19.98,77.37)
  IN4 w0.089: v2(24.7,178.18) 24.7,177.93 24.15,177.38 24.15,177.33 20.54,173.71 20.54,171.14 17.89,168.49 15.86,168.49 13.89,166.52 11.6,166.52 10.46,165.38 10.46,160.42 11.09,159.79 13.38,159.79 14.14,159.03 14.14,155.86 15.78,154.23 15.78,151.58 15.14,150.94 15.14,145.36 18.66,141.83 18.66,140.28 v2(20.11,138.83)
  BOTTOM w0.114: R68761.2 23.8,49.43 v1(23.67,49.43)
ADP_ID: length 386.7
  TOP w0.114: v1(163.75,116.38) v2(163.75,117.17) 163.37,117.55 163.37,118.74 162.94,119.17 161.92,119.17 161.52,119.57 161.52,121.75 161.88,122.1 161.88,122.62 161.46,123.03 PR9276.1
  IN3 w0.102: v2(36.11,175.61) 36.11,178.14 37.59,179.61 40.28,179.61 41.45,180.77 41.45,184.43 42.26,185.24 42.26,189.96 38.2,194.03 18.99,194.03 18.23,193.27 15.08,193.27 11.55,196.8 PJ8000.3 ; v1(163.75,116.38) 165.12,116.38 165.51,115.99 167.95,115.99 168.45,116.48 168.45,117.24 168.96,117.75 170.35,117.75 172.66,120.06 172.66,120.57 172.79,120.7 175.15,120.7 175.38,120.47 175.38,119.76 175.51,119.63 176.55,119.63 178.15,118.03 191.41,118.03 192.7,116.74 192.7,115.72 193.34,115.08 200.32,115.08 205.28,110.13 205.91,110.13 207.69,108.35 207.69,105.68 204.47,102.46 204.47,101.42 205.66,100.23 205.66,99.21 205.28,98.83 204.26,98.83 202.74,97.3 201.09,97.3 200.2,96.42 195.54,96.42 194.81,95.68 180.87,95.68 180.54,96.01 172.79,96.01 171.65,94.87 154.56,94.87 153.78,95.65 150.9,95.65 150.79,95.55 149.63,95.55 147.75,97.43 143.09,97.43 141.9,96.24 124.81,96.24 124.56,96.49 119.68,96.49 119.2,96.01 117.88,96.01 116.63,94.76 113.63,94.76 v2(112.36,96.03)
  IN4 w0.089: v2(36.11,175.61) 36.62,175.1 36.62,166.28 35.35,165 35.35,162.54 33.57,160.76 33.57,156.43 33.24,156.1 33.24,146 31.14,143.89 31.14,141.27 32.45,139.96 32.45,130.85 31.54,129.94 31.54,128.55 32.95,127.14 33.31,127.14 34.19,126.26 34.19,120.88 36.49,118.58 36.49,114.07 37.64,112.93 37.64,103.02 40.05,100.61 41.32,100.61 41.96,99.97 47.09,99.97 47.85,99.21 49.45,99.21 53.26,95.4 57.17,95.4 57.58,94.99 70.76,94.99 72.31,96.54 73.71,96.54 74.21,97.05 76.44,97.05 78.53,99.15 82.15,99.15 82.34,99.34 91.49,99.34 92.88,97.94 98.09,97.94 99.23,96.8 99.8,96.8 101.77,94.82 112.24,94.82 112.36,94.95 v2(112.36,96.03)
ADP_IN_CCG5: length 20.4
  IN3 w0.102: v2(12.02,53.2) 11.7,53.2 8.68,50.19 8.68,48.16 9.19,47.65 10.33,47.65 v1(13.51,44.47)
  BOTTOM w0.114: Q6602.3 14.27,57.93 v2(13.94,57.6) 12.62,56.28 12.62,54.76 11.92,54.06 11.92,53.3 v2(12.02,53.2) ; v1(13.51,44.47) 13.81,44.17 R68974.2
ADP_IN_EN_CCG5: length 16.4
  IN4 w0.089: v1(21.89,54.89) 22.4,54.38 22.4,51.08 v2(22.14,50.82)
  BOTTOM w0.114: v2(22.14,50.82) 22.7,50.82 v2(22.8,50.72) 24.15,50.72 24.3,50.57 24.3,49.43 24.68,49.04 25.95,49.04 26.72,48.28 26.72,47.39 26.91,47.2 Q6603.1 ; R69081.2 22.27,57.68 23.03,56.92 23.03,56.28 21.89,55.14 v1(21.89,54.89)
ADP_IN_EN_EC: length 184.6
  TOP w0.114: v1(137.46,108.51) 138.12,108.51 138.7,109.09 138.7,109.47 139.49,110.26 140.36,110.26 141.55,111.45 146.78,111.45 147.24,111.91 147.62,111.91 v2(149.08,113.37) 149.4,113.69 R69083.1
  IN1 w0.089: v1(137.46,108.51) 137.43,108.51 136.57,109.37 135.55,109.37 135.15,109.78 129.62,109.78 128.7,108.86 120.44,108.86 119.6,108.02 115.62,108.02 115.13,107.54 109.16,107.54 108.91,107.29 101.8,107.29 100.58,106.07 98.47,106.07 98.34,106.19 96.95,106.19 96.57,105.81 93.26,105.81 93.01,105.56 92.76,105.56 92.27,105.08 89.23,105.08 88.81,104.66 84.49,104.66 84.04,104.21 79.93,104.21 77.31,101.6 77.31,100.4 73.32,96.42 73.32,94.89 69.85,91.41 37.21,91.41 35.48,89.68 35.48,89.18 34.16,87.86 34.16,82.08 31.03,78.96 31.03,69.24 28.62,66.82 26.97,66.82 26.72,67.08 26.08,67.08 25.95,66.95 24.43,66.95 24.18,66.7 24.18,65.94 23.44,65.2 23.44,62.1 24.18,61.36 24.18,59.59 23.41,58.82 23.41,57.68 23.03,57.3 21.76,57.3 21.25,56.79 21.25,54.76 21.64,54.38 23.46,54.38 v1(23.54,54.45)
  IN4 w0.089: v1(23.54,54.45) 23.03,53.95 23.03,49.45 v1(23.67,48.82)
  BOTTOM w0.114: R68759.1 24.57,45.86 24.18,46.25 24.18,48.54 23.9,48.82 v1(23.67,48.82)
ALERT: length 17
  TOP w0.102: 123.64,183.74 124.29,183.74 125.25,184.71 125.25,186.57 v1(125.61,186.93)
  TOP w0.114: R397.1 114.57,183.61 114.81,183.84 v2(115.74,183.84) 117.6,183.84 118.16,183.28 118.16,182.39 119.16,181.39 120.75,181.39 123.11,183.74 123.64,183.74
  BOTTOM w0.102: v1(125.61,186.93) U8.F8
AMP_MUTE#: length 254.1
  TOP w0.114: U37.108 161.46,109.8 161.31,109.65 161.31,108.05 161.51,107.85 164.77,107.85 165.02,108.1 165.02,108.96 166.7,110.64 167.94,110.64 168.23,110.93 168.23,111.19 168.85,111.81 169.62,111.81 170.35,112.54 172.13,112.54 172.64,113.05 174.04,113.05 v2(174.8,112.29) 174.8,111.66 173.65,110.51 173.65,110.39 172.23,108.96 172.23,104.28 175.66,100.85 176.51,100.85 177.42,99.95 177.42,98.24 177.85,97.81 177.85,97.3 178.1,97.05 182.45,97.05 v2(182.93,96.57)
  IN2 w0.102: v2(182.93,96.57) 180.1,93.75 154.1,93.75 153.84,93.49 137.59,93.49 136.19,94.89 122.98,94.89 121.58,93.49 94.03,93.49 93.14,94.38 78.91,94.38 76.37,91.84 75.04,91.84 73.74,90.55 36.72,90.55 34.32,88.15 34.32,78.95 32.81,77.44 32.81,65.05 32.34,64.58 32.34,48.88 32.94,48.28 32.94,34.95 33.37,34.52 v2(33.57,34.52)
  BOTTOM w0.114: v2(33.57,34.52) 33.71,34.38 D13.1
AN_RBIAS: length 1.2
  TOP w0.079: v5(21.66,65.52) 21.79,65.65 U6549.L4
  BOTTOM w0.114: R68632.1 21.73,65.62 21.66,65.54 v5(21.66,65.52)
AN_RSENSE: length 1.3
  TOP w0.079: U6549.L5 21.33,65.78 v5(21.08,65.53)
  BOTTOM w0.114: R68632.2 21.28,65.73 v5(21.08,65.53)
AP12: length 3.2
  TOP w0.114: v1(118.56,151.05) 119.66,151.05 119.82,150.89 119.82,150.09 119.83,150.08 TP13294.1
  BOTTOM w0.15: v1(118.56,151.05) 118.98,150.62 U6539.AP12
AUX_PWRGD: length 1
  BOTTOM w0.114: PR7074.1 167.91,134.87 168.19,135.15 TP7000.1
BAT-V: length 27.5
  TOP w0.114: PR208.2 139.24,112.23 139.19,112.27 139.19,114.06 139.06,114.2 PR209.2
  TOP w0.381: v2(155.52,122.71) 155.52,123.11 156.02,123.6 PD9002.1
  IN1 w0.508: v2(155.52,122.71) 155.52,122.93 155.11,123.34 149.91,123.34 148,121.43 140.76,121.43 139.94,120.61 139.3,120.61 138.6,119.91 138.6,116.69 137.56,115.65 v3(137.56,115.6)
  vias: v2(105.71,101.09) v2(105.71,100.42) v2(105.84,96.44) v2(106.37,101.09) v2(106.37,100.42) v2(107.03,101.09) v2(107.03,100.42) v2(107.69,101.09) v2(107.69,100.42) v3(136.88,115.21) v3(137.56,114.84)
BATLED0#: length 116.9
  TOP w0.114: R67487.1 149.8,96.97 v4(150.08,97.25) 150.08,97.35 150.39,97.66 150.39,97.74 150.99,98.34 U37.29 153.38,98.34 154.08,99.04 v2(154.08,99.14)
  IN3 w0.102: v2(154.08,99.14) 154.17,99.14 155.95,97.35 160.74,97.35 161.51,96.59 165.7,96.59 165.9,96.8 169.9,96.8 170.25,97.15 181.99,97.15 183.51,98.68 197.38,98.68 197.91,99.21 201.47,99.21 202.48,100.23 v2(202.48,100.61) 202.48,103.02 204.77,105.31 204.77,107.58 v2(205.16,107.97)
  IN4 w0.089: v2(205.16,107.97) 205.16,107.57 205.15,107.56 205.15,107.08 205.4,106.83 210.87,106.83 212.52,108.48 214.17,108.48 215.95,106.7 218.87,106.7 223.31,111.15 228.65,111.15 229.15,111.66 229.15,112.93 228.26,113.81 228.26,116.7 227.5,117.46 v2(227.5,117.86)
  BOTTOM w0.114: v2(227.5,117.86) 226.89,117.86 226.36,118.39 226.36,118.77 227.05,119.46 CN55.12 ; CN48.22 201.95,111.43 203.88,109.5 203.88,107.59 204.13,107.34 204.9,107.34 205.15,107.59 205.15,107.96 v2(205.16,107.97) ; CN52.14 204.35,100.23 204.2,100.07 203.02,100.07 v2(202.48,100.61)
BATLED1#: length 115.1
  TOP w0.114: R67485.1 150.24,99.41 150.77,99.94 U37.25 153.2,99.94 153.98,100.72 v2(153.98,100.81)
  IN3 w0.102: v2(153.98,100.81) 153.59,100.42 153.59,98.95 153.9,98.63 154.29,98.63 155.8,97.13 160.65,97.13 161.41,96.36 166.24,96.36 166.42,96.54 170,96.54 170.38,96.92 182.09,96.92 183.61,98.45 197.91,98.45 198.17,98.7 201.72,98.7 202.92,99.9 202.92,102.44 v2(203.31,102.83) 205.02,104.54 205.02,107.17 v2(205.84,107.99)
  IN4 w0.089: v2(205.84,107.99) 205.84,107.37 206.13,107.08 210.74,107.08 212.39,108.73 214.45,108.73 215.47,107.72 219.5,107.72 223.18,111.4 228.39,111.4 228.9,111.91 228.9,112.8 228.01,113.69 228.01,116.61 226.99,117.62 226.99,118.39 226.89,118.49 v2(226.89,118.52)
  BOTTOM w0.114: v2(226.89,118.52) 227.39,119.02 228.13,119.02 228.19,118.96 CN55.13 ; v2(205.84,107.99) 206.36,107.46 206.93,107.46 207.82,108.35 208.58,108.35 208.83,108.61 208.83,111.91 209.45,112.53 CN48.7 ; CN52.15 203.85,102.29 v2(203.31,102.83)
BATLOW#: length 19.2
  TOP w0.102: 101.32,121.98 103.59,121.98 104.92,123.31 104.92,124 105.31,124.39 v1(105.32,124.39)
  TOP w0.114: 101.32,121.98 101.11,122.2 100.38,122.2 100.12,121.94 94.25,121.94 93.85,121.54 93.26,121.54 93.14,121.66 91,121.66 90.82,121.84 R68459.1 90.82,122.78 v2(90.64,122.97) 90.19,123.42 R68460.1
  BOTTOM w0.102: U6539.DN41 105.54,124.39 v1(105.32,124.39)
BI: length 169.8
  IN1 w0.089: v2(43.84,119.43) 43.23,120.04 35.35,120.04 34.08,121.31 27.73,121.31 27.35,121.69 24.05,121.69 23.16,122.58 23.16,130.58 24.68,132.1 24.68,137.69 19.98,142.39 19.98,149.13 v2(18.58,150.53)
  IN4 w0.089: v2(43.84,119.43) 44.37,118.89 44.37,116.1 43.38,115.11 43.38,110.61 44.29,109.7 44.29,104.06 46.3,102.05 48.1,102.05 48.46,101.7 49.88,101.7 54.15,97.43 58.34,97.43 58.85,96.92 68.63,96.92 70.81,99.11 72.13,99.11 73.43,97.81 75.99,97.81 78.02,99.84 80.92,99.84 81.17,100.1 81.17,102.1 81.33,102.26 82.21,102.26 82.72,101.75 85.77,101.75 86.28,102.26 94.91,102.26 95.55,102.89 99.84,102.89 104.69,98.04 111.2,98.04 v2(111.68,97.56)
  BOTTOM w0.114: v2(18.58,150.53) 18.07,151.04 SW2.1 SW2.2 15.41,153.44 14.53,154.32 R25321.1 14.53,156.22 v2(14.14,156.61) ; PR10.1 103.83,104.29 103.81,104.26 103.81,103.85 104.12,103.54 PJ1.6 104.12,102.32 104.44,102 109.14,102 109.77,101.37 109.77,99.46 v2(111.68,97.56)
BIOS_WP#: length 4.5
  BOTTOM w0.114: U6548.3 131.94,106.33 TP13315.1 132.35,105.92 R68578.2 132.35,104.77 132.22,104.64 R68591.2
BL#: length 2.9
  BOTTOM w0.114: Q6521.3 87.98,188.57 88.47,189.05 R25368.1 88.18,189.38 88.02,189.22 Q6521.2
BL_ON: length 24.3
  IN3 w0.102: v2(69.15,191.95) 70.1,191 71.57,191 71.93,190.65 79.33,190.65 79.8,190.18 v2(80.79,190.18)
  BOTTOM w0.114: v2(80.79,190.18) 81.06,190.18 81.71,190.83 81.71,190.88 81.82,190.99 Q6522.3 82.05,190.99 82.21,191.16 82.21,191.87 81.99,192.1 R25367.1 81.99,192.68 82.12,192.81 83.23,192.81 v2(83.48,193.06) 83.87,193.06 84.24,192.69 84.27,192.69 84.49,192.47 85.5,191.45 D3.2 86.56,191.08 86.43,190.95 86.2,190.95 85.9,190.65 85.9,190.27 85.72,190.09 Q6521.6 ; CN29.26 v2(69.15,191.95)
BOARD_ID0: length 14.2
  TOP w0.089: 120.31,122.07 119.98,122.4 119.2,122.4 118.94,122.65 118.94,123.19 118.66,123.47 118.66,123.99 v1(119.03,124.36)
  TOP w0.114: R68516.1 R68515.2 126.26,117.02 126.36,117.12 126.36,117.67 126.16,117.88 126.16,118.26 125.62,118.79 v2(125.22,118.79) 124.61,118.79 124.07,119.33 124.07,120.11 122.85,121.33 121.43,121.33 120.84,121.93 120.45,121.93 120.31,122.07
  BOTTOM w0.102: U6539.DN10 119.22,124.36 v1(119.03,124.36)
BOARD_ID1: length 13.2
  TOP w0.089: v1(117.2,124.46) 117.2,124.43 116.84,124.06 116.84,123.64 117.24,123.24 117.24,122.4 117.57,122.07
  TOP w0.114: R68518.1 R68517.2 122.63,117.02 122.75,117.15 122.75,118.77 122.47,119.05 121.84,119.05 v2(121.64,118.84) 121.43,119.05 120.8,119.05 119.78,120.06 119.78,120.72 119.36,121.14 118.5,121.14 117.57,122.07
  BOTTOM w0.102: U6539.DN15 117.29,124.46 v1(117.2,124.46)
BOARD_ID2: length 12.6
  TOP w0.114: v1(119.17,120.29) 119.17,119.91 120.31,118.77 v2(120.31,118.56) 120.31,117.24 120.54,117.02 R68519.2 R68520.1
  IN2 w0.102: v1(119.17,120.29) 119.17,120.67 117.14,122.7 117.14,123.21 116.76,123.59 116.76,125.94 117.2,126.38 v1(117.2,126.39)
  BOTTOM w0.102: v1(117.2,126.39) 117.31,126.39 U6539.DJ15
BOARD_ID3: length 13
  TOP w0.089: 119.15,122.2 118.74,122.6 118.74,123.14 118.49,123.39 118.49,124.04 118.16,124.36 118.14,124.36 v1(118.11,124.39)
  TOP w0.114: 119.15,122.2 119.83,122.2 120.35,121.68 120.71,121.68 121.35,121.03 122.53,121.03 v2(122.71,120.86) 123.02,120.55 123.26,120.55 123.82,119.99 123.82,119.25 124.84,118.23 124.84,117.24 125.06,117.02 R68521.2 R68522.1
  BOTTOM w0.102: v1(118.11,124.39) 118.27,124.39 U6539.DN13
BOARD_ID4_TSN: length 153.1
  TOP w0.089: 118.61,122.07 118.28,122.4 118.28,123.06 117.75,123.59 117.75,124.65 118.06,124.96 118.09,124.96 v1(118.11,124.98)
  TOP w0.114: v2(67.13,184.78) 67.1,184.78 67.08,184.81 66.47,184.81 66.09,185.19 66.09,187.47 66.47,187.86 C20001.2 66.88,188.52 67.24,188.88 v2(68.9,188.88) 69.02,188.88 69.38,189.24 69.38,189.77 69.03,190.12 69.03,191.18 69.62,191.77 69.62,192.33 68.15,193.79 v1(68.15,193.95) ; R68525.1 R68524.2 124.41,117.02 124.56,117.17 124.56,118.16 123.57,119.15 123.57,119.78 123.34,120.01 122.96,120.01 122.5,119.55 121.05,119.55 120.85,119.76 120.85,120.77 120.58,121.04 120.25,121.04 119.6,121.69 118.99,121.69 118.61,122.07
  IN1 w0.089: v1(118.11,124.98) 117.75,125.35 117.75,128.83 117.58,128.99 117.58,130.9 116.63,131.85 108.76,131.85 107.87,130.96 107.87,130.35 107.42,129.9 105.06,129.9 104.98,129.82 102.53,129.82 102.03,130.32 98.79,130.32 98.54,130.58 92.63,130.58 92.12,130.07 85.19,130.07 77.44,122.32 v1(76.5,122.32) ; v2(67.13,184.78) 67.13,184.02 69.39,181.76 69.39,181 70.02,180.36 70.02,177.19 71.17,176.04 72.82,176.04 74.34,174.52 77.33,174.52 v2(77.77,174.96)
  BOTTOM w0.102: U6539.DM13 118.32,124.98 v1(118.11,124.98)
  BOTTOM w0.114: v2(77.77,174.96) 77.77,174.65 77.13,174.01 77.13,165.63 76.5,165 v1(76.5,122.32) ; CN29.24 v1(68.15,193.95)
BOARD_ID5: length 14.3
  TOP w0.089: v1(118.11,125.75) 118.11,125.7 117.57,125.16 117.57,123.49 118.08,122.98 118.08,122.12 118.13,122.07
  TOP w0.114: R68527.1 R68526.2 123.08,117.02 122.98,117.12 122.98,118.92 122.6,119.3 120.92,119.3 120.62,119.61 120.62,120.61 120.44,120.79 120.12,120.79 119.45,121.46 118.74,121.46 v4(118.69,121.51) 118.13,122.07
  BOTTOM w0.102: U6539.DK13 118.21,125.75 v1(118.11,125.75)
BOARD_ID6_MIC_SINGLE: length 148.6
  TOP w0.089: v1(117.2,125.75) 116.66,125.21 116.66,123.57 117.06,123.16 117.06,122.25 117.24,122.07
  TOP w0.114: 117.24,122.07 118.38,120.93 119.17,120.93 119.56,120.54 119.56,119.9 121.25,118.21 121.25,117.8 121.2,117.75 121.2,117.12 121.3,117.02 R68528.2 R68529.1 ; v1(69.39,193.93) 69.87,193.44 70.3,193.44 70.48,193.27 70.48,191.36 v2(70.28,191.16) 69.82,190.7 69.82,190.22 70.02,190.01 70.02,188.79 69.21,187.98 68.35,187.98 v2(67.81,187.45) 67.99,187.27 C20002.2
  IN1 w0.089: v1(75.86,122.32) 76.32,121.87 77.31,121.87 84.37,128.93 91.36,128.93 91.61,129.18 98.47,129.18 99.36,130.07 101.77,130.07 102.41,129.44 104.9,129.44 105.19,129.72 107.62,129.72 108.17,130.27 108.17,130.88 108.76,131.47 116.5,131.47 117.14,130.83 117.14,129.05 117.57,128.62 117.57,126.12 v1(117.2,125.75) ; v2(77.01,174.96) 74.28,174.96 72.94,176.3 71.42,176.3 70.28,177.44 70.28,180.62 69.64,181.25 69.64,181.89 67.58,183.94 67.58,187.22 v2(67.81,187.45)
  BOTTOM w0.102: U6539.DK15 117.29,125.75 v1(117.2,125.75)
  BOTTOM w0.114: v1(69.39,193.93) 69.74,193.57 70.4,193.57 70.65,193.32 CN29.29 ; v1(75.86,122.32) 75.86,165.25 76.75,166.14 76.75,174.71 v2(77.01,174.96)
BOARD_ID7: length 5.7
  BOTTOM w0.102: 117.98,119.35 118.16,119.53 118.16,121.57 U6539.DV14
  BOTTOM w0.114: R68531.1 118.84,117.32 118.66,117.5 118.41,117.5 118.21,117.7 R68530.2 117.87,117.91 117.65,118.13 117.65,119.02 117.98,119.35
BOARD_ID8: length 4.3
  TOP w0.114: R68771.2 v2(108.65,112.13) 108.65,112.52 108.5,112.67 108.07,112.67 107.94,112.8 107.94,114.03 108.07,114.17 R68772.1 R68957.2
BOARD_ID8_SIM_TYPE1: length 162.5
  TOP w0.089: 108.4,122.07 108.4,122.3 108.35,122.35 108.35,122.93 108.66,123.24 108.66,125.4 v1(109.04,125.78)
  TOP w0.114: 108.4,122.07 108.4,117.45 108.2,117.24 108.2,116.3 108.58,115.92 108.58,115.54 108.38,115.34 R68957.1 ; R69101.2 135.56,103.33 136.09,103.86 v1(136.09,104.16)
  IN4 w0.089: v2(221.53,116.86) 222.3,116.1 222.3,112.04 218.97,108.71 216.1,108.71 215.06,109.75 210.87,109.75 210.23,110.39 203.5,110.39 202.94,110.94 196.34,110.94 196.13,111.15 194.1,111.15 192.37,112.87 185.03,112.87 183.15,110.99 182.85,110.99 181.71,109.85 181.71,105.03 179.37,102.69 175.26,102.69 173.27,104.67 167.18,104.67 166.59,105.25 162.17,105.25 161.87,104.95 158.64,104.95 157.91,105.69 155.87,105.69 154.99,104.8 151.94,104.8 151.05,105.69 148.38,105.69 148.08,105.38 145.79,105.38 145,104.59 139.7,104.59 139.44,104.85 136.8,104.85 136.11,104.16 v1(136.09,104.16) 136.09,104.64 135.15,105.58 133.62,105.58 132.63,106.58 132.63,107.06 131.47,108.23 130.09,108.23 124.25,114.07 124.25,115.72 123.87,116.1 122.85,116.1 121.25,117.7 121.25,118.46 120.24,119.48 116.43,119.48 115.87,120.03 115.87,120.55 114.83,121.59 113.28,121.59 111.7,123.16 111.55,123.16 111.39,123.33 111.39,127.44 111.17,127.66 109.65,127.66 109.52,127.53 109.52,126.26 v1(109.04,125.78)
  BOTTOM w0.102: v1(109.04,125.78) 109.09,125.78 U6539.DK33
  BOTTOM w0.114: v2(221.53,116.86) 221.86,116.53 221.86,115.9 222.01,115.75 CN49.25
BOARD_ID9: length 2.3
  TOP w0.114: R69028.2 109.8,115.44 v2(110.03,115.21) 109.55,114.73 R68773.2 R68774.1
BOARD_ID9_SIM_TYPE2: length 152.6
  TOP w0.089: v1(109.93,125.12) 109.57,124.76 109.57,123.42 109.67,123.31 109.67,122.53 109.27,122.12 109.27,122.07
  TOP w0.114: R69028.1 109.8,116.74 109.27,117.27 109.27,122.07 ; v1(135.12,104.97) 135.44,104.97 135.56,105.1 R69102.2
  IN4 w0.089: v1(109.93,125.12) 110.41,124.64 110.41,123.34 110.79,122.96 110.79,122.58 111.3,122.07 111.93,122.07 112.82,121.18 114.09,121.18 114.35,120.93 114.35,120.55 114.6,120.29 114.98,120.29 116.2,119.07 117.72,119.07 118.28,118.51 119.17,118.51 120.63,117.05 121.01,117.05 122.47,115.59 122.47,115.08 122.6,114.96 123.49,114.96 124,114.45 124,114.04 130.02,108.02 131.39,108.02 132.38,107.03 132.38,106.45 133.45,105.38 134.72,105.38 v1(135.12,104.97) 135.35,104.97 135.71,104.62 135.71,103.91 135.83,103.78 138.48,103.78 139.06,104.37 145.16,104.37 145.97,105.18 148.13,105.18 148.76,104.54 151.18,104.54 151.3,104.42 155.37,104.42 155.7,104.75 162.17,104.75 162.48,105.05 166.42,105.05 167.69,103.78 170.73,103.78 171.24,104.29 173.27,104.29 175.08,102.49 179.45,102.49 181.91,104.94 181.91,109.75 182.93,110.77 183.21,110.77 185.11,112.67 192.2,112.67 193.97,110.89 195.88,110.89 196.08,110.69 202.56,110.69 203.25,110 210.1,110 210.61,109.5 214.93,109.5 215.97,108.45 219.1,108.45 222.68,112.04 222.68,114.58 v2(223.44,115.34)
  BOTTOM w0.102: v1(109.93,125.12) 110.2,125.39 U6539.DK31
  BOTTOM w0.114: v2(223.44,115.34) 223.35,115.25 CN49.26
BOARD_ID10: length 9.9
  BOTTOM w0.102: R68775.2 107.44,112.41 R68776.1 107.67,113.18 107.61,113.23 107.61,114.67 107.78,114.83 107.78,115.5 107.72,115.56 107.72,115.88 107.94,116.1 107.95,116.1 108.43,116.58 108.43,118.01 108.33,118.11 108.33,121.25 U6539.DW35
BOARD_ID11: length 8.7
  BOTTOM w0.102: U6539.DV35 108.27,121.68 108.08,121.49 108.04,121.39 108.04,121.01 108.12,120.93 108.12,118.01 108.22,117.9 108.22,117.45 v4(108.02,117.24) 108.22,117.04 108.22,116.67 107.86,116.3 107.86,116.3 107.51,115.96 107.51,115.48 107.58,115.41 107.58,114.92 107.39,114.73 R68777.2 R68778.1
BOARD_ID12: length 13.5
  BOTTOM w0.102: U6539.DT32 109.3,122.32 109.3,121.77 109.24,121.59 109.14,121.34 109.14,118.36 v4(109.16,118.34) 109.19,118.31 109.19,117.73 109.11,117.66 109.11,116.17 108.89,115.95 108.89,115.64 108.9,115.63 108.9,114.72 108.86,114.68 108.86,113.52 108.96,113.42 108.96,113.11 108.96,112.69 108.22,111.95 R68793.2 108.22,111.55 107.92,111.25 107.92,111.14
  BOTTOM w0.114: 107.92,111.14 107.92,111.01 107.72,110.8 107.72,110.15 R68794.1
BOARD_ID13: length 9.5
  BOTTOM w0.102: R68859.1 R68858.2 108.21,114.73 108.49,115.02 108.49,115.35 108.48,115.36 108.48,116.11 108.63,116.27 108.63,118.09 108.53,118.19 108.53,120.88 108.58,120.93 108.58,122.95 U6539.DR35
BRIGHT: length 2.7
  BOTTOM w0.114: R439.2 R443.2 R441.1 66.34,187.52 v2(66.06,187.25)
BT_EN: length 42.6
  TOP w0.114: R960.2 169.46,105.33 v1(169.46,105.71)
  IN1 w0.089: v2(200.45,103.53) 200.34,103.42 193.19,103.42 190.55,106.07 189.02,106.07 188.39,105.43 187.75,105.43 187.12,106.07 185.59,106.07 182.61,103.09 175.92,103.09 172.92,106.09 169.84,106.09 v1(169.46,105.71)
  BOTTOM w0.114: v2(200.45,103.53) 199.97,104.01 199.97,106.42 199.44,106.96 198.93,106.96 197.53,108.35 R68690.2
BT_OFF#: length 5.9
  BOTTOM w0.114: CN17.54 192.77,110.4 193.25,109.92 v2(193.58,109.92) 193.97,109.52 193.97,109.12 194.38,108.71 R671.1 194.86,108.71 194.98,108.83 195.62,108.83 195.87,108.58 R68692.1 196.06,108.58 196.29,108.35 R68690.1
BXTALOUT: length 9.9
  BOTTOM w0.102: U8.C10 127.7,183.73 127.27,183.3 127.27,182.24 127.14,182.11 127.14,181.15 126.33,180.34 125.7,180.34 124.73,179.38
  BOTTOM w0.114: R330.1 v2(123.49,177.42) 123.49,177.44 123.62,177.57 123.62,178.58 123.72,178.68 R332.1 124.35,178.68 124.48,178.81 124.48,179.12 124.73,179.38
C_IN_CLK: length 14.6
  TOP w0.089: LH1.2 18.54,129.31 17.83,129.31 17.7,129.18 17.7,128.6 17.26,128.17 16.81,128.17 16.71,128.07 C96553.2 16.33,128.07 16.01,127.75 D13088.2 15.77,128.03 15.62,128.18 15.05,128.18 14.91,128.32 14.5,128.32 14.19,128.02 14.19,127.48 14.52,127.15 15.92,127.15 16.24,126.83 16.24,126.39 15.9,126.04 13.78,126.04 13.27,126.55 13.27,127.68 13.13,127.83 12.95,127.83 CN37.10
C_IN_CLK#: length 14.7
  TOP w0.089: CN37.12 13.02,128.06 13.22,128.06 13.5,127.78 13.5,126.65 13.88,126.27 15.81,126.27 16.02,126.48 16.02,126.73 15.83,126.92 14.43,126.92 13.97,127.38 13.97,128.11 14.4,128.55 15,128.55 15.15,128.4 15.66,128.4 15.77,128.51 D13087.2 16.01,128.84 16.33,128.52 C96553.1 16.71,128.52 16.84,128.39 17.17,128.39 17.47,128.7 17.47,129.28 17.73,129.54 18.52,129.54 LH1.3
C_TX0_HDMI+: length 14.5
  TOP w0.089: v2(16.86,126.07) 17.1,126.31 18.02,126.31 R68232.2
  BOTTOM w0.089: v2(16.86,126.07) 16.58,126.35 15.84,126.35 D13082.2 15.55,126.29 14.3,126.29 13.74,125.73 13.74,123.24 13.09,122.6 12.27,122.6 11.76,123.12 11.76,126.26 11.63,126.39 11.46,126.39 CN37.7
C_TX0_HDMI-: length 14.5
  TOP w0.089: v2(16.86,126.83) 17.16,126.54 18.1,126.54 R68233.2
  BOTTOM w0.089: v2(16.86,126.83) 16.61,126.58 15.82,126.58 D13081.2 15.45,126.51 14.2,126.51 13.51,125.82 13.51,123.34 13,122.83 12.36,122.83 11.98,123.21 11.98,126.35 11.72,126.62 11.41,126.62 CN37.9
C_TX1_HDMI+: length 15.6
  TOP w0.089: CN37.4 12.97,124.85 13.16,124.85 13.28,124.72 13.28,123.49 14.05,122.73 16.14,122.73 16.5,123.08 16.5,123.53 16.18,123.85 14.52,123.85 14.24,124.13 14.24,124.74 14.38,124.88 15.55,124.88 15.69,124.74 D13084.2 15.8,124.48 16.22,124.91 16.69,124.91 16.84,124.77 16.84,123.88 17.49,123.22 18.31,123.22 18.45,123.09 R68230.2
C_TX1_HDMI-: length 15.7
  TOP w0.089: CN37.6 13,125.08 13.25,125.08 13.51,124.82 13.51,123.59 14.14,122.96 16.05,122.96 16.27,123.18 16.27,123.43 16.08,123.62 14.43,123.62 14.02,124.03 14.02,124.83 14.29,125.1 15.59,125.1 15.69,125.21 D13083.2 15.85,125.54 16.25,125.14 16.79,125.14 17.06,124.86 17.06,123.97 17.58,123.45 18.32,123.45 18.45,123.58 R68231.2
C_TX2_HDMI+: length 9.7
  TOP w0.089: R68228.2 18.45,121.07 18.33,121.19 16.85,121.19 16.78,121.27 15.88,121.27 15.47,120.86 D13086.2 15.25,121.13 15.1,121.28 13.85,121.28 13.18,121.94 12.37,121.94 11.76,122.55 11.76,123.23 11.63,123.36 11.43,123.36 CN37.1
C_TX2_HDMI-: length 9.6
  TOP w0.089: R68229.2 18.45,121.55 18.33,121.42 16.95,121.42 16.87,121.5 15.86,121.5 15.44,121.92 D13085.2 15.25,121.71 15.05,121.51 13.94,121.51 13.28,122.17 12.46,122.17 11.98,122.65 11.98,123.33 11.72,123.59 11.44,123.59 CN37.3
CCG5_SWD_CLK_SP: length 8.7
  BOTTOM w0.114: TP13363.1 23.92,55.52 22.75,54.35 21.66,54.35 21.38,54.63 21.38,54.89 21.25,55.01 R68695.2 R68700.1 21.1,53.33 20.37,52.6 20.37,51.97 20.21,51.81 U6555.2
CCG5_SWD_IO_RST#_SP: length 3
  BOTTOM w0.114: U6555.6 20.75,49.81 21.12,50.19 TP13364.1 21.89,49.68 R69011.2
CCG5_VBUS: length 3.3
  BOTTOM w0.305: 12.24,48.03 12.52,48.31 U6555.22
  BOTTOM w0.381: R69057.2 11.89,47.68 12.24,48.03
CCG5_VBUS_C_CTRL_P1: length 73.4
  TOP w0.114: PR8014.2 32.84,97.66 31.28,99.21 31.03,99.21 29.89,100.35 v2(29.64,100.35) 29.13,100.35 v1(29,100.48)
  IN4 w0.089: v1(21,45.49) 21.51,45.49 22.02,46 22.02,46.76 22.65,47.39 22.65,54.25 23.72,55.32 23.72,56.91 23.21,57.42 23.21,59.89 24.25,60.93 24.25,66.39 25.88,68.02 25.88,77.7 25.32,78.25 25.32,80.79 25.7,81.18 25.7,83.59 24.68,84.6 24.68,86.64 24.05,87.27 24.05,93.8 28.06,97.81 29.89,97.81 30.78,98.7 30.78,99.46 29.76,100.48 v1(29,100.48)
  BOTTOM w0.114: R68696.2 21.41,45.21 21.13,45.49 v1(21,45.49) 20.75,45.49 20.01,46.22 18.49,46.22 18.31,46.41 U6555.12
CCG5_VBUS_P_CTRL_P1: length 24.6
  TOP w0.114: v2(8.43,42.69) 9.95,42.69 10.59,42.06 13,42.06 14.52,43.58 20.62,43.58 21.51,44.47 21.51,45.84 v1(21.36,46)
  BOTTOM w0.114: U6555.11 18.81,46.63 18.93,46.5 20.11,46.5 20.62,46 v1(21.36,46) 21.36,45.89 21.71,45.54 22.22,45.54 22.4,45.36 R68697.2 ; v2(8.43,42.69) 8.3,42.82 5.25,42.82 5.17,42.91 Q6593.2
CCG5_VSYS: length 3.7
  BOTTOM w0.254: 14.65,46.12 14.81,46.28 U6555.19
  BOTTOM w0.381: 14.65,46.12 C96865.1 C96862.1 13.33,45.41 13.29,45.45 R69056.2
CCG5_XRES_SP: length 3.9
  BOTTOM w0.114: R68711.2 C96869.1 TP13362.1 20.29,47.09 20.29,47.6 20.08,47.81 U6555.10
CFG_RCOMP: length 8.3
  BOTTOM w0.152: 121.94,165.99 121.94,165.09 U6539.B5
  BOTTOM w0.254: 121.94,165.99 121.94,168.4 122.04,168.5 122.04,169.36 121.64,169.77 121.64,170.63 121.84,170.84 122.09,170.84 122.6,171.35 122.6,171.85 122.47,171.98 R68305.1
CHA_SA0: length 4
  TOP w0.114: R225.2 R228.1 45.52,107.04 46.41,106.15 v2(46.41,105.92)
  BOTTOM w0.114: JDIM1.256 46.32,105.82 v2(46.41,105.92)
CHA_SA1: length 3
  TOP w0.114: v2(44.92,104.25) 44.74,104.43 R229.1 44.74,105.39 45.52,106.17 R226.2
  BOTTOM w0.114: JDIM1.260 45.13,104.47 v2(44.92,104.25)
CHA_SA2: length 4.9
  TOP w0.114: v2(44.75,127.23) 44.75,127.33 45.06,127.64 R227.2
  TOP w0.508: v2(43.79,128.76) 44.12,129.09 R230.1 45.06,129.04 R227.2
  BOTTOM w0.254: JDIM1.166 44.12,128.32 43.79,128.65 v2(43.79,128.76)
CHB_SA0: length 5.5
  TOP w0.114: R25596.2 54.06,104.92 54.06,104.63 54.16,104.53 R25599.2 54.46,104.6 54.46,105.04 54.38,105.13 v2(54.38,105.38) 54.53,105.53 54.85,105.53 55.33,106.02 v2(55.6,106.02)
  BOTTOM w0.114: v2(55.6,106.02) 55.99,106.02 56.18,105.82 JDIM02.256
CHB_SA1: length 9.5
  TOP w0.114: R25597.1 53.8,104.1 53.8,103.16 54.47,102.49 v2(57.56,102.49) 58.37,103.3 R25600.1 58.37,104.47 58.47,104.57 v2(58.47,104.8)
  BOTTOM w0.254: JDIM02.260 58.24,104.82 58.27,104.8 v2(58.47,104.8)
CHB_SA2: length 6.6
  TOP w0.114: R25598.2 57.7,130.32 R25601.2 59.1,130.33 v2(59.71,129.72)
  BOTTOM w0.114: JDIM02.166 58.65,128.32 59.71,129.39 v2(59.71,129.72)
CL_CLK: length 99.2
  IN2 w0.102: v2(197.02,113) 196.69,113 195.5,114.2 192.83,114.2 191.38,115.64 190.24,115.64 189.91,115.97 189.91,117.24 187.75,119.4 185.85,119.4 185.31,119.94 182.19,119.94 182.04,120.09 179.09,120.09 176.98,122.2 170.25,122.2 168.26,120.2 168.26,119.97 166.16,117.88 165.15,117.88 164.51,117.24 164.51,116.1 164.76,115.85 164.76,115.34 164.46,115.03 161.17,115.03 160.17,114.03 158.35,114.03 157.02,112.7 154.49,112.7 154.24,112.44 152.34,112.44 150.31,110.41 141.42,110.41 140.76,109.75 138.68,109.75 135.81,112.62 135.81,116.23 136.65,117.07 136.65,118.69 134.86,120.48 129.01,120.48 128.19,121.31 128.19,123.85 127.3,124.74 126.74,124.74 125.98,125.5 125.06,125.5 v1(124.81,125.75)
  BOTTOM w0.102: U6539.DH3 123.19,126.13 124.05,126.13 124.18,126.01 124.56,126.01 v1(124.81,125.75)
  BOTTOM w0.114: v2(197.02,113) 196.69,112.67 R68945.2
CL_DATA: length 98.6
  IN2 w0.102: v1(124.56,124.81) 124.91,125.17 125.83,125.17 126.64,124.36 127.17,124.36 127.81,123.72 127.81,121.18 128.89,120.1 134.73,120.1 136.32,118.51 136.32,117.37 135.43,116.48 135.43,112.52 138.53,109.42 140.91,109.42 141.57,110.08 150.46,110.08 152.5,112.11 154.38,112.11 154.63,112.37 157.2,112.37 158.01,113.18 160.73,113.18 161.34,113.79 161.34,114.2 161.84,114.7 164.76,114.7 165.15,115.08 165.15,116.1 164.89,116.35 164.89,117.12 165.27,117.5 166.26,117.5 168.69,119.92 168.69,120.15 170.4,121.87 176.83,121.87 178.94,119.76 181.81,119.76 181.96,119.61 185.14,119.61 185.67,119.07 187.57,119.07 189.53,117.12 189.53,115.85 190.09,115.29 191.1,115.29 192.58,113.81 195.24,113.81 v2(195.37,113.69)
  BOTTOM w0.102: U6539.DH4 122.48,126.38 122.74,126.12 122.93,125.93 122.93,125.68 123.11,125.5 123.87,125.5 v1(124.56,124.81)
  BOTTOM w0.114: R68944.2 v2(195.37,113.69)
CL_RST#: length 98.3
  IN2 w0.102: v1(126.66,125.47) 127.71,125.47 128.57,124.61 128.57,121.56 129.2,120.93 135,120.93 136.98,118.94 136.98,116.63 136.19,115.85 136.19,114.2 138.98,111.4 138.98,110.39 139.24,110.13 140.66,110.13 141.27,110.74 150.16,110.74 152.75,113.33 154.05,113.33 154.35,113.03 156.88,113.03 158.22,114.36 160.03,114.36 161.03,115.36 162.08,115.36 162.67,115.95 162.67,116.67 163.88,117.88 164.38,117.88 164.89,118.39 164.89,118.89 165.6,119.61 166.62,119.61 168.23,121.22 168.79,121.22 170.15,122.58 177.72,122.58 178.1,122.2 178.94,122.2 179.73,121.41 180.92,121.41 181.4,120.93 181.91,120.93 182.54,120.29 185.47,120.29 185.97,119.78 188.01,119.78 189.91,117.88 191.05,117.88 191.18,117.75 191.18,116.48 193.09,114.58 196.13,114.58 v2(197.02,113.69)
  BOTTOM w0.102: 125.92,125.48 125.5,125.9 125.5,126.24 125.22,126.51 124.25,126.51 124.12,126.64 123.62,126.64 U6539.DF2
  BOTTOM w0.114: 125.92,125.48 125.93,125.47 v1(126.66,125.47) ; R68943.2 v2(197.02,113.69)
CLK_BIASREF: length 1.4
  TOP w0.203: v1(121.8,126.34) 122.02,126.56 R68443.2
  BOTTOM w0.203: v1(121.8,126.34) 121.8,125.98 U6539.DJ5
CLK_PCIE_LANN: length 165.7
  TOP w0.114: U6521.45 21.49,162.23 21.41,162.14 21.41,161.41 21.51,161.31 21.51,160.61 21.22,160.32 21.13,160.32 v2(20.82,160.02)
  IN1 w0.089: v1(120.92,134.61) 120.92,134.85 120.79,134.97 119.73,134.97 119.38,135.33 119.38,141.19 119.75,141.56 122.92,141.56 123.54,142.19 125.83,142.19 126.29,142.64 126.29,143.28 126.8,143.79 126.8,148.99 126.62,149.17 123.95,149.17 123.19,149.93 123.19,160.47 123.06,160.6 117.4,160.6 116.71,161.29 116.71,162.6 117.27,163.16 117.27,163.52 116.28,164.52 116.28,165.38 115.87,165.78 115.87,166.29 114.98,167.18 114.98,169.59 114.6,169.97 114.6,171.22 113.13,172.69 112.11,172.69 111.63,173.17 104.85,173.17 103.73,172.06 102.25,172.06 100.54,170.34 92.92,170.34 92.83,170.43 90.5,170.43 90.33,170.6 89.35,170.6 89.17,170.43 83.71,170.43 82.85,169.57 68.24,169.57 63.98,173.83 52.93,173.83 50.74,176.02 44.39,176.02 38.02,169.65 38.02,168.55 37.79,168.33 37.79,166.8 35.1,164.11 34.72,164.11 32.38,161.77 28.57,161.77 27.07,160.27 21.79,160.27 21.69,160.37 21.04,160.37 20.82,160.16 v2(20.82,160.02)
  BOTTOM w0.102: v1(120.92,134.61) 120.92,134.48 U6539.CL8
CLK_PCIE_LANP: length 165.8
  TOP w0.114: v2(20.8,160.7) 20.95,160.55 21.13,160.55 21.28,160.7 21.28,161.22 21.18,161.32 21.18,162.14 21.09,162.23 U6521.44
  IN1 w0.089: v2(20.8,160.7) 20.95,160.55 21.76,160.55 21.87,160.45 27,160.45 28.5,161.95 32.31,161.95 34.64,164.28 35.02,164.28 37.61,166.87 37.61,168.4 37.84,168.63 37.84,169.72 44.32,176.2 50.82,176.2 53,174.01 64.05,174.01 68.32,169.74 82.78,169.74 83.64,170.61 89.1,170.61 89.27,170.78 90.4,170.78 90.57,170.61 92.91,170.61 92.99,170.52 100.46,170.52 102.18,172.23 103.66,172.23 104.77,173.35 111.7,173.35 112.19,172.87 113.2,172.87 114.78,171.29 114.78,170.05 115.16,169.67 115.16,167.26 116.05,166.37 116.05,165.86 116.45,165.45 116.45,164.59 117.44,163.6 117.44,163.09 116.89,162.53 116.89,161.36 117.47,160.78 123.13,160.78 123.37,160.54 123.37,150 124.02,149.35 126.69,149.35 126.98,149.06 126.98,143.72 126.46,143.21 126.46,142.57 125.9,142.01 123.62,142.01 122.99,141.39 119.82,141.39 119.55,141.12 119.55,135.4 119.81,135.15 120.86,135.15 120.99,135.02 121.15,135.02 v1(121.57,134.61)
  BOTTOM w0.102: U6539.CL7 121.57,134.48 v1(121.57,134.61)
CLK_PCIE_SSDN: length 173.2
  IN1 w0.089: v1(125.6,138.4) 125.55,138.4 125.32,138.63 125.32,138.76 125.62,139.06 126.32,139.06 128.37,137 130.02,137 131.34,135.68 132.81,135.68 133.44,136.32 134.05,136.32 134.92,135.45 136.09,135.45 137.08,134.47 137.08,124.61 135.94,123.46 135.94,121.46 130.65,116.17 130.65,114.8 125.83,109.99 119.66,109.99 119.07,109.39 118.06,109.39 117.83,109.17 113.26,109.17 112.55,108.45 109.04,108.45 108.58,108.91 104.75,108.91 104.24,108.4 101.62,108.4 100.33,107.11 94.43,107.11 94.08,106.75 92.69,106.75 92.31,106.37 89,106.37 88.57,105.94 86.91,105.94 86.66,105.69 83.57,105.69 83.31,105.43 79.85,105.43 75.99,101.57 75.99,100.86 68.35,93.21 36.22,93.21 33.73,90.72 33.73,89.99 32.41,88.67 32.41,83.56 31.27,82.42 21.28,82.42 20.62,83.08 20.62,84.1 20.82,84.3 21,84.3 21.13,84.17 v2(21.13,83.97)
  BOTTOM w0.089: U6539.CB5 122.27,137.83 122.77,137.83 123.13,137.72 124.56,137.72 124.86,138.02 125.22,138.02 v1(125.6,138.4)
  BOTTOM w0.114: v2(21.13,83.97) 20.71,83.97 20.59,83.85 20.59,83.49 21,83.08 21.14,83.08 R2658.1
CLK_PCIE_SSDN_C: length 2.1
  BOTTOM w0.114: CN16.53 21.35,81.31 21.23,81.43 21.23,82.06 21.44,82.27 R2658.2
CLK_PCIE_SSDP: length 173.3
  IN1 w0.089: v2(21.13,84.71) 20.9,84.48 20.75,84.48 20.44,84.17 20.44,83 21.2,82.24 31.34,82.24 32.58,83.49 32.58,88.59 33.9,89.91 33.9,90.65 36.29,93.04 68.42,93.04 76.17,100.79 76.17,101.5 79.92,105.25 83.38,105.25 83.64,105.51 86.73,105.51 86.99,105.76 88.64,105.76 89.07,106.19 92.39,106.19 92.77,106.58 94.15,106.58 94.51,106.93 100.4,106.93 101.7,108.23 104.31,108.23 104.82,108.73 108.51,108.73 108.96,108.28 112.62,108.28 113.33,108.99 117.9,108.99 118.13,109.22 119.15,109.22 119.74,109.81 125.91,109.81 130.83,114.73 130.83,116.1 136.11,121.38 136.11,123.39 137.26,124.53 137.26,134.54 136.16,135.63 134.99,135.63 134.13,136.5 133.37,136.5 132.74,135.86 131.41,135.86 130.09,137.18 128.44,137.18 126.39,139.23 125.54,139.23 125.14,138.83 125.14,138.55 v1(124.99,138.4)
  BOTTOM w0.089: U6539.CB4 122.7,138.06 122.71,138.04 123.15,137.89 124.48,137.89 v1(124.99,138.4)
  BOTTOM w0.114: v2(21.13,84.71) 20.37,83.94 20.37,83.39 20.73,83.03 R2659.1
CLK_PCIE_SSDP_C: length 2.1
  BOTTOM w0.114: R2659.2 20.78,82.27 21,82.05 21,81.46 20.85,81.31 CN16.55
CLK_PCIE_WLANN: length 82.9
  IN4 w0.089: v1(126,139.85) 125.9,139.85 125.73,139.67 125.73,139.39 125.98,139.14 126.36,139.14 126.77,138.73 126.77,137.84 127.45,137.16 130.25,137.16 131.57,135.84 131.69,135.84 134.27,133.26 134.27,131.99 139.42,126.84 139.42,125.19 140.76,123.85 146.47,123.85 151.3,119.02 151.3,115.34 152.95,113.69 154.35,113.69 155.19,112.85 164.31,112.85 166.42,114.96 169.85,114.96 170.64,115.74 172.54,115.74 172.72,115.92 172.72,116.05 172.54,116.23 v2(172.44,116.23)
  BOTTOM w0.089: v1(126,139.85) 125.57,139.42 125.57,139.14 125.27,138.83 123.07,138.83 U6539.BY3
  BOTTOM w0.114: v2(172.44,116.23) 172.72,115.95 172.74,115.95 172.87,115.82 172.87,115.55 174.42,113.99 177.75,113.99 178.04,113.7 178.04,112.92 178.84,112.11 179.67,112.11 180.01,111.77 183.45,111.77 183.58,111.65 CN17.49
CLK_PCIE_WLANP: length 83
  IN4 w0.089: v2(173.1,116.25) 172.89,116.05 172.89,115.85 172.61,115.57 170.71,115.57 169.92,114.78 166.49,114.78 164.38,112.67 155.11,112.67 154.27,113.51 152.88,113.51 151.13,115.26 151.13,118.94 146.4,123.67 140.69,123.67 139.24,125.12 139.24,126.77 134.09,131.91 134.09,133.18 131.62,135.66 131.49,135.66 130.17,136.98 127.38,136.98 126.59,137.77 126.59,138.66 126.29,138.96 125.91,138.96 125.55,139.32 125.55,139.7 v1(125.39,139.85)
  BOTTOM w0.089: U6539.BY4 122.47,138.7 122.78,139.01 125.19,139.01 125.39,139.21 v1(125.39,139.85)
  BOTTOM w0.114: v2(173.1,116.25) 173.1,115.64 174.52,114.22 177.85,114.22 178.27,113.8 178.27,113.01 178.94,112.34 179.77,112.34 180.11,112 183.45,112 183.6,112.15 CN17.47
CLK_VGA_N: length 97.1
  IN4 w0.089: v1(120.93,133.78) 121.08,133.78 121.2,133.65 121.2,133.5 121.08,133.37 119.93,133.37 119.48,133.83 119.48,145.74 120.95,147.22 122.47,147.22 123.8,148.54 123.8,148.67 125.98,150.85 132.91,150.85 136.72,154.66 137.41,154.66 139.07,156.32 139.07,163.76 132.83,170 131.19,170 127.5,173.68 124.96,173.68 123.79,174.85 123.79,178.4 123.12,179.08 123.12,181.75 122.98,181.89 122.98,185.79 124.63,187.44 124.63,193.82 124.18,194.28 124.18,201.05 125.38,202.26 125.57,202.26 125.66,202.16 v1(125.66,201.84)
  BOTTOM w0.102: v1(120.93,133.78) 120.98,133.72 120.98,133.4 120.82,133.24 U6539.CN8
  BOTTOM w0.114: v1(125.66,201.84) 125.72,201.9 125.92,201.9 126.06,201.76 U8.AD8
CLK_VGA_P: length 97.2
  IN4 w0.089: v1(121.58,133.78) 121.38,133.58 121.38,133.43 121.15,133.19 119.86,133.19 119.3,133.76 119.3,145.82 120.88,147.39 122.4,147.39 123.62,148.61 123.62,148.74 125.9,151.03 132.84,151.03 136.65,154.84 137.33,154.84 138.9,156.4 138.9,163.69 132.76,169.82 131.11,169.82 127.43,173.5 124.89,173.5 123.62,174.77 123.62,178.33 122.94,179 122.94,181.67 122.8,181.81 122.8,185.86 124.46,187.52 124.46,193.75 124,194.21 124,201.16 125.29,202.46 125.49,202.46 v1(125.67,202.64)
  BOTTOM w0.102: U6539.CN7 v1(121.58,133.78)
  BOTTOM w0.114: v1(125.67,202.64) U8.AE8
CLR_CMOS: length 87.3
  TOP w0.114: v2(144.95,97.94) 144.95,98.32 146.98,100.35 147.54,100.35 148.06,100.87 148.06,100.95 148.59,101.47 150.13,101.47 151.01,102.34 U37.19 ; v1(79.44,102.04) 79.34,102.04 78.91,102.47 78.91,103.15 78.67,103.39 Q22.2 78.22,103.65 78.48,103.91 78.69,103.91 78.81,104.04 R409.2 v2(78.15,104.42) 78.15,104.8 78.29,104.93 Q6520.2
  IN1 w0.089: v1(79.44,102.04) 79.67,101.81 79.67,98.83 82.34,96.16 83.38,96.16 84.45,95.09 89.02,95.09 91.02,97.09 91.96,97.09 92.73,96.31 101.62,96.31 101.77,96.16 105.81,96.16 106.19,96.54 117.39,96.54 118.23,97.38 119.63,97.38 120.15,97.9 124.72,97.9 125.17,98.35 133.88,98.35 134.54,97.69 134.79,97.69 135.33,98.22 137.94,98.22 138.48,97.69 144.17,97.69 144.42,97.94 v2(144.95,97.94)
CNV_BRI_DT: length 93.7
  TOP w0.114: R68431.2 130,129.28 v1(130.73,128.55)
  IN2 w0.102: v1(130.73,128.55) 131.36,128.55 134.16,125.75 134.16,123.85 139.34,118.67 139.34,113.1 140.38,112.06 148.28,112.06 149.02,112.8 150.29,112.8 152.2,114.72 154.58,114.72 154.88,115.02 157.01,115.02 157.65,115.67 157.65,116.68 158.85,117.88 160.07,117.88 161.34,119.15 162.61,119.15 162.99,119.53 162.99,120.16 164.13,121.31 164.51,121.31 166.8,123.59 168.24,123.59 168.57,123.92 178.53,123.92 178.79,123.67 180.69,123.67 181.99,122.37 187.7,122.37 188.01,122.07 191.31,122.07 192.7,120.67 192.7,117.37 193.21,116.86 194.86,116.86 v2(195.37,116.35)
  BOTTOM w0.114: CN17.36 195.7,114.9 196.01,115.21 196.01,115.72 v2(195.37,116.35)
CNV_BRI_DT_R: length 17.7
  TOP w0.114: R68431.1 R68409.2 129.34,128.26 v1(129.13,128.47) 128.92,128.26 R68412.1
  IN2 w0.102: v1(129.13,128.47) 128.95,128.29 123.08,128.29 121.81,129.56 117.77,129.56 116.73,128.52 116.73,127.44 v1(116.29,127)
  BOTTOM w0.102: v1(116.29,127) 116.41,127 U6539.DF17
CNV_BRI_RSP: length 105.4
  TOP w0.114: R68428.2 128.54,126.99 v1(129.08,127.53)
  IN2 w0.102: v1(118.13,127.64) 118.54,127.23 118.54,123.67 118.92,123.29 121.15,123.29 121.97,124.1 122.98,124.1 123.36,124.48 123.36,126.01 124.48,127.12 128.67,127.12 v1(129.08,127.53) 129.97,126.64 131.36,126.64 132.76,125.24 132.76,124.28 138.6,118.44 138.6,112.85 140.05,111.4 149.86,111.4 152.5,114.04 154.85,114.04 155.17,114.36 157.28,114.36 157.94,115.02 159.34,115.02 160.31,115.99 160.31,116.77 161.04,117.5 162.07,117.5 163.98,119.4 164.38,119.4 165.27,120.29 166.29,120.29 167.69,121.69 167.69,122.5 168.02,122.83 168.57,122.83 169.01,123.26 178.18,123.26 178.48,122.96 180.39,122.96 181.66,121.69 186.48,121.69 187.5,120.67 190.04,120.67 191.94,118.77 191.94,116.99 193.04,115.9 193.42,115.9 v2(193.87,116.35)
  BOTTOM w0.102: v1(118.13,127.64) 117.96,127.64 U6539.DF15
  BOTTOM w0.114: R665.2 193.9,116.38 v2(193.87,116.35)
