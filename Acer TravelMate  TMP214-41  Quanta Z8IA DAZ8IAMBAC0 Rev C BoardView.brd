# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_EDC7: length 14.7
  BOTTOM w0.079: VRAM2.C13 154.44,196.02 154.12,196.34 152.59,196.34
  BOTTOM w0.165: 142.41,195.44 141.26,195.44 140.92,195.1 U8.T26
  BOTTOM w0.178: 152.59,196.34 152.34,196.34 152.23,196.45 144.76,196.45 143.75,195.44 142.41,195.44
FBA_VREFC_1:
  vias: v2(158.64,189.61) v2(159.8,186.67)
FBA_VREFC_2: length 0.6
  BOTTOM w0.33: v1(159.8,194.82) 159.41,195.22 VRAM2.J14
  vias: v2(159.03,191.54)
FBVDD_EN: length 5.3
  BOTTOM w0.114: U11.4 129.14,211.37 128.81,211.04 128.81,210.06 128.06,209.32 R325.2 127.72,208.91 127.68,208.95 R25469.1 126.42,208.95 v2(126.28,208.81)
FBVDDQ_EN: length 93.9
  TOP w0.114: v2(126.66,208.05) 126.66,207.31 v2(127.3,206.68)
  IN1 w0.089: v1(126.48,184.42) 127.3,183.6 127.3,182.65 129.4,180.55 130.67,180.55 132.79,178.43 134.71,178.43 136.51,176.64 139.44,176.64 141.01,175.06 141.01,173.47 144.01,170.47 154.71,170.47 155.49,169.69 159.39,169.69 160.45,168.64 167.06,168.64 168.43,167.27 168.43,165.77 167.85,165.19 167.85,160.99 169.21,159.63 169.21,156.96 v2(170.56,155.61)
  IN3 w0.102: v1(126.48,184.42) 126.09,184.03 125.25,184.03 124.7,184.58 124.7,186.54 124.51,186.74 124.51,189.13 124.63,189.25 124.63,194.46 124.12,194.97 124.12,195.48 124.35,195.7 124.35,203.61 125.39,204.65 125.39,205.41 126.65,206.68 v2(127.3,206.68)
  BOTTOM w0.114: PR9095.2 170.25,155.3 v2(170.56,155.61) ; R25469.2 127.17,206.8 v2(127.3,206.68)
FOST1: length 21.1
  TOP w0.114: v1(14.75,44.45) 14.02,43.71 3.98,43.71 v2(3.35,44.35)
  BOTTOM w0.114: U6553.5 6.53,48.31 6.4,48.18 4.16,48.18 4.03,48.05 4.03,47.19 3.82,46.98 R69006.1 3.55,46.56 3.78,46.33 3.78,44.78 v2(3.35,44.35) ; R68975.2 14.9,43.8 15.39,44.29 v2(15.39,44.42) 15.36,44.45 v1(14.75,44.45)
G5335-AGND-2: length 1.8
  BOTTOM w0.203: PC9091.2 169.48,157.1 169.58,157.01 v3(170,157.01)
  BOTTOM w0.508: v3(170,157.01) 170,156.99 170,156.99 170,156.46 PC9090.2
  vias: v1(168.66,153.73) v2(169.84,154.71)
G5335-BST-2: length 2.1
  BOTTOM w0.254: PU9004.20 165.28,157.26
  BOTTOM w0.508: PR9089.2 166.01,158 165.28,157.26
G5335-EN-2: length 28.4
  TOP w0.508: v2(159.1,167.14) 158.73,166.77 PQ9086.2
  IN3 w0.508: v2(168.9,154.38) 169.06,154.55 169.06,155.37 168.2,156.23 168.2,157.04 167.3,157.93 167.3,159.28 166.19,160.39 166.19,166.33 164.47,168.05 159.69,168.05 159.1,167.46 v2(159.1,167.14)
  BOTTOM w0.254: PR9096.2 169.9,153.57 v2(169.49,153.97) 169.31,153.97 v2(168.9,154.38) 168.9,154.67 169.02,154.8 PR9095.1 PC9090.1 168.56,156.27 168.3,156.01 168.3,155.49 167.97,155.16 PU9004.2
G5335-FB-2: length 4.7
  BOTTOM w0.254: PR9094.2 PC9089.1 169.92,152.05 169.65,152.31 PR9097.1 168.81,152.31 168.41,152.71 168.41,153.24 167.98,153.66 PU9004.5
G5335-LX-2: length 1.1
  TOP w0.508: PR9092.1 161.69,157.86 v2(162.17,157.37)
  vias: v2(162.35,156.46)
G5335-PFM-2: length 3.6
  TOP w0.114: v2(168.07,154.35) 168.07,154.54 v1(168.44,154.91)
  TOP w0.203: PR9091.1 168.99,156.37 PR9093.2 168.99,155.25 168.65,154.91 v1(168.44,154.91)
  BOTTOM w0.254: v1(168.44,154.91) 168.19,154.66 PU9004.3
G5335-PWRGD-2: length 2.1
  TOP w0.203: PR9090.2 168.17,155.47 v2(167.38,155.47) 167.38,156.02 v1(167.53,156.17)
  BOTTOM w0.254: PU9004.1 v1(167.53,156.17)
G5335-SS-2: length 2.6
  BOTTOM w0.254: PU9004.23 166.78,156.68 167.1,157 167.1,157.02 167.49,157.4 167.71,157.4 168.01,157.1 PC9091.1
G5335-TON-2: length 2.6
  BOTTOM w0.203: PU9004.6 167.84,153.16 168,153 168,152.31 v2(168.12,152.19) 168.14,152.17 168.19,152.17 168.95,151.41 PR9086.1
G5335-VCC-2: length 2.7
  BOTTOM w0.254: 166.48,157.21 166.36,157.09 166,157.09 165.78,156.86 PU9004.21
  BOTTOM w0.508: PR9087.2 167.44,158.17 166.48,157.22 166.48,157.21
G5719LX1.5V:
  vias: v2(8.83,33.42)
GC6_FB_EN: length 5.7
  TOP w0.114: Q16.2 111.52,189.35 112.69,189.35 113.05,189.71 114.16,189.71 v2(114.61,189.26) 114.88,188.99 R394.1 114.88,187.88 114.53,187.53 R372.2
GC6_FB_EN_N17: length 15.9
  TOP w0.114: v1(119.56,182.64) 122.9,185.98 122.9,186.37 122.51,186.76 119.42,186.76 119.2,186.53 118.59,186.53 118.54,186.59 v2(116.5,186.59) 116.12,186.2 114.83,186.2 R372.1
  BOTTOM w0.102: U8.B2 120.84,183.25 120.47,182.88 120.23,182.88 120,182.64 v1(119.56,182.64)
GC6_FB_EN_Q: length 126.3
  TOP w0.089: v1(119.03,123.72) 119.03,123.48 119.3,123.21 119.43,123.21 119.81,122.83 119.88,122.83 120.52,122.2 120.95,122.2 121.08,122.07
  TOP w0.114: 121.08,122.07 121.54,121.61 122.96,121.61 124.33,120.24 124.33,119.45 124.51,119.28 125.52,119.28 126.51,118.28 126.51,117.93 126.64,117.8 126.64,116.61 126.8,116.45 R68356.2 ; Q14.3 110.87,185.2 111.14,184.93 v2(112.06,184.93) 112.06,184.43 111.83,184.2 111.65,184.2 111.58,184.27 v1(111.55,184.27)
  IN1 w0.089: v1(111.55,184.27) 113.81,184.27 114.02,184.48 118.33,184.48 119.04,185.19 122.35,185.19 122.98,185.82 122.98,186.71 124,187.73 124,189.63 124.35,189.99 124.35,196.69 126.94,199.29 126.94,204.77 v2(127.55,205.38)
  IN3 w0.089: 116.63,131.34 116.76,131.21 116.76,128.04 116.84,127.96 116.84,123.64 117.06,123.42 118.72,123.42 v1(119.03,123.72)
  IN3 w0.102: 116.63,131.34 116.5,131.47 116.5,155.09 116.76,155.34 116.76,156.11 115.9,156.97 115.9,157.27 116.38,157.76 116.38,158.67 116.75,159.04 116.97,159.04 117.52,159.58 117.52,160.04 116.89,160.68 116.89,162.33 117.65,163.09 117.65,163.98 117.9,164.23 117.9,165.38 117.52,165.76 117.52,166.27 117.95,166.7 117.95,168.75 117.01,169.69 117.01,169.95 116.76,170.2 116.25,170.2 115.92,170.53 115.92,173.7 112.09,177.54 112.09,178.48 111.76,178.81 111.76,179.37 111.22,179.9 111.22,180.92 110.97,181.17 v1(110.97,181.25)
  BOTTOM w0.102: U6539.DR9 119.87,123.26 119.4,123.72 v1(119.03,123.72)
  BOTTOM w0.114: v2(127.55,205.38) 127.55,205.64 125.78,207.41 125.78,209.57 126.28,210.07 U11.1 ; v1(111.55,184.27) 111.55,184.17 111.42,184.05 111.42,182.78 110.92,182.27 110.92,181.76 110.97,181.71 v1(110.97,181.25)
GPD2: length 3
  TOP w0.079: U6516.D4 155.87,214.9 156.37,214.9 156.74,215.27
  TOP w0.114: 156.74,215.27 156.89,215.41 v2(157.28,215.41) 157.28,215.43 157.68,215.82 R68990.1
GPIO0: length 1.3
  BOTTOM w0.114: U40.17 28.76,57.82 TP104.1
GPIO10_VREF: length 88
  TOP w0.102: 124.69,185.78 v2(124.68,185.77)
  TOP w0.381: v2(124.68,185.77) 124.69,185.76 124.69,185.11 124.04,184.46 v1(123.99,184.46) ; v2(163.57,190.55) 163.02,190 Q20.2 ; R398.2 124.69,185.78
  IN2 w0.508: v2(163.57,190.55) 164.94,190.55 168.19,187.29 168.19,170.25 167.71,169.77 165.14,169.77 163.72,171.19 147.9,171.19 146.98,170.27 144.01,170.27 139.26,175.03 v2(138.98,175.03)
  IN4 w0.508: v1(123.99,184.46) 123.99,183.39 124.38,183 124.38,179.35 125.27,178.46 128.44,178.46 128.82,178.08 128.82,174.39 130.86,172.36 135.56,172.36 136.32,173.12 139.24,173.12 139.87,173.76 139.87,174.65 139.49,175.03 v2(138.98,175.03)
  BOTTOM w0.381: U8.C5 v1(123.99,184.46)
GPO: length 8.5
  TOP w0.114: Q6619.1 30.33,164.68 30.24,164.77 R67474.2 29.26,164.77 28.99,164.51 R67504.1 28.9,163.88 R67524.2 27.75,163.65 v4(26.77,163.65) 25.65,163.65 25.45,163.85 25.19,164.11 24.74,164.11 24.23,164.61 U6521.3
GPP_B18: length 6.9
  BOTTOM w0.102: 96.28,127.88 96.29,127.89 97.46,127.89 99.19,129.62 99.84,129.62 99.93,129.53 100.66,129.53 100.81,129.37 U6539.DA51
  BOTTOM w0.114: 96.28,127.88 R68383.1 95.56,127.88 95.43,128.01 R68377.2
GPP_B23: length 7.4
  BOTTOM w0.102: R68382.2 R68387.1 95.96,128.55 96.09,128.42 96.69,128.42 96.82,128.29 97.25,128.29 99.03,130.07 99.64,130.07 99.78,130.21 101.22,130.21 U6539.CY50
GPP_E2: length 3.4
  TOP w0.114: R68359.2 123.16,124.02 v2(122.85,123.72) 122.14,124.43 v1(121.7,124.43)
  BOTTOM w0.102: U6539.DN5 121.7,124.23 v1(121.7,124.43)
GPP_F7: length 5.4
  BOTTOM w0.102: U6539.DT15 117.8,122.25 117.8,121.31 117.9,121.21 117.9,120.04 117.37,119.5 R68546.1 R68544.2
GPP_F10: length 7.2
  BOTTOM w0.102: U6539.DT14 118.1,122.76 118.41,122.45 118.41,121.43 118.36,121.38 118.36,119.88 118.91,119.34 118.91,118.91 119.3,118.51 119.3,118.03 119.17,117.91 R68547.1
  BOTTOM w0.114: R68545.2 119.55,117.12 119.17,117.5 119.04,117.5 118.92,117.62 R68547.1
GPP_F20: length 6.1
  TOP w0.089: v1(118.11,123.8) 118.11,123.51 118.54,123.09 118.54,122.48 118.94,122.07
  TOP w0.114: R68937.2 121.23,120.77 120.65,121.36 120.31,121.36 119.71,121.97 119.04,121.97 118.94,122.07
  BOTTOM w0.102: v1(118.11,123.8) 118.21,123.8 U6539.DR12
GPP_F21: length 7.5
  BOTTOM w0.102: U6539.DW12 118.56,121.11 118.56,120.01 119.04,119.53 119.44,119.53 119.68,119.29 119.68,118.89 119.55,118.77 119.55,117.75 ; 119.68,115.44 119.55,115.31 R68936.2
  BOTTOM w0.114: 119.68,115.44 119.68,115.72 120.01,116.05 120.01,117.04 119.55,117.5 119.55,117.75
GPP_H0: length 12.4
  BOTTOM w0.102: 109.36,111.14 109.36,111.2 109.62,111.46 109.62,112.29 v2(109.88,112.54) 109.9,112.57 109.9,113.31 109.57,113.64 109.57,114.98 109.93,115.34 109.93,115.63 110.18,115.89 110.18,116.66 109.93,116.91 109.81,116.91 109.57,117.15 109.57,117.54 109.75,117.72 109.75,119.05 109.56,119.23 109.56,121.28 U6539.DW32
  BOTTOM w0.114: 109.36,111.14 109.36,111.06 109.1,110.8 R68537.2 R68541.1
GPP_H1: length 8.5
  BOTTOM w0.102: U6539.DV32 109.59,121.68 109.39,121.49 109.35,121.39 109.35,119.06 109.55,118.87 109.55,117.8 109.37,117.62 109.37,117.07 109.9,116.54 R68542.1 109.9,115.89 109.72,115.72 109.72,115.43 109.22,114.93 R68538.2
GPP_H2: length 23.4
  TOP w0.114: v1(123.13,115.47) 123.26,115.33 R68543.1 R68539.2
  IN4 w0.089: v1(109.93,127.02) 110.31,127.4 111.04,127.4 111.21,127.24 111.21,123.12 111.07,122.98 111.07,122.6 111.35,122.32 112.26,122.32 113.2,121.38 114.65,121.38 115.6,120.43 115.6,120.02 116.35,119.28 117.8,119.28 118.36,118.72 119.53,118.72 120.75,117.5 120.95,117.5 122.73,115.72 122.73,115.59 122.85,115.47 v1(123.13,115.47)
  BOTTOM w0.102: U6539.DF31 110.07,127.02 v1(109.93,127.02)
GPP_RCOMP: length 8.1
  BOTTOM w0.102: R68290.1 95.32,120.09 95.96,120.72 98.65,120.72 99.41,121.48 99.41,122.09 100.03,122.72 100.37,122.72 100.67,123.02 101.13,123.02 U6539.DR51
GPPC_D19: length 4.4
  BOTTOM w0.102: U6539.DW24 113.36,121.15 113.36,120.32 113.68,119.99 113.68,119.38 113.51,119.2 113.51,117.45 TP13290.1
GPPC_E6: length 14.1
  BOTTOM w0.102: 120.95,117.04 120.19,117.8 120.19,118.39 120.38,118.58 120.38,119.59 119.78,120.19 119.78,121.03 119.76,121.05 119.76,122.8 119.89,122.94 120.64,122.94 U6539.DT8
  BOTTOM w0.114: 120.95,117.04 120.95,116.99 121.1,116.84 121.1,116.13 120.67,115.69 120.67,114.47 v2(120.39,114.2) 120.39,114.19 120.26,114.06 119.31,114.06 119.14,114.22 R68396.1 R68390.1 R68391.1
GPU_CHOKE_THERMAL: length 192.2
  TOP w0.114: v1(170.48,116.23) 170.48,118.01 v2(171.24,118.77) 171.17,118.84 171.17,120.97 R68870.2
  IN1 w0.089: v1(85.26,192.94) 85.26,192.87 86.34,191.79 87.17,191.79 87.62,192.25 92.2,192.25 93.62,193.67 100.78,193.67 101.01,193.44 v1(102,193.44) ; v2(140.13,130.35) 139.75,129.97 139.75,125.37 142.03,123.09 147.37,123.09 148.64,124.36 156.13,124.36 158.41,122.07 160.07,122.07 161.59,120.55 164.51,120.55 165.02,120.04 165.02,118.39 166.52,116.89 166.52,116 166.85,115.67 169.13,115.67 169.69,116.23 v1(170.48,116.23)
  IN3 w0.102: v1(97.73,184.38) 97.73,184.4 99.79,186.46 102.92,186.46 103.45,185.92 112.09,185.92 112.31,185.7 112.31,185.32 112.69,184.93 113.33,184.93 114.47,183.79 114.47,181.89 115.29,181.07 115.29,179.63 114.8,179.14 114.8,178.48 115.95,177.34 116.71,177.34 117.14,176.91 117.14,176.15 119.15,174.14 122.12,174.14 123.97,172.28 126.87,172.28 128.44,170.71 128.44,167.79 130.86,165.38 131.62,165.38 132.76,164.23 134.28,164.23 134.58,164.53 137.55,164.53 139.11,162.96 139.11,156.31 139.44,155.98 139.44,147.47 139.62,147.29 139.62,144.55 140.28,143.89 140.28,140.89 139.62,140.23 139.62,130.86 v2(140.13,130.35)
  IN4 w0.089: v1(97.73,184.38) 97.73,187.88 94.1,191.51 91.21,191.51 89.71,190.01 86.28,190.01 85.9,190.4 85.9,190.9 84.75,192.05 84.75,192.55 85.14,192.94 v1(85.26,192.94)
  BOTTOM w0.114: PR9025.1 102.54,193.7 102.54,193.55 102.46,193.46 102.41,193.44 v1(102,193.44) ; v2(140.13,130.35) 139.85,130.35 138.98,131.21 134.16,131.21 131.87,128.93 131.87,127.28 131.62,127.02 R68867.1
GPU_CLK#_C: length 3.2
  TOP w0.114: U6537.48 29.09,127.95 29.17,127.87 29.34,127.87 29.64,128.17 29.64,128.8 30.12,129.28 30.5,129.28 30.68,129.46 C96552.1
GPU_CLK_C: length 3.2
  TOP w0.114: U6537.47 29.15,127.55 29.24,127.64 29.43,127.64 29.87,128.07 29.87,128.71 30.21,129.05 30.53,129.05 30.68,128.9 C96551.1
GPU_D0#_C: length 2.2
  TOP w0.114: U6537.45 29.29,126.75 29.37,126.67 29.79,126.67 29.89,126.77 30.53,126.77 30.68,126.92 C96550.1
GPU_D0_C: length 2.3
  TOP w0.114: U6537.44 29.29,126.35 29.37,126.44 29.88,126.44 29.99,126.54 30.5,126.54 30.68,126.36 C96549.1
GPU_D1#_C: length 2.3
  TOP w0.114: C96548.1 30.68,125.4 30.5,125.22 30.24,125.22 29.99,125.47 29.42,125.47 29.34,125.55 U6537.42
GPU_D1_C: length 2.3
  TOP w0.114: U6537.41 29.34,125.15 29.42,125.24 29.9,125.24 30.15,124.99 30.53,124.99 30.68,124.83 C96547.1
GPU_D2#_C: length 2.5
  TOP w0.114: U6537.39 29.13,124.35 29.3,124.18 29.5,124.18 29.8,123.89 29.95,123.89 30.27,123.57 30.5,123.57 30.68,123.75 C96546.1
GPU_D2_C: length 2.4
  TOP w0.114: U6537.38 29.41,123.95 29.7,123.66 29.85,123.66 30.17,123.34 30.53,123.34 30.68,123.18 C96545.1
GPU_EVENT#: length 82.2
  TOP w0.114: v1(109.65,181.28) v2(110.31,181.28) 110.63,181.6 R25482.2 110.63,182.62 110.92,182.9 110.92,183.16 110.41,183.66 109.67,183.66 109.16,184.16 D4.1
  IN3 w0.102: v1(121.76,120.65) 121.74,120.67 121.56,120.67 120.8,121.43 116.5,121.43 114.93,123.01 114.93,127.45 114.24,128.14 114.24,131.11 114.35,131.21 114.35,151.41 114.42,151.48 114.42,156.94 114.6,157.12 114.6,158.85 115.36,159.61 115.36,162.89 115.74,163.27 115.74,166.9 115.08,167.56 115.08,169.59 114.7,169.97 114.7,173.2 110.87,177.03 110.87,177.92 109.57,179.22 109.57,181.2 v1(109.65,181.28)
  BOTTOM w0.102: v1(121.76,120.65) 121.76,120.67 121.79,120.7 121.79,121 121.81,121.03 121.81,122.02 U6539.DU5
  BOTTOM w0.114: v1(121.76,120.65) 121.79,120.62 121.79,120.16 122.12,119.83 122.8,119.83 123.9,118.74 123.9,117.78 123.55,117.43 123.55,117.05 123.24,116.74 R68278.2
GPU_EVENT#_GPU: length 8.1
  TOP w0.114: D4.2 109.33,186.47 110.49,185.31 110.49,185.11 111.04,184.55 111.04,184.05 111.37,183.71 112.8,183.71 113,183.92 113,184.1 v2(113.2,184.3) 113.3,184.4 R25490.1 114.32,184.4 114.6,184.68 R373.2
GPU_GPIO0: length 10.5
  BOTTOM w0.102: 121.22,181.03 121.82,181.62 122.74,181.62 123,181.88 123.77,181.88 124.02,182.14
  BOTTOM w0.114: R370.1 117.21,179.73 118.52,181.03 121.22,181.03 ; U8.C6 124.02,183.65 124.02,182.14
GPU_GPIO2: length 12.9
  TOP w0.102: v1(123.98,185.29) 123.44,185.29
  TOP w0.114: R373.1 116,184.68 v2(116.5,185.19) 117.9,185.19 118.66,184.43 118.66,182.52 119.13,182.05 119.67,182.05 122.91,185.29 123.44,185.29
  BOTTOM w0.102: v1(123.98,185.29) U8.D6
GPU_GPIO6: length 6.8
  BOTTOM w0.102: U8.A4 122.35,182.08 121.63,182.08 121.03,181.49 118.1,181.49
  BOTTOM w0.114: 118.1,181.49 117.36,180.74 R376.1
GPU_GPIO21: length 10.2
  BOTTOM w0.102: U8.C4 122.32,183.65 122.32,183 122.19,182.88 121.68,182.88 121.53,182.72 121.53,182.31 120.94,181.72 117.9,181.72 117.89,181.7
  BOTTOM w0.114: 117.89,181.7 117.41,181.23 115.44,181.23 v2(115.11,181.56) 115.03,181.63 R404.1
GPU_PEX_RST_HOLD#: length 12.7
  BOTTOM w0.102: U8.D5 123.17,184.45 123.17,182.38 122.64,181.85 121.72,181.85 121.13,181.26 118.33,181.26
  BOTTOM w0.114: 118.33,181.26 118.29,181.26 117.31,180.29 v2(115.06,180.29) 114.53,180.29 114.19,179.94 R399.1
GPU_PWR_GD: length 101.7
  TOP w0.114: v2(117.14,204.49) 119.68,207.03 v2(119.68,209.45)
  TOP w0.254: PR9008.1 v1(105.66,194.1)
  IN1 w0.089: v1(105.66,194.1) 106.04,193.72 106.04,193.11 106.29,192.86 108.33,192.86 108.91,193.44 112.57,193.44 113.13,194 115.67,194 117.52,195.86 117.52,198.02 117.06,198.47 117.06,202.64 117.65,203.22 117.65,206.02 119.63,208 119.63,209.39 v2(119.68,209.45)
  IN4 w0.089: v1(104.06,173.63) 104.31,173.63 104.95,174.27 114.89,174.27 115.74,173.41 116.66,173.41 116.89,173.63 116.89,174.14 116.02,175 116.02,177.14 115.16,178 115.16,178.89 115.87,179.6 115.87,184.05 114.37,185.54 114.37,190.17 115.03,190.83 115.03,194.76 115.49,195.22 115.49,197.51 116.71,198.73 116.71,200.38 117.27,200.94 117.27,204.11 117.14,204.24 v2(117.14,204.49)
  BOTTOM w0.114: PR9079.1 100.4,179.88 102.41,177.87 v2(102.41,174.77) 103.04,174.14 103.63,174.14 104.06,173.71 v1(104.06,173.63) 104.8,172.89 106.98,172.89 107.56,173.48 R69111.1 ; v2(119.68,209.45) 120.02,209.78 R324.1
GPUT_CLK_L: length 18.9
  IN2 w0.102: v1(127.31,184.44) 127.54,184.44 129.61,182.37 130.5,182.37 130.86,182.01 130.86,181.51 131.11,181.25 131.11,180.62 133.9,177.82 135.17,177.82 135.72,177.28 135.72,176.34 135.43,176.04 v2(133.24,176.04)
  BOTTOM w0.102: U8.D9 v1(127.31,184.44)
  BOTTOM w0.114: v2(133.24,176.04) 132.76,176.04 132.5,175.78 R365.1 133.15,175.53 133.26,175.42 v2(133.4,175.42) Q13.4
GPUT_DATA_L: length 22.2
  IN2 w0.102: v2(138.04,175.44) 136.93,175.44 136.19,176.17 136.19,177.44 135.3,178.33 133.9,178.33 131.97,180.26 131.97,181.02 131.87,181.12 131.87,182.27 130.87,183.27 130.11,183.27 129.33,184.05 128.57,184.05 127.77,184.85 U8.D8 v1(125.67,184.45)
  BOTTOM w0.102: v1(125.67,184.45) 125.69,184.48 U8.D8
  BOTTOM w0.114: v2(138.04,175.44) R362.1 137.43,175.99 v2(137.18,176.25) 137.01,176.42 Q13.1
GS_HUB_INT1#: length 202.6
  TOP w0.114: R68998.1 143.57,211.98 143.83,211.72 v2(143.83,211.48) Q6637.3
  IN1 w0.089: v1(123.62,179.12) 123.62,179.22 122.6,180.24 122.6,180.49 122.09,181 119.68,181 119.43,181.25 118.6,181.25 117.84,182.01 114.04,182.01 113.66,181.63 111.76,181.63 v1(111.4,181.99) ; v2(143.83,211.48) 143.19,212.11 141.78,212.11 140.89,211.22 139.87,211.22 139.62,211.48 135.3,211.48 134.67,212.11 131.74,212.11 131.24,211.6 128.82,211.6 127.1,209.88 122.52,209.88 121.36,208.71 121.36,207.36 120.44,206.45 120.44,203.22 v2(119.43,202.21)
  IN3 w0.102: v2(131.24,107.59) 132.25,108.61 132.25,108.86 135.55,112.16 135.55,115.34 137.97,117.75 137.97,118.39 137.23,119.12 137.23,121.31 137.84,121.92 137.84,123.21 138.73,124.1 138.73,127.78 137.87,128.65 137.87,130.93 137.21,131.59 137.21,138.96 137.33,139.09 138.09,139.09 138.43,139.42 138.43,146.83 137.92,147.34 137.92,152.98 136.95,153.95 132,153.95 131.01,154.94 131.01,162.68 129.59,164.11 128.82,164.11 127.81,165.12 126.54,165.12 125.78,165.88 125.78,167.92 123.24,170.46 123.24,170.91 121.53,172.62 118.61,172.62 116.71,174.52 115.75,174.52 114.7,175.57 114.7,176.53 112.21,179.02 112.21,179.61 111.73,180.09 111.73,181.48 111.4,181.81 v1(111.4,181.99) ; v2(119.43,202.21) 117.85,202.21 116.38,200.73 116.38,197.25 115.74,196.62 115.74,195.48 116,195.22 116,192.05 118.36,189.68 118.36,186.33 118.79,185.9 118.79,181.31 120.57,179.54 120.57,179.22 121.08,178.71 122.09,178.71 122.47,179.09 123.59,179.09 v1(123.62,179.12)
  IN4 w0.089: v1(112.16,120.67) 112.69,120.67 113.2,120.16 114.46,120.16 114.59,120.03 114.86,120.03 116.05,118.84 117.67,118.84 118.21,118.31 118.87,118.31 121.46,115.72 121.46,114.96 122.85,113.56 124.2,113.56 129.94,107.82 131.01,107.82 v2(131.24,107.59)
  BOTTOM w0.102: U6539.DV27 112.21,121.68 112.01,121.49 111.97,121.39 111.97,120.86 v1(112.16,120.67)
GS_HUB_INT2#: length 225.9
  IN4 w0.089: v1(97.8,95.59) 97.82,95.61 97.82,95.64 97.83,95.65 97.83,95.83 97.25,96.42 92.5,96.42 92.12,96.03 86.91,96.03 85.9,97.05 79.55,97.05 75.99,93.49 74.34,93.49 72.82,91.97 51.61,91.97 50.41,93.16 50.41,94.1 48.69,95.83 45.74,95.83 45.13,96.44 39.01,96.44 36.75,98.7 36.24,98.7 34.21,100.73 34.21,103.88 32.43,105.66 32.43,115.34 32.66,115.57 32.66,116.25 31.03,117.88 31.03,121.18 28.87,123.34 28.87,131.34 29.1,131.57 29.1,133.27 28.65,133.73 28.65,148.89 29.26,149.5 29.26,157.5 28.62,158.14 28.62,159.66 29.76,160.8 29.76,162.2 29.89,162.33 29.89,163.47 32.05,165.63 34.08,165.63 35.73,167.28 35.73,168.3 36.24,168.81 36.24,174.65 35.48,175.41 35.48,176.55 37.64,178.71 40.69,178.71 42.72,180.74 42.72,182.9 46.91,187.09 49.45,187.09 52.37,190.01 52.37,191.28 53.61,192.53 v1(53.61,193.32)
  BOTTOM w0.102: U6539.DT27 111.92,122.32 111.92,121.77 111.86,121.59 111.76,121.34 111.76,118.94 111.98,118.72 111.98,115.52 111.93,115.47 111.93,113.32
  BOTTOM w0.114: 111.93,113.32 111.93,112.93 111.55,112.54 111.55,111.91 110.74,111.1 110.74,109.75 110.84,109.65 110.84,108.66 110.59,108.4 109.19,108.4 v2(108.99,108.61) 108.78,108.4 108.43,108.4 107.53,107.5 104.86,107.5 103.91,106.55 100.6,106.55 99.99,105.94 99.49,105.94 98.29,104.75 98.29,101.06 97.9,100.67 97.9,95.69 v1(97.8,95.59) ; v1(53.61,193.32) 52.88,193.32 52.5,192.94 R69082.1 52,193.31 51.23,194.08 Q6653.3
H_CATERR#: length 11.5
  TOP w0.089: v1(121.58,160.23) 121.58,160.04 121.76,159.86 123.31,159.86 123.49,160.04
  TOP w0.114: 123.49,160.04 123.6,160.16 128.94,160.16 v2(128.95,160.17) 129.31,160.53 129.31,161.67 129.84,162.2 130.07,162.2 130.22,162.36 R68257.2
  BOTTOM w0.102: v1(121.58,160.23) 121.24,160.57 U6539.M7
H_PROCHOT#: length 274.3
  TOP w0.114: v1(142.16,94.59) 142.29,94.71 Q6509.3 ; PR7007.1 162.9,149.15 v2(163.09,149.34) ; v1(87.52,123.44) 87.7,123.62 R68514.2 87.7,124.45 87.62,124.54 Q6654.1
  IN1 w0.089: v2(124.99,171.7) 126.03,172.74 135.55,172.74 139.54,168.75 140.31,168.75 142.64,166.42 142.64,150.92 143.05,150.52 143.05,148.36 144.47,146.94 144.47,140.43 144.6,140.31 154.15,140.31 155.14,139.32 156.87,139.32 157.27,139.72 159.96,139.72 161.54,141.3 161.54,143.86 163.09,145.41 v2(163.09,149.34)
  IN3 w0.102: v2(167.69,120.04) 167.69,119.66 165.91,117.88 165.02,117.88 164.64,117.5 162.86,117.5 161.97,116.61 161.97,115.97 161.69,115.69 158.14,115.69 157.25,114.8 154.71,114.8 153.89,113.99 153.06,113.99 152.37,113.31 150.92,113.31 148.18,110.56 142.97,110.56 142.16,109.75 138.09,109.75 137.33,110.51 134.54,110.51 132.76,108.73 132.76,106.83 128.82,102.89 121.2,102.89 118.21,99.89 116.5,99.89 114.83,98.22 114.09,98.22 v1(113.33,97.46)
  IN4 w0.089: v1(87.04,102.89) 87.55,103.4 99.97,103.4 104.87,98.5 112.26,98.5 113.3,97.46 v1(113.33,97.46) 113.81,97.94 116.25,97.94 116.63,97.56 116.63,96.8 117.95,95.48 117.95,94.71 118.41,94.26 122.35,94.26 123.21,95.12 135.2,95.12 135.45,94.87 136.34,94.87 137,94.21 141.78,94.21 v1(142.16,94.59) ; v2(163.09,149.34) 163.09,148.64 164.51,147.22 164.51,141.75 164,141.25 164,138.81 165.4,137.41 165.4,136.95 166.75,135.61 166.75,126.95 167.33,126.36 167.33,123.19 167.56,122.96 167.56,120.16 v2(167.69,120.04)
  BOTTOM w0.114: v2(167.69,120.04) 166.72,119.07 166.72,118.69 165.65,117.62 163.99,117.62 163.22,118.39 163.14,118.39 163.02,118.51 PR22.1 162.69,119.22 161.95,119.22 161.42,119.75 PU1.10 ; v1(87.04,102.89) 87.04,103.27 86.48,103.83 85.29,103.83 83.22,105.9 83.22,106.7 83.33,106.82 83.33,109.56 83.22,109.67 83.22,114.69 86.28,117.75 86.28,120.72 87.52,121.97 v1(87.52,123.44) ; R68260.1 125.3,170.43 124.99,170.74 v2(124.99,170.96) v2(124.99,171.7) 124.76,171.93 R68259.1 ; PR7042.1 162.87,149.12 v2(163.09,149.34)
H_PROCHOT#_CCG5: length 123.4
  TOP w0.114: v1(88.15,123.43) 88.34,123.62 R68913.2
  IN1 w0.089: v1(21.89,56.44) 22.37,56.92 25.45,56.92 26.59,58.06 26.59,59.59 26.51,59.66 26.51,65.73 27.05,66.27 28.92,66.27 31.41,68.77 31.41,78.8 34.36,81.75 34.36,87.68 35.68,89 35.68,89.55 37.34,91.21 70.15,91.21 73.58,94.64 73.58,95.15 77.52,99.08 77.52,101.52 79.98,103.98 85.24,103.98 v1(85.54,104.29)
  BOTTOM w0.114: v1(85.54,104.29) 84.22,105.61 84.22,107.74 83.75,108.21 83.75,109.74 83.64,109.85 83.64,114.47 87.55,118.39 87.55,120.16 87.17,120.55 87.17,120.98 88.15,121.96 v1(88.15,123.43) ; R68712.2 21.66,56.67 v1(21.89,56.44)
H_THRMDA1: length 66.6
  TOP w0.114: v2(132.42,168.35) 132.42,168.18 v2(132.91,167.69) 133.45,167.15 135.43,167.15 139.83,162.75 Q6544.2 140.54,160.65 141.49,159.7 Q6544.3
  IN3 w0.102: v2(132.42,168.35) 132.42,170.11 128.31,174.22 124.61,174.22 121.38,177.44 119.81,177.44 118.79,178.46 117.65,178.46 116.81,179.3 116.81,183.08 114.47,185.42 114.47,185.82 113.41,186.89 106.95,186.89 105.89,187.96 97.23,187.96 96.95,188.24 95.8,188.24 95.04,187.48 v2(95.02,187.48)
  BOTTOM w0.114: U2.2 93.56,186.86 93.64,186.94 C96270.1 94.81,186.94 95.02,187.14 v2(95.02,187.48)
H_THRMDC1: length 66.5
  TOP w0.114: v2(131.74,168.35) 131.74,168.09 133.07,166.77 135.3,166.77 139.11,162.96 139.11,158.9 139.26,158.75 Q6544.1
  IN3 w0.102: v2(95.68,187.48) 95.71,187.48 96.2,187.98 96.69,187.98 96.97,187.7 105.74,187.7 106.78,186.66 113.25,186.66 114.22,185.7 114.22,185.34 116.58,182.98 116.58,179.14 117.52,178.2 118.69,178.2 119.68,177.21 121.28,177.21 124.51,173.99 128.21,173.99 131.74,170.46 v2(131.74,168.35)
  BOTTOM w0.114: v2(95.68,187.48) 95.68,187.15 v2(95.25,186.71) 95.02,186.49 C96270.2 93.77,186.49 93.49,186.21 U2.3
H_VCCST_PWRGD: length 7.8
  BOTTOM w0.102: R68493.2 126.31,144.22 125.62,143.53 122.98,143.53 122.85,143.66 122.35,143.66 122.22,143.53 122.22,143.15 121.58,142.52 121.58,142.26 121.23,141.9 121.02,141.9 U6539.BP8
H_VCCST_PWRGD_R: length 88.8
  TOP w0.114: D13107.2 94.2,106.95 94.08,107.08 94.08,107.41 v2(93.52,107.97) 93.22,108.27 D13106.2 93.22,110.05 91.36,111.91 91.36,114.83 v2(90.03,116.16) 87.68,118.51 87.68,120.04 87.18,120.53 87.18,120.63 86.91,120.9 86.13,120.9 85.03,121.99 85.03,124.05 84.48,124.61 78.91,124.61 78.02,125.5 v1(78.02,125.84)
  IN1 w0.089: v1(78.02,125.84) 78.02,126.13 83.23,131.34 101.26,131.34 103.42,133.5 105.84,133.5 106.34,134.01 106.34,134.52 107.06,135.23 110.99,135.23 117.32,141.55 118.66,141.55 119.5,142.39 121.08,142.39 122.09,143.41 122.73,143.41 123.49,144.17 124.89,144.17 v1(125.14,144.42)
  BOTTOM w0.102: v1(125.14,144.42) 125.19,144.47 125.8,144.47 126.21,144.88 C96718.2 127.27,144.68 R68493.1 127.27,143.91 R68491.2
HDD_MS_PWR_EN: length 253
  TOP w0.114: Q6645.2 212.12,103.54 211.78,103.88 R69049.1 R69048.2 211.91,104.57 212.39,105.05 v2(212.39,106.07) ; v1(130.7,113.28) 130.7,118.49 v2(133.52,121.31) R69035.1 ; Q6643.2 230.61,126.57 230.07,127.11 R69044.2 R69042.1 229.25,127.18 v2(229.53,126.9) ; R68736.2 134.02,100.92 v2(134.21,100.73)
  IN1 w0.089: v2(212.39,106.07) 212.01,106.45 208.96,106.45 206.93,108.48 204.01,108.48 203.88,108.35 202.1,108.35 200.96,109.5 197.73,109.5 197.35,109.88 197.18,109.88 196.54,110.51 194.61,110.51 194.36,110.26 184.45,110.26 183.18,111.53 181.02,111.53 180.34,110.84 174.67,110.84 174.44,110.61 173.65,110.61 173.02,111.25 171.09,111.25 169.59,109.75 168.8,109.75 168.7,109.65 161.62,109.65 160.95,108.99 154.27,108.99 153.79,108.51 152.37,108.51 150.75,110.13 141.14,110.13 140.51,109.5 137.71,109.5 134.29,112.93 131.06,112.93 v1(130.7,113.28)
  IN4 w0.089: v1(118.97,94.89) 118.97,95.5 117.39,97.08 117.39,98.45 116.63,99.21 105.1,99.21 100.02,104.29 96.82,104.29 96.57,104.54 91.74,104.54 91.23,105.05 87.63,105.05 v1(87.37,105.31) ; v2(229.53,126.9) 229.53,124.23 228.26,122.96 228.26,117.24 228.52,116.99 228.52,113.94 229.41,113.05 229.41,111.53 228.77,110.89 223.44,110.89 218.99,106.45 216.33,106.45 215.95,106.07 v2(212.39,106.07)
  BOTTOM w0.102: R69079.2 92.76,127.63 92.76,126.26 91.87,125.37 91.38,125.37 90.5,124.48 90.22,124.48
  BOTTOM w0.114: 90.22,124.48 89.96,124.48 88.95,123.47 88.95,121.56 88.36,120.98 88.36,118.18 84.17,113.99 84.17,110.08 84.3,109.95 84.3,108.68 85.14,107.85 86.66,107.85 87.37,107.13 v1(87.37,105.31) ; v1(118.97,94.89) 118.97,94.59 119.17,94.38 121.58,94.38 123.34,96.14 136.42,96.14 137.03,96.75 137.03,97.56 134.21,100.38 v2(134.21,100.73) 135.17,101.7 135.58,101.7 137.23,103.35 137.23,104.42 137.02,104.63 136.33,104.63 134.97,105.99 134.97,108.05 134.09,108.92 134.09,109.43 132.25,111.27 132.25,112.54 132,112.8 131.19,112.8 v1(130.7,113.28)
HDD_MS_PWR_EN_36079458: length 3.3
  TOP w0.114: R69094.2 R69100.2 R69096.1 25.93,83.72 v2(25.83,83.61) 25.38,83.17 Q6656.2
HDD_MS_PWR_EN_GPPB4: length 12.6
  BOTTOM w0.102: U6539.DB42 104.6,129.46 102.17,129.46 101.92,129.71 101.69,129.71 101.61,129.63 100.82,129.63 100.74,129.71 100.04,129.71 99.93,129.82 99.07,129.82 97.35,128.09 96.64,128.09 96.57,128.17 96.42,128.17
  BOTTOM w0.114: 96.42,128.17 95.73,128.17 95.47,128.42 94.28,128.42 94.15,128.29 R69079.1
HDMI_DDCCLK: length 161.9
  TOP w0.114: R68909.1 113.74,118.42 114.09,118.77 v1(114.09,119.73) ; v1(83.89,122.2) 83.61,122.48 R68910.1 83.33,122.86 82.6,123.59 73.96,123.59 70.66,120.29 70.66,111.4 66.34,107.08 66.34,104.86 65.55,104.07 65.55,102.61 64.82,101.88 61.13,101.88 58.34,99.08 58.34,98.32 56.56,96.54 56.56,93.82 v2(56.36,93.62) ; Q62.4 23.53,136.31 23.44,136.39 R69019.2 23.03,136.8 23.29,137.06 28.37,137.06 v2(29,136.42) 29.89,135.53 v2(30.65,135.53)
  IN3 w0.102: v1(114.09,119.73) 114.04,119.73 113.46,119.15 113.08,119.15 111.81,117.88 109.39,117.88 109.27,117.75 108.63,117.75 108.12,118.26 107.49,118.26 106.93,117.7 100.83,117.7 99.18,119.35 94.86,119.35 92.86,117.34 83.05,117.34 v1(82.9,117.5)
  IN4 w0.089: v2(56.36,93.62) 55.95,94.03 52.98,94.03 49.04,97.96 41.8,97.96 40.81,98.96 39.37,98.96 36.98,101.34 36.98,101.52 36.01,102.49 36.01,109.6 35.1,110.51 35.1,117.12 32.94,119.28 32.94,124.48 32.2,125.22 32.2,126.49 30.6,128.09 30.6,130.4 31.41,131.21 31.41,133.25 30.25,134.41 30.25,135.12 v2(30.65,135.53)
  BOTTOM w0.114: v1(83.89,122.2) 83.89,121.18 82.6,119.88 82.6,118.26 82.9,117.95 v1(82.9,117.5)
HDMI_DDCCLK_DDP3: length 7.8
  TOP w0.089: 113.08,122.96 113.29,123.17 113.55,123.17 113.74,123.37 113.74,123.67 v1(113.57,123.85)
  TOP w0.114: 113.08,122.96 113.08,122.67 113.19,122.56 113.34,122.56 113.46,122.44 113.46,122.21 113.34,122.1 113.19,122.1 113.08,121.99 113.08,121.72 113.19,121.6 113.34,121.6 113.46,121.49 113.46,121.26 113.34,121.14 113.19,121.14 113.08,121.03 113.08,120.67 113.33,120.42 113.58,120.42 113.69,120.32 v4(113.69,120.16) 113.69,119.55 113.84,119.4 113.84,118.99 113.71,118.87 R68909.2
  BOTTOM w0.102: U6539.DN23 113.78,123.85 v1(113.57,123.85)
HDMI_DDCDATA: length 162.7
  TOP w0.114: v2(30.65,134.77) 30.02,134.77 29.41,135.38 29.1,135.38 v2(28.87,135.15) 28.73,135.01 Q62.1 ; v2(57.02,93.62) 57.02,96.36 58.85,98.19 58.85,98.7 61.39,101.24 65.07,101.24 65.98,102.16 65.98,103.91 66.85,104.77 66.85,106.85 71.09,111.1 71.09,120.09 74.16,123.16 75.9,123.16 76.02,123.05 76.02,122.95 76.13,122.83 76.36,122.83 76.48,122.95 76.48,123.05 76.59,123.16 76.91,123.16 77.02,123.05 77.02,122.56 77.14,122.45 77.37,122.45 77.48,122.56 77.48,123.05 77.59,123.16 77.82,123.16 77.94,123.05 77.94,122.56 78.05,122.45 78.28,122.45 78.39,122.56 78.39,123.05 78.51,123.16 78.74,123.16 78.85,123.05 78.85,122.56 78.97,122.45 79.19,122.45 79.31,122.56 79.31,123.05 79.42,123.16 79.65,123.16 79.77,123.05 79.77,122.56 79.88,122.45 80.11,122.45 80.22,122.56 80.22,123.05 80.34,123.16 82.27,123.16 83.71,121.71 84.15,121.71 84.5,122.07 v1(84.5,122.2) R68911.1 ; v1(113.05,119.73) 113.05,119.66 113.03,119.63 113.03,119.61 112.57,119.15 R68908.1
  IN3 w0.102: v1(113.05,119.73) 111.58,118.26 108.88,118.26 108.38,118.77 107.36,118.77 106.7,118.11 101.01,118.11 99.33,119.78 94.71,119.78 92.68,117.75 83.48,117.75 v1(83.43,117.8)
  IN4 w0.089: v2(30.65,134.77) 31.92,133.5 31.92,131.09 31.03,130.2 31.03,128.29 32.61,126.72 32.61,125.45 33.37,124.69 33.37,119.48 35.61,117.24 35.61,110.64 36.42,109.83 36.42,102.71 37.38,101.75 37.38,101.5 39.52,99.36 41.09,99.36 42.08,98.37 49.19,98.37 53.13,94.43 56.21,94.43 v2(57.02,93.62)
  BOTTOM w0.114: v1(83.43,117.8) 83.43,118.26 83.04,118.65 83.04,119.73 84.37,121.07 84.37,121.43 84.5,121.56 85.36,121.56 85.64,121.84 85.64,123.16 85.47,123.34 84.68,123.34 84.5,123.16 v1(84.5,122.2)
HDMI_HPD: length 16.9
  TOP w0.114: U6537.21 21.8,124.75 v2(21.79,124.74)
  BOTTOM w0.114: R25297.1 VC2.1 16.53,134.21 R1250.2 v2(17.19,134.72) 18.13,134.72 19.22,133.63 19.22,126.01 20.49,124.74 v2(21.79,124.74)
HDMI_HPD_C: length 6
  BOTTOM w0.114: CN37.19 12.57,133.5 14.14,133.5 14.62,133.02 C616.1 15.92,133.02 R25297.2
HDMI_HPD_DC: length 7.5
  TOP w0.114: v2(31.54,121.94) R68219.1 31.95,121.15 32.17,120.93 R68221.2 32.56,121.56 v2(32.81,121.82) ; v2(30.02,124.48) 29.75,124.75 U6537.40
  BOTTOM w0.114: v2(30.02,124.48) 30.02,123.47 v2(31.54,121.94)
HDMI_HPD_PCH: length 121.7
  TOP w0.114: v1(74.24,96.54) 74.21,96.57 74.21,96.97 74.09,97.1 74.09,99.97 74.59,100.48 74.59,101.11 74.34,101.37 74.34,102.16 75.13,102.94 75.13,106.13 75.52,106.52 75.52,109.64 74.21,110.94 74.21,115.85 72.82,117.24 72.82,119.4 74.79,121.38 79.22,121.38 79.93,120.67 v1(82.09,120.67) ; v2(33.95,119.53) 33.95,119.78 33.58,120.16 v2(33.45,120.16) R68221.1 ; R68247.2 90.72,124.79 90.57,124.64 90.57,123.9 90.72,123.75 R68227.2 90.98,123.29 v1(91.36,122.91)
  IN1 w0.089: v1(91.36,122.91) 91.16,122.91 90.72,122.48 86.18,122.48 85.39,121.69 83.99,121.69 82.98,120.67 v1(82.09,120.67)
  IN4 w0.089: v2(33.95,119.53) 36.11,117.37 36.11,113.31 37.13,112.29 37.13,110.26 36.83,109.95 36.83,102.94 37.79,101.98 37.79,101.65 39.59,99.84 41.19,99.84 42.26,98.78 49.37,98.78 53.26,94.89 56.56,94.89 57.32,94.13 72.44,94.13 74.21,95.91 74.21,96.52 v1(74.24,96.54)
  BOTTOM w0.102: 95.78,124.71 95.91,124.84 97.44,124.84 98.35,125.75 99.25,125.75 99.8,126.31 100.45,126.31 100.65,126.12 U6539.DH52
  BOTTOM w0.114: 95.78,124.71 95.11,124.04 95.11,123.66 94.86,123.42 92.45,123.42 91.99,122.96 91.41,122.96 v1(91.36,122.91)
HDMI_RST#: length 3.7
  TOP w0.114: U6537.35 27.5,122.3 27.86,121.94 28.42,121.94 v2(28.7,121.66) 28.87,121.66 29.41,121.13 C96554.2 R68216.2
HDMI_SCLK: length 17.7
  TOP w0.114: CN37.15 11.98,130.91 11.98,131.85 12.24,132.1 12.87,132.1 13.25,131.72 13.25,131.34 13.63,130.97 D13089.2 14.92,130.97 14.93,130.99 C614.1 R490.2 16.84,130.99 v2(16.94,131.09) ; R68907.2 23.79,133.36 v2(23.79,133.35) R69020.2
  IN3 w0.102: v2(16.94,131.09) 17.95,131.09 20.75,133.88 23.26,133.88 v2(23.79,133.35)
HDMI_SCLK_R1: length 4.2
  TOP w0.114: R69020.1 23.57,131.62 23.57,131.26 24.05,130.78 24.05,130.65 24.66,130.04 24.96,130.04 25.5,129.51 U6537.7
HDMI_SDATA: length 17.7
  TOP w0.114: CN37.16 12.77,130.31 v2(13.75,130.31) D13090.2 15.02,130.31 15.03,130.3 C613.1 R491.2 16.81,130.3 v2(16.94,130.42) ; R68906.2 22.79,133.38 v2(22.78,133.37) R69021.2
  IN3 w0.102: v2(16.94,130.42) 17.48,130.42 17.57,130.32 17.57,128.17 17.74,128 17.92,128 18.08,128.17 18.08,130.58 20.87,133.37 v2(22.78,133.37)
HDMI_SDATA_R2: length 4.2
  TOP w0.114: U6537.8 25.1,129.4 24.81,129.69 24.56,129.69 23.72,130.53 23.72,130.65 23.16,131.21 23.16,131.46 R69021.1
HDMI_SEL#_A1: length 1.8
  TOP w0.114: R68204.2 26.63,121.15 26.3,121.48 U6537.32
HDMI_TXCN: length 148.9
  TOP w0.114: v2(33.7,128.93) 33.57,128.93 33.34,129.16 33.34,129.38 33.06,129.66 31.96,129.66 31.54,129.25 31.31,129.25 31.13,129.43 C96552.2
  IN1 w0.089: v2(33.7,128.93) 33.57,128.93 33.45,129.05 33.45,130.2 35.91,132.66 35.91,140.92 38.22,143.23 38.22,145.13 42.64,149.55 42.64,164.16 43.48,165 45.13,165 45.51,164.61 48.43,164.61 49.7,165.88 57.45,165.88 58.01,166.44 62.99,166.44 63.78,165.66 101.21,165.66 101.78,166.23 106.31,166.23 106.55,166.47 108.71,166.47 111.53,163.65 111.53,159.69 112.01,159.2 112.01,157.7 111.55,157.25 111.55,155.98 116.58,150.95 116.58,146 118.01,144.57 118.94,144.57 119.3,144.93 119.3,145.95 120.26,146.91 123.04,146.91 124.18,145.77 124.94,145.77 v1(125.14,145.56)
  BOTTOM w0.102: v1(125.14,145.56) 125.39,145.31 125.39,145.18 125.27,145.06 124.89,145.06 124.68,145.26 124.37,145.26 124.19,145.44 123.52,145.44 U6539.BF2
HDMI_TXCP: length 149
  TOP w0.114: C96551.2 31.13,128.9 31.26,129.02 31.64,129.02 32.05,129.44 32.96,129.44 33.12,129.28 33.12,129.1 v2(32.94,128.93)
  IN1 w0.089: v1(125.78,145.56) 125.39,145.95 124.25,145.95 123.11,147.09 120.19,147.09 119.12,146.02 119.12,145.01 118.87,144.75 118.08,144.75 116.76,146.07 116.76,151.02 111.73,156.05 111.73,157.17 112.19,157.63 112.19,159.28 111.7,159.76 111.7,163.72 108.78,166.65 106.47,166.65 106.23,166.4 101.71,166.4 101.14,165.83 63.85,165.83 63.06,166.62 57.94,166.62 57.38,166.06 49.63,166.06 48.36,164.79 45.59,164.79 45.2,165.17 43.41,165.17 42.46,164.23 42.46,149.63 38.04,145.21 38.04,143.3 35.73,140.99 35.73,132.74 33.27,130.27 33.27,128.98 33.22,128.93 v2(32.94,128.93)
  BOTTOM w0.102: U6539.BF1 124.16,145.18 124.29,145.06 124.6,145.06 124.8,144.85 125.35,144.85 125.6,145.1 125.6,145.39 v1(125.78,145.56)
HDMI_TXDN0: length 146.2
  TOP w0.114: C96550.2 31.13,126.98 31.26,126.86 33.19,126.86 33.47,126.58 33.47,126.36 v2(33.7,126.13)
  IN1 w0.089: v1(122.17,146.5) 122.14,146.5 121.88,146.24 121.88,146.15 121.69,145.96 120.23,145.96 120.11,145.85 120.11,144.22 118.89,143 117.93,143 115.44,145.49 115.44,151.08 110.87,155.65 110.87,156.17 110.62,156.41 110.62,157.13 111.09,157.6 111.09,159.1 110.61,159.59 110.61,163.68 108.76,165.53 106.58,165.53 106.45,165.66 102.05,165.66 101.46,165.07 63.37,165.07 63.04,164.74 57.07,164.74 56.31,163.98 54.4,163.98 53.11,162.68 45.41,162.68 44.62,163.47 43.35,163.47 43.23,163.34 43.23,159.79 43.73,159.28 43.73,158.65 43.23,158.14 43.23,149.25 38.83,144.85 38.83,141.55 36.55,139.26 36.55,132.28 35.1,130.83 35.1,128.17 34.41,127.48 33.9,127.48 33.57,127.15 33.57,126.26 v2(33.7,126.13)
  BOTTOM w0.102: v1(122.17,146.5) 122.17,146.32 U6539.BD5
HDMI_TXDN1: length 148.4
  TOP w0.114: v2(31.8,125.5) 31.56,125.26 31.27,125.26 31.13,125.4 C96548.2
  IN1 w0.089: v1(125.78,146.45) 125.5,146.73 125.5,146.89 125.25,147.14 124.2,147.14 123.61,147.72 119.79,147.72 119.17,148.34 119.17,150.29 118.79,150.67 118.26,150.67 113.71,155.21 113.71,156.99 113.09,157.61 113.09,159.11 112.62,159.58 112.62,163.8 110.6,165.82 110.6,166.45 109.82,167.23 107.31,167.23 106.8,167.74 106.09,167.74 105.79,167.43 105.79,167.13 105.66,167 101.47,167 100.89,166.42 64.16,166.42 63.38,167.19 56.77,167.19 56.23,166.65 45.74,166.65 44.9,165.81 43.15,165.81 41.78,164.44 41.78,149.83 36.88,144.93 36.88,143.28 35.05,141.45 35.05,133.06 31.62,129.64 31.62,128.73 32.38,127.96 32.38,125.32 32.27,125.21 32.09,125.21 v2(31.8,125.5)
  BOTTOM w0.102: U6539.BE1 124.03,145.95 125.13,145.95 125.26,146.07 125.39,146.07 v1(125.78,146.45)
HDMI_TXDN2: length 150.8
  TOP w0.114: C96546.2 31.13,123.61 31.23,123.52 31.61,123.52 31.8,123.71 v2(31.8,123.97)
  IN1 w0.089: v2(31.8,123.97) 31.92,123.97 32.13,123.77 32.13,123.49 32,123.36 31.29,123.36 31.16,123.49 31.16,129.82 34.59,133.25 34.59,141.75 35.48,142.64 35.48,145.69 35.99,146.2 35.99,147.47 41.32,152.8 41.32,164.74 43.43,166.85 45.08,166.85 46.15,167.92 56.69,167.92 57.02,167.59 63.62,167.59 64.37,166.83 100.74,166.83 101.47,167.56 102,167.56 103.75,169.31 104.85,169.31 106,170.47 110.14,170.47 110.49,170.13 110.49,167.39 111.04,166.83 111.04,166.01 113.34,163.71 113.34,159.5 113.84,159 113.84,157.65 114.24,157.25 114.24,155.65 114.78,155.11 118.9,155.11 119.63,154.38 119.63,149.55 120.48,148.7 121.15,148.7 v1(121.52,148.33)
  BOTTOM w0.102: v1(121.52,148.33) 121.52,148.33 121.52,148.15 U6539.AY7
HDMI_TXDP0: length 146.1
  TOP w0.114: v2(33.02,126.13) 33.07,126.13 33.24,126.31 33.24,126.49 33.1,126.63 31.4,126.63 31.13,126.36 C96549.2
  IN1 w0.089: v1(121.56,146.5) 121.7,146.36 121.7,146.22 121.61,146.14 120.15,146.14 119.93,145.92 119.93,144.29 118.82,143.18 118,143.18 115.62,145.56 115.62,151.15 111.04,155.72 111.04,156.24 110.8,156.49 110.8,157.06 111.27,157.53 111.27,159.18 110.79,159.66 110.79,163.75 108.83,165.71 106.65,165.71 106.52,165.83 101.98,165.83 101.39,165.25 63.29,165.25 62.96,164.92 57,164.92 56.23,164.16 54.33,164.16 53.03,162.86 45.48,162.86 44.7,163.65 43.28,163.65 43.05,163.42 43.05,159.71 43.56,159.21 43.56,158.72 43.05,158.21 43.05,149.32 38.65,144.93 38.65,141.62 36.37,139.34 36.37,132.36 34.92,130.91 34.92,128.24 34.34,127.66 33.83,127.66 33.4,127.23 33.4,126.4 33.13,126.13 v2(33.02,126.13)
  BOTTOM w0.102: U6539.BD7 121.56,146.36 v1(121.56,146.5)
HDMI_TXDP1: length 148.4
  TOP w0.114: v2(31.8,124.74) 31.8,124.9 31.67,125.03 31.33,125.03 31.13,124.83 C96547.2
  IN1 w0.089: v1(125.14,146.45) 125.32,146.64 125.32,146.82 125.18,146.96 124.12,146.96 123.54,147.55 119.71,147.55 118.99,148.26 118.99,150.21 118.72,150.49 118.18,150.49 113.53,155.14 113.53,156.92 112.91,157.54 112.91,159.04 112.44,159.51 112.44,163.73 110.42,165.75 110.42,166.38 109.75,167.05 107.23,167.05 106.73,167.56 106.17,167.56 105.96,167.36 105.96,167.06 105.73,166.82 101.54,166.82 100.96,166.24 64.08,166.24 63.31,167.01 56.85,167.01 56.3,166.47 45.82,166.47 44.98,165.63 43.22,165.63 41.96,164.36 41.96,149.75 37.05,144.85 37.05,143.2 35.22,141.37 35.22,132.99 31.8,129.56 31.8,128.8 32.56,128.04 32.56,125.24 32.34,125.03 32.09,125.03 v2(31.8,124.74)
  BOTTOM w0.102: U6539.BE2 123.58,146.15 125.04,146.15 125.14,146.25 v1(125.14,146.45)
HDMI_TXDP2: length 150.8
  TOP w0.114: C96545.2 31.13,123.16 31.26,123.29 31.59,123.29 31.8,123.09 v2(31.8,122.96)
  IN1 w0.089: v2(31.8,122.96) 31.57,123.19 31.21,123.19 30.98,123.42 30.98,129.89 34.41,133.32 34.41,141.83 35.3,142.72 35.3,145.77 35.81,146.27 35.81,147.54 41.14,152.88 41.14,164.82 43.35,167.03 45.01,167.03 46.07,168.09 56.76,168.09 57.09,167.76 63.7,167.76 64.45,167.01 100.67,167.01 101.39,167.74 101.93,167.74 103.68,169.49 104.77,169.49 105.93,170.65 110.22,170.65 110.66,170.2 110.66,167.46 111.22,166.9 111.22,166.09 113.52,163.79 113.52,159.57 114.02,159.07 114.02,157.73 114.42,157.32 114.42,155.73 114.85,155.29 118.97,155.29 119.81,154.45 119.81,149.63 120.56,148.88 121.22,148.88 121.35,148.75 121.73,148.75 v1(122.14,148.33)
  BOTTOM w0.102: U6539.AY5 122.14,148.13 v1(122.14,148.33)
HOLD#: length 4.4
  BOTTOM w0.114: R68580.2 118.69,107.24 119.04,107.59 R68592.1 119.66,107.75 TP13316.1 120.65,108.02 121.07,107.6 U6548.7
HP-L2: length 15.9
  IN1 w0.381: v2(13.76,32.28) 13.25,31.77 13.25,29.44 15.7,26.99 15.7,25.17 15.35,24.82 v2(15.35,22.28)
  BOTTOM w0.203: 13.97,32.28 14.52,32.28 15.08,32.84 15.84,32.84 16.01,33.01 U20.32
  BOTTOM w0.381: C589.2 15.6,22.52 v2(15.35,22.28) ; v2(13.76,32.28) 13.97,32.28
HP-L3: length 11.2
  BOTTOM w0.381: CN51.4 9.75,26.09 12.95,26.09 14.11,24.93 14.11,21.1 v2(14.52,20.69) 14.52,19.96 14.9,19.58
HP-R2: length 25
  TOP w0.381: v2(18.91,22.53) 18.19,22.53 16.94,23.77 15.96,23.77 v2(15.92,23.82) 15.6,24.13 15.6,25.36 14.9,26.06 14.19,26.06 13.25,27 11.81,27 11.48,27.33 v2(11.48,28.47)
  IN1 w0.381: v2(14.4,33.04) 14.73,32.71 14.73,29.66 17.07,27.32 17.07,25.15 v2(16.38,24.46)
  BOTTOM w0.203: v2(14.4,33.04) 14.52,33.17 15.74,33.17 15.98,33.41 U20.33
  BOTTOM w0.381: C594.2 16.98,23.86 v2(16.38,24.46)
HP-R3: length 4.3
  BOTTOM w0.381: v2(8.71,27.58) 8.55,27.58 6.58,25.61 CN51.3
HP_JD#: length 20.9
  TOP w0.381: v2(12.64,15.26) 12.1,15.26 11.56,15.26 D13095.1 10.58,14.8 v2(10.1,15.28) 9.67,15.71 CN51.6
  IN1 w0.381: v2(12.64,15.26) 12.8,15.41 13.48,15.41 21.8,23.74 21.8,26.79 v2(22.12,27.1)
HWPG: length 110.9
  TOP w0.114: D13106.1 90.92,108.28 91.1,108.1 91.61,108.1 91.76,107.95 91.76,107.5 92.18,107.08 Q6588.3 92.65,106.6 92.37,106.32 92.37,104.29 92.28,104.19 R68490.1 R68492.1 91.1,104.04 90.92,103.85 v2(88.56,103.85) 86.22,103.85 85.42,103.04 85.42,102.46 85.21,102.26 84.12,102.26 82.98,101.11 v1(82.98,100.73) ; Q6651.6 139.33,98.28 139.5,98.46 R25524.2 140,98.96 139.62,99.34 139.62,100.61 140.02,101.01 D60.2 ; v1(150.21,100.99) 150.21,101.01 150.74,101.54 U37.21 ; D60.2 140.61,102 v2(141.68,100.94) 142.08,100.94 142.42,100.6 D62.2 142.42,99.72 141.93,99.23 141.93,98.75 142.21,98.47 142.59,98.47 143.3,99.18 143.3,100.23 143.46,100.38 R25312.1 ; D60.2 D51.2 140.02,104.56 140.3,104.84 D64.2
  IN3 w0.102: v1(150.21,100.99) 150.21,100.66 149.09,99.54 143.99,99.54 142.67,100.86 141.75,100.86 v2(141.68,100.94) 140.99,101.62 138.22,101.62 136.82,100.23 135.43,100.23 135.17,99.97 133.01,99.97 131.41,98.37 125.22,98.37 124.73,97.89 119.1,97.89 118.59,97.38 116.99,97.38 116.2,96.59 111.37,96.59 v2(110.82,96.03)
  IN4 w0.089: v2(110.82,96.03) 110.82,96.52 110.21,97.13 104.24,97.13 101.9,99.46 95.8,99.46 94.53,100.73 v1(82.98,100.73)
HWPG_1.5V: length 197.4
  TOP w0.114: R25524.1 141.01,96.67 142.67,96.67 142.84,96.49 142.84,95.7 v1(143.35,95.2)
  IN2 w0.102: v2(6.52,32.53) 6.52,33.59 8.94,36 8.94,36.98 11.09,39.14 11.09,40.03 12.62,41.55 13.25,41.55 14.19,42.49 16,42.49 16.63,41.86 25.24,41.86 25.7,42.31 29.38,42.31 31.66,44.59 31.66,65.03 32.05,65.43 32.05,77.65 33.63,79.23 33.63,88.43 36.43,91.23 71.83,91.23 73.76,93.16 76.93,93.16 78.61,94.84 93,94.84 93.41,95.25 95.96,95.25 96.62,94.59 116.45,94.59 117.42,95.55 120.09,95.55 121.08,96.54 123.49,96.54 124,96.03 136.8,96.03 137.21,95.63 142.92,95.63 v1(143.35,95.2)
  BOTTOM w0.114: PR284.1 6.16,31.72 6.34,31.9 PR6416.2 6.7,32.35 v2(6.52,32.53)
HWPG_1.8VS5: length 257.5
  TOP w0.114: v2(39.35,144.69) 39.35,144.81 v2(38.88,145.28) 38.38,145.79 PR9256.1 37.07,145.79 PR9255.2 ; v1(154.35,96.67) 154.6,96.92 154.6,97.3 155.72,98.42 155.72,99.69 155.95,99.92 159.51,99.92 159.84,99.59 v1(159.84,99.46) ; v2(178.86,124.36) v2(179.88,124.36) 181.66,122.58 181.66,119.91 181.17,119.43 181.17,112.47 v1(181.2,112.44) ; D62.1 140.12,100.6 140.46,100.94 v2(141.02,100.94)
  IN1 w0.089: v2(43.73,121.56) 43.23,121.05 38.27,121.05 35.22,124.1 35.22,127.28 35.61,127.66 35.61,130.45 37.38,132.23 37.38,136.1 39.54,138.26 39.54,141.18 39.35,141.37 v2(39.35,144.69) ; v1(164.94,139.19) 164.94,139.11 165.02,139.04 165.02,136.93 166.42,135.53 166.42,130.27 169.03,127.66 169.31,127.66 171.72,125.24 177.57,125.24 178.46,124.36 v2(178.86,124.36)
  IN3 w0.102: v2(114.63,95.65) 115.34,96.36 116.33,96.36 117.11,97.15 118.69,97.15 119.2,97.66 125.04,97.66 125.32,97.38 134.69,97.38 135.76,98.45 138.22,98.45 140.71,100.94 v2(141.02,100.94) ; v2(169.39,107.41) 169.87,107.41 170.02,107.57 171.93,107.57 175.95,111.59 180.32,111.59 181.17,112.44 v1(181.2,112.44)
  IN4 w0.089: v2(114.63,95.65) 114.63,95.88 114.07,96.44 111.45,96.44 111.27,96.26 111.27,95.65 111.15,95.53 109.14,95.53 108.83,95.83 101.36,95.83 99.92,97.27 99.52,97.27 97.58,99.21 95.17,99.21 94.53,99.84 82.09,99.84 81.83,99.59 78.15,99.59 76.12,97.56 73.83,97.56 73.32,97.05 72.05,97.05 70.4,95.4 57.96,95.4 57.45,95.91 53.34,95.91 49.3,99.95 47.92,99.95 47.39,100.48 45.51,100.48 41.17,104.82 41.17,118.74 42.72,120.29 42.72,121.15 43.13,121.56 v2(43.73,121.56)
  BOTTOM w0.114: v1(164.94,139.19) 164.77,139.01 PR7080.1 ; v1(154.35,96.67) 154.22,96.54 152.83,96.54 152.06,97.3 150.54,97.3 149.78,96.54 147.92,96.54 147.09,97.38 144.57,97.38 143.39,98.56 143.39,99.25 142.87,99.77 142.18,99.77 v2(141.02,100.94) ; v1(159.84,99.46) 161.72,99.46 163.83,101.58 165.73,101.58 167.43,103.27 167.43,105.46 v2(169.39,107.41)
HWPG_1.35VGFX: length 110
  TOP w0.114: v2(132.1,176.7) 131.97,176.7 130.47,178.2 130.47,178.58 129.28,179.78 128.14,179.78 127.93,179.98 124.76,179.98 124.63,179.85 123.16,179.85 121.86,178.56 118.05,178.56 117.24,177.75 113.03,177.75 112.57,178.2 R69109.1
  TOP w0.203: v1(167.58,156.78) 167.58,157.27 167.77,157.45 PR9088.2 168.19,157.33 PR9090.1
  IN4 w0.089: v2(132.1,176.7) 131.9,176.5 131.9,175.79 132.15,175.54 133.4,175.54 133.52,175.66 135.81,175.66 136.57,176.43 140.89,176.43 141.65,175.66 141.65,172.36 145.26,168.75 166.34,168.75 168.19,166.9 168.19,165.76 167.56,165.12 167.56,160.93 168.19,160.3 168.96,160.3 169.59,159.66 169.59,158.65 170.23,158.01 170.23,157.5 170.48,157.25 170.48,156.49 170.35,156.36 169.59,156.36 169.17,156.78 v1(167.58,156.78)
  BOTTOM w0.114: v2(132.1,176.7) 131.57,177.24 130.98,177.24 130.68,177.54 129.41,177.54 129.1,177.23 129.1,174.04 128.7,173.64 128.42,173.64 128.42,173.64 124.41,173.64 124.13,173.91 120.67,173.91 119.62,174.96 119.62,175.46 119.32,175.76 118.16,175.76 117.84,175.45 112.3,175.45 112.09,175.66 112.06,175.66 112.04,175.69 R69112.1
HWPG_2.5V: length 213.1
  TOP w0.114: v1(179.62,113.2) 180,113.59 v2(180,115.21) 180.39,115.59 180.39,119.02 179.14,120.27 v2(179.14,120.75) ; D64.1 142.6,106.29 v2(142.16,106.73)
  IN1 w0.089: v2(179.14,120.75) 177.49,120.75 176.93,121.31 168.47,121.31 167.46,122.32 167.46,122.55 166.03,123.97 166.03,125.24 165.53,125.75 163.62,125.75 162.35,127.02 159.3,127.02 155.24,131.09 155.24,132.2 151.43,136.01 143.23,136.01 140.38,138.86 140.38,140.15 140.71,140.48 140.71,144.6 139.06,146.25 139.06,163.39 137.87,164.59 136.49,164.59 133.9,167.18 125.75,167.18 123.81,169.12 123.43,169.12 121.97,170.58 121.97,174.75 118.33,178.38 117.5,178.38 116.4,179.47 115.67,179.47 115.03,178.84 110.08,178.84 109.88,179.04 104.67,179.04 104.08,179.63 101.62,179.63 99.92,181.33 93.36,181.33 91.88,179.85 88.18,179.85 82.09,185.95 80.06,185.95 79.55,185.44 79.55,185.19 79.34,184.98 73.38,184.98 73.2,184.81 71.29,184.81 70.53,185.57 69.13,185.57 v2(68.24,184.68)
  IN3 w0.102: v1(179.62,113.2) 179.62,112.67 179.32,112.37 175.73,112.37 172.58,109.22 170.46,109.22 169.78,109.9 166.39,109.9 165.27,111.02 155.16,111.02 153.59,109.45 151.38,109.45 151.05,109.12 151.05,108.61 149.27,106.83 148.38,106.83 147.87,106.32 144.44,106.32 144.06,105.94 142.95,105.94 v2(142.16,106.73)
  BOTTOM w0.114: v2(68.24,184.68) 68.75,184.68 69.09,185.01 PR5000.2 PR5021.2
HWPG_VDDR: length 185.7
  TOP w0.114: v2(178.63,121.18) 178.63,120.39 179.88,119.15 v2(179.88,118.26) 179.88,115.85 179.17,115.13 179.17,113.05 179.09,112.98 v1(179.09,112.9) ; PR5001.2 92.9,179.96 92.66,180.21 PR5002.2 92.37,180.62 v1(92.12,180.87) ; v2(142.82,106.73) 143.09,106.46 143.09,105.24 142.32,104.47 D51.1
  IN1 w0.089: v1(92.12,180.87) 92.63,180.87 93.32,181.56 99.97,181.56 101.7,179.83 104.16,179.83 104.74,179.24 110,179.24 110.15,179.09 115.01,179.09 115.64,179.73 116.45,179.73 117.6,178.58 118.44,178.58 122.22,174.8 122.22,170.71 123.49,169.44 123.87,169.44 125.93,167.38 134.06,167.38 136.66,164.78 137.96,164.78 139.26,163.47 139.26,146.38 140.91,144.73 140.91,140.36 140.63,140.08 140.63,138.88 143.3,136.22 151.51,136.22 155.37,132.36 155.9,132.36 157.27,130.98 157.27,129.59 159.46,127.4 162.61,127.4 164,126.01 166.16,126.01 167.3,124.86 167.3,123.97 168.78,122.5 168.78,121.82 169.08,121.51 177.01,121.51 177.34,121.18 v2(178.63,121.18)
  IN3 w0.102: v2(142.82,106.73) 143.36,106.19 143.94,106.19 144.44,106.7 147.62,106.7 148.84,107.92 149.35,107.92 150.03,108.61 150.03,109.12 150.59,109.67 153.49,109.67 155.14,111.32 165.35,111.32 166.5,110.17 169.83,110.17 170.56,109.45 172.49,109.45 175.64,112.59 178.96,112.59 179.09,112.72 v1(179.09,112.9)
I2C0_SCL_TS: length 7.1
  BOTTOM w0.102: TP13371.1 116.63,117.24 115.74,118.13 115.74,118.99 115.9,119.15 115.9,121.39 115.94,121.49 116.13,121.68 U6539.DV18
