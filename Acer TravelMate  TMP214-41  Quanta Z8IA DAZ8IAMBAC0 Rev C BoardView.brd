# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 158.87,120.85 158.99,120.85 159.02,120.82 159.73,120.82 159.78,120.83 159.83,120.85 159.84,120.86 160.9,120.86 160.9,118.23 161.04,118.1 161.27,118.1 161.34,118.07 161.5,117.72 161.78,117.61 161.93,117.64 162.07,117.73 162.1,117.77 162.46,117.41 162.46,116.12 162.31,115.97 161.84,115.97 161.72,115.85 161.72,115.72 161.59,115.59 161.08,115.59 160.95,115.47 160.07,115.47 159.83,115.7 159.74,115.83 159.61,115.92 159.55,115.98 159.55,116.2 159.56,116.28 159.56,116.31 159.55,116.35 159.55,117.03 159.34,117.24 158.44,117.24 157.55,118.13 157.55,120.7 158.06,121.21 158.52,121.21
GND on TOP (solid shape): 86.02,176.55 86.02,174.77 86.24,174.56 86.23,174.53 86.21,174.46 86.2,174.39 86.32,174.11 86.61,173.99 86.71,174 86.8,174.03 87.1,174.03 87.29,173.84 87.29,173.5 87.17,173.38 85.77,173.38 85.34,173.81 85.31,173.92 85.4,173.99 85.68,174.11 85.8,174.39 85.68,174.68 85.39,174.8 85.33,174.8 85.27,174.78 85.18,174.8 85.14,174.88 85.14,175.7 85.42,175.98 85.42,176.58 85.57,176.73 85.85,176.73
GND on TOP (solid shape): 39.34,164.76 39.34,163.97 39.34,163.97 39.34,160.93 39.19,160.78 38.82,160.78 38.74,160.85 38.74,162.7 38.6,162.84 38.51,162.84 38.46,162.88 36.11,162.88 36.07,162.85 35.78,162.85 35.68,162.82 35.63,162.74 35.62,162.7 35.58,162.7 35.58,161.95 35.38,161.95 35.38,162.7 35.34,162.7 35.33,162.74 35.27,162.82 35.18,162.85 34.94,162.85 34.94,162.9 34.81,162.9 34.81,162.9 34.18,162.9 34.15,162.91 33.65,162.91 33.58,162.84 32.56,162.84 32.3,162.58 32.3,161.31 32.68,160.93 32.68,160.55 32.56,160.42 32.3,160.42 32.18,160.55 32.18,160.93 31.94,161.17 31.95,161.24 31.94,161.3 31.92,161.38 31.92,161.78 31.92,161.82 31.29,162.46 31.29,163.81 31.59,164.11 32.43,164.11 32.74,163.79 36.77,163.79 36.78,163.79 37.69,163.79 37.7,163.8 37.96,163.8 38,163.84 38.01,163.84 38.51,164.34 38.51,164.45 38.5,164.48 38.5,164.83 38.51,164.85 38.51,164.89 38.55,164.93 39.17,164.93
GND on TOP (solid shape): 100.38,183.92 100.38,181.48 100.08,181.18 98.42,181.18 98.24,181.35 98.24,181.71 98.35,181.84 98.39,182.02 98.39,182.03 98.27,182.32 97.98,182.44 97.83,182.41 97.7,182.34 97.64,182.31 97.57,182.33 97.46,182.4 97.34,182.43 97.33,182.43 97.28,182.48 97.28,183.36 97.32,183.43 97.33,183.51 97.33,183.81 97.33,183.84 97.36,183.92 97.43,183.95 98.16,183.95 98.22,183.88 98.42,183.88 98.44,183.85 98.53,183.74 98.67,183.7 98.97,183.7 99.15,183.77 99.22,183.95 99.22,184.05 100.26,184.05
GND on TOP (solid shape): 133.18,190.46 133.19,190.39 133.19,189.68 133.14,189.63 133.14,189.25 133.27,189.13 133.9,189.13 134.16,189.38 134.16,189.76 134.49,190.09 135.21,190.09 135.22,190.1 135.3,190.01 135.3,188.62 136.06,187.86 136.06,187.6 135.94,187.47 135.55,187.47 135.43,187.6 135.43,187.86 135.17,188.11 133.99,188.11 133.71,188.39 133.62,188.39 133.52,188.49 133.01,188.49 132.76,188.74 134.05,188.74 134.05,188.69 134.06,188.64 134.08,188.59 134.1,188.54 134.13,188.5 134.17,188.47 134.21,188.43 134.26,188.41 134.31,188.4 134.36,188.39 134.41,188.39 134.46,188.4 134.51,188.41 134.56,188.43 134.6,188.47 134.64,188.5 134.67,188.54 134.69,188.59 134.71,188.64 134.71,188.69 134.71,188.74 134.71,188.79 134.69,188.84 134.67,188.89 134.64,188.93 134.6,188.97 134.56,189 134.51,189.02 134.46,189.04 134.41,189.05 134.36,189.05 134.31,189.04 134.26,189.02 134.21,189 134.17,188.97 134.13,188.93 134.1,188.89 134.08,188.84 134.06,188.79 134.05,188.74 132.76,188.74 132.25,189.25 132.25,189.51 132.38,189.63 132.51,189.63 132.76,189.89 132.76,190.09 132.76,190.09 132.76,190.4 132.83,190.47
GND on TOP (solid shape): 94.91,186.67 94.91,185.63 94.9,185.63 94.9,185.51 94.9,185.47 94.9,185.27 94.9,185.23 94.9,185.11 94.9,185.07 94.9,184.87 94.9,184.83 94.9,184.72 94.9,184.67 94.9,184.47 94.94,184.36 94.99,184.33 95.04,184.28 95.05,184.28 95.05,184.27 95.74,184.27 95.75,184.26 95.75,184.09 95.74,184.07 95.05,184.07 95.05,184.07 94.99,184.07 94.91,183.98 94.91,183.92 94.9,183.87 94.9,183.67 94.91,183.62 94.91,183.56 94.84,183.56 94.84,182.52 94.53,182.52 94.28,182.27 94.28,181.51 94.15,181.38 93.26,181.38 93.26,182.39 93.52,182.65 93.95,182.65 93.95,183.65 93.92,183.69 93.92,183.87 93.91,183.92 93.89,183.96 93.89,183.98 93.91,184.02 93.92,184.07 93.92,184.67 93.91,184.72 93.89,184.76 93.89,184.78 93.91,184.83 93.95,184.87 93.95,186.17 93.51,186.61 93.51,186.76 93.42,186.85 92.89,186.85 92.77,186.97 92.77,187.35 92.84,187.42 94.16,187.42
GND on TOP (solid shape): 16.22,101.93 16.22,100.46 15.31,99.54 15.31,96.64 16.17,95.77 16.17,95.01 15.84,94.68 14.04,94.68 13.76,94.97 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.27 13.85,102.36 15.78,102.36
GND on TOP (solid shape): outline of 82 points within 106.85,130.03 116.86,138.77
GND on TOP (solid shape): 13.95,119.43 13.95,116.52 16,114.46 16,112.79 15.03,111.82 14.69,111.82 14.65,111.82 14.61,111.84 14.37,111.97 14.1,112.02 13.99,112.01 13.89,111.99 13.8,112.01 13.76,112.09 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78 10.31,122.15 11.23,122.15
GND on TOP (solid shape): 178.25,98.86 178.3,98.81 178.37,98.8 178.75,98.8 178.82,98.81 178.87,98.86 178.88,98.88 178.97,98.88 178.98,98.86 179.04,98.81 179.1,98.8 179.48,98.8 179.55,98.81 179.61,98.86 179.62,98.88 179.7,98.88 179.72,98.86 179.77,98.81 179.84,98.8 180.22,98.8 180.29,98.81 180.34,98.86 180.36,98.88 180.44,98.88 180.46,98.86 180.51,98.81 180.58,98.8 180.96,98.8 181.03,98.81 181.08,98.86 181.09,98.88 181.33,98.88 181.34,98.86 181.4,98.81 181.47,98.8 181.85,98.8 181.91,98.81 181.97,98.86 181.98,98.88 182.2,98.88 182.2,98.82 182.25,98.72 182.35,98.67 182.74,98.67 182.84,98.72 182.89,98.82 182.89,98.88 183.09,98.88 183.09,98.82 183.14,98.72 183.24,98.67 183.65,98.67 183.65,98.14 182.96,97.45 182.32,97.45 182.3,97.43 178.13,97.43 178.06,97.51 178.06,97.9 177.63,98.32 177.63,98.8 178.01,98.8 178.08,98.81 178.13,98.86 178.15,98.88 178.23,98.88
GND on TOP (solid shape): 162.35,145.82 162.35,145.69 161.69,145.02 161.63,145.05 161.42,145.26 161.25,145.33 161.07,145.26 160.85,145.05 160.78,144.87 160.85,144.69 161,144.55 161,144.34 160.48,143.82 160.17,143.82 160.05,143.89 159.91,143.91 159.63,143.79 159.48,143.43 159.4,143.41 159.05,143.41 159.05,143.91 158.92,144.04 158.67,144.04 158.52,144.18 158.52,144.44 158.62,144.53 158.69,144.71 158.62,144.89 158.42,145.09 158.24,145.16 158.06,145.09 157.85,144.88 157.83,144.85 157.81,144.83 157.74,144.78 157.65,144.8 157.14,145.31 157.14,146.33 157.79,146.97 157.87,147 157.94,146.95 157.95,146.94 157.95,146.92 158.19,146.68 158.21,146.68 158.23,146.67 158.37,146.63 158.51,146.67 158.53,146.68 159.7,147.85 160.32,147.85
GND on TOP (solid shape): 89.2,194.21 89.2,192.05 90.02,191.22 90.02,190.4 89.91,190.29 89.52,190.29 89.35,190.47 89.35,190.64 89.32,190.76 89.23,190.85 89.22,190.85 89.17,190.91 88.24,190.91 88.1,191.02 87.93,191.06 87.64,190.94 87.52,190.65 87.52,190.61 87.53,190.55 87.5,190.51 87.5,190.44 87.27,190.21 87.21,190.2 86.6,190.2 86.55,190.21 85.85,190.21 85.8,190.26 85.79,190.34 85.82,190.41 85.83,190.49 85.71,190.78 85.42,190.9 85.13,190.78 85.01,190.49 85.02,190.41 85.04,190.34 85.03,190.25 84.95,190.2 84.65,190.2 84.46,190.4 84.46,191.86 84.67,192.08 84.97,192.08 85.1,191.98 85.26,191.94 85.42,191.98 85.55,192.08 86.31,192.08 87.17,192.94 87.17,193.95 87.68,194.46 88.95,194.46
GND on TOP (solid shape): 114.81,156.33 114.88,156.42 114.99,156.39 115.12,156.29 115.29,156.25 115.36,156.26 115.37,156.25 115.96,156.25 116.01,156.2 116.02,156.19 116.08,156.09 116.17,156.01 116.17,155.94 115.76,155.53 115.76,153.59 115.74,153.59 115.34,153.18 115.74,152.78 115.91,152.81 116.04,152.91 116.04,152.26 115.9,152.11 115.84,151.91 115.96,151.63 116.25,151.51 116.31,151.51 116.37,151.53 116.37,148.36 116.38,148.36 116.76,147.98 116.76,147.6 116.63,147.47 115.8,147.47 115.66,147.33 115.66,147.01 115.49,146.83 115.23,146.83 115.11,146.96 115.11,147.72 114.75,148.08 114.75,148.71 114.34,149.13 114.34,152.15 114.27,152.22 114.27,152.79 114.27,152.8 114.27,154.34 114.44,154.49 114.5,154.71 114.5,154.74 114.49,154.81 114.81,155.13
GND on TOP (solid shape): 28.49,65.81 28.49,65.43 27.73,65.43 27.6,65.3 27.6,64.16 27.86,63.9 28.24,63.9 28.49,64.16 30.02,64.16 30.4,64.54 30.91,64.54 30.91,63.78 30.65,63.52 27.22,63.52 26.25,62.55 26.25,60.66 26.12,60.53 25.77,60.53 25.7,60.6 25.7,60.62 25.78,60.75 25.81,60.89 25.81,60.94 25.8,60.99 25.77,61.07 25.71,61.15 25.7,61.17 25.7,61.26 25.71,61.27 25.79,61.39 25.81,61.53 25.78,61.68 25.7,61.8 25.7,62.14 25.79,62.27 25.83,62.42 25.8,62.57 25.71,62.69 25.7,62.71 25.7,62.75 25.71,62.77 25.8,62.89 25.83,63.04 25.79,63.2 25.7,63.32 25.7,63.77 25.85,64.04 25.76,64.33 25.75,64.34 25.74,64.37 25.76,64.41 25.76,64.42 25.85,64.54 25.88,64.69 25.85,64.84 25.76,64.96 25.73,65.04 25.76,65.11 25.79,65.13 25.82,65.12 25.88,65.1 25.95,65.1 26.08,65.12 26.18,65.17 26.46,65.17 27.22,65.94 28.37,65.94
GND on TOP (solid shape): outline of 83 points within 184.13,97.43 193.85,98.88
GND on TOP (solid shape): 10.96,195.34 10.26,194.26 9.05,193.83 9.16,193.63 9.24,193.42 12.2,193.42 13.42,192.92 13.92,191.7 13.92,190.57 13.84,190.49 13.09,190.49 12.91,190.67 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.2,194.86 9.93,195.47 10.06,195.6 10.7,195.6
GND on TOP (solid shape): 39.29,157.25 39.29,148.61 39.16,148.49 38.78,148.49 38.65,148.61 38.65,148.99 38.4,149.25 36.33,149.25 36.18,149.4 35.29,149.4 34.02,150.67 33.67,150.67 33.59,150.76 33.59,151.07 33.66,151.15 33.83,151.15 34.46,150.52 35.04,150.52 35.45,150.11 36.88,150.11 37.16,150.23 37.28,150.52 37.23,150.72 37.07,150.87 37.02,150.96 37.07,151.05 37.23,151.2 37.28,151.41 37.16,151.69 36.88,151.81 36.85,151.81 36.62,152.04 36.62,152.68 36.72,152.78 36.88,152.78 37.16,152.9 37.28,153.18 37.25,153.35 37.15,153.49 37.11,153.57 37.15,153.64 37.25,153.78 37.28,153.95 37.23,154.15 37.07,154.3 37.02,154.39 37.28,154.84 37.02,155.28 37.07,155.37 37.23,155.52 37.28,155.72 37.16,156.01 36.88,156.13 34.62,156.13 33.7,155.22 33.45,155.22 33.45,155.85 34.27,156.68 34.28,156.68 34.42,156.78 34.52,156.92 34.53,156.93 34.72,157.12 38.65,157.12 38.91,157.38 39.16,157.38
GND on TOP (solid shape): outline of 99 points within 26.72,167.01 34.84,172.11
GND on TOP (solid shape): outline of 106 points within 12.44,151.15 27.3,155.16
GND on TOP (solid shape): outline of 199 points within 9.53,149.99 25.87,154.48
GND on TOP (solid shape): 63.3,182.14 63.34,182.14 63.41,182.11 66.62,182.11 66.72,182.01 66.72,178.46 66.82,178.36 66.82,178.33 66.94,178.04 67.23,177.92 67.4,177.96 67.53,178.06 67.61,178.09 67.69,178.06 67.82,177.96 67.99,177.92 68.23,178 68.38,178.2 69.09,178.2 69.18,178.15 69.17,178.05 69.12,177.94 69.11,177.82 69.51,177.41 69.92,177.82 69.91,177.94 69.86,178.05 69.85,178.15 69.94,178.2 71.04,178.2 71.42,177.82 72.31,177.82 72.69,178.2 72.94,178.2 73.2,177.95 73.2,177.44 73.1,177.34 72.88,177.34 71.59,176.04 65.37,176.04 65.28,176.1 65.28,176.2 65.33,176.31 65.35,176.43 64.94,176.83 64.54,176.43 64.55,176.31 64.6,176.2 64.62,176.13 64.59,176.07 64.59,175.64 64.23,175.28 63.22,175.28 63.2,175.3 63.2,175.98 63.2,176 63.23,176.08 63.24,176.17 63.16,176.42 62.95,176.56 62.91,176.57 62.91,177.95 62.28,178.58 62.28,181.47 62.32,181.55 62.42,181.56 62.5,181.53 62.59,181.52 62.88,181.64 63,181.93 62.99,181.97 62.99,182.02 63.01,182.1 63.09,182.14
GND on TOP (solid shape): outline of 206 points within 128.82,129.94 144.32,148.61
GND on TOP (solid shape): outline of 123 points within 9.65,152.06 26.65,156.25
GND on TOP (solid shape): outline of 128 points within 8.63,152.69 27.41,157.69
GND on TOP (solid shape): 36.09,33.83 36.09,26.32 35.65,25.27 34.6,24.83 31.2,24.83 30.24,24.64 29.43,24.1 18.14,12.81 17.42,12.81 14.2,12.81 12.43,12.07 11.69,10.3 11.69,0.51 4.71,0.51 4.71,2.1 4.41,2.81 3.7,3.11 1.51,3.11 1.51,4.52 1.59,4.62 1.7,4.56 2.48,3.71 3.6,3.39 4.25,3.49 4.83,3.78 5.12,4.03 5.36,4.32 5.63,4.89 5.72,5.51 5.72,5.99 5.1,7.49 3.6,8.11 3.04,8.04 2.52,7.82 2.5,7.8 2.04,7.43 1.7,6.94 1.59,6.88 1.51,6.98 1.51,15.16 2.52,15.16 2.52,10.72 3.25,10 10.68,10 10.68,10.3 11.71,12.79 14.2,13.82 17.62,13.82 17.72,13.82 28.71,24.82 29.85,25.58 31.2,25.85 31.28,25.85 31.29,25.83 31.31,25.85 34.6,25.85 34.94,25.99 35.08,26.32 35.08,33.61 35.33,33.86 36.06,33.86
GND on TOP (solid shape): outline of 328 points within 1.51,132.81 17.19,178.29
GND on TOP (solid shape): outline of 118 points within 0.51,30.19 16.33,83.66
GND on TOP (solid shape): outline of 534 points within 45.99,104.66 65.58,109.76
GND on TOP (solid shape): outline of 753 points within 102.39,145.79 113.51,164.25
GND on TOP (solid shape): outline of 264 points within 1.01,56.26 237.49,218.99
GND on BOTTOM (solid shape): 105.2,113.69 104.19,113.69 104.19,115.08 105.2,115.08
GND on BOTTOM (solid shape): 81.16,198.08 81.16,196.17 81.03,196.05 80.59,196.05 80.53,196.11 80.53,198.08 80.65,198.21 81.03,198.21
GND on BOTTOM (solid shape): 84.82,198.46 84.82,196.55 84.69,196.43 84.25,196.43 84.18,196.49 84.18,198.46 84.31,198.59 84.69,198.59
GND on BOTTOM (solid shape): 85.64,198.46 85.64,196.55 85.52,196.43 85.07,196.43 85.01,196.49 85.01,198.46 85.14,198.59 85.52,198.59
GND on BOTTOM (solid shape): 89.45,198.4 89.45,196.49 89.33,196.36 88.82,196.36 88.69,196.49 88.69,198.4 88.82,198.52 89.33,198.52
GND on BOTTOM (solid shape): 139.24,135.28 139.24,133.37 138.98,133.12 134.41,133.12 134.35,133.18 134.35,135.34 134.54,135.53 138.98,135.53
GND on BOTTOM (solid shape): 193.04,127.27 193.04,126.33 192.59,125.88 189.31,125.88 189.17,126.02 189.17,127.32 189.29,127.45 192.86,127.45
GND on BOTTOM (solid shape): 33.83,171.35 33.83,167.54 32.05,167.54 31.54,167.03 30.91,167.03 30.4,167.54 30.4,171.47 30.53,171.6 33.57,171.6
GND on BOTTOM (solid shape): 73.45,179.09 73.45,177.82 73.25,177.62 70.31,177.62 70.28,177.65 70.28,178.18 70.15,178.31 70.15,178.97 70.4,179.22 73.32,179.22
GND on BOTTOM (solid shape): 90.13,97.6 90.13,96.21 89.83,95.91 87.42,95.91 86.53,96.8 86.53,98.88 86.66,99.01 88.72,99.01
GND on BOTTOM (solid shape): 196.39,105.31 196.39,104.42 196.17,104.2 195.31,104.2 195.21,104.3 195.21,105.4 195.24,105.43 196.26,105.43
GND on BOTTOM (solid shape): 150.26,184.91 150.26,183.64 149.75,183.13 146.6,183.13 146.6,183.74 146.32,184.02 146.32,184.09 146.19,184.22 146.19,185.11 146.37,185.29 149.88,185.29
GND on BOTTOM (solid shape): 24.68,99.08 24.68,98.7 24.05,98.07 20.49,98.07 19.98,97.56 19.98,96.03 19.73,95.78 17.7,95.78 17.44,96.03 17.44,98.83 17.95,99.34 24.43,99.34
GND on BOTTOM (solid shape): 47.85,188.11 47.85,187.04 47.54,186.74 45.21,186.74 44.78,186.31 44.11,186.31 43.86,186.56 43.86,187.86 44.34,188.34 47.62,188.34
GND on BOTTOM (solid shape): 112.95,172.49 112.95,171.73 113.08,171.6 113.46,171.6 113.58,171.47 113.58,169.82 113.46,169.69 112.57,169.69 112.44,169.82 112.44,172.49 112.57,172.62 112.82,172.62
GND on BOTTOM (solid shape): 134.76,211.8 134.76,207.55 134.58,207.37 132.63,207.37 132.56,207.44 132.56,208.94 132.98,209.37 133.05,209.44 133.05,211.74 133.22,211.91 134.66,211.91
GND on BOTTOM (solid shape): 230.38,99.15 231.18,99.15 231.31,99.02 231.32,99.01 231.35,98.93 231.39,98.86 231.39,98.62 230.02,97.25 227.99,97.25 227.89,97.34 227.89,99.13 228.31,99.55 229.98,99.55
GND on BOTTOM (solid shape): 8.68,45.49 8.68,43.46 8.43,43.2 6.4,43.2 6.14,43.46 6.14,43.96 6.01,44.09 4.87,44.09 4.74,44.22 4.74,45.49 4.87,45.62 8.55,45.62
GND on BOTTOM (solid shape): 114.42,103.53 114.42,100.34 114.25,100.17 112.01,100.17 112.01,100.17 111.73,100.17 111.55,100.35 111.55,101.37 111.79,101.6 111.79,103.4 112.04,103.65 114.29,103.65
GND on BOTTOM (solid shape): 149.52,137.41 151.94,137.41 152.95,136.39 152.95,133.32 152.6,132.97 151.48,132.97 151.2,132.69 151.2,131.39 150.92,131.11 147.62,131.11 147.26,131.47 147.26,133.35 145.71,134.9 145.71,138.25 146.02,138.55 148.38,138.55
GND on BOTTOM (solid shape): 196.15,103.13 196.15,103.02 195.83,102.7 195.83,101.92 195.34,101.42 195.34,100.39 195.27,100.32 194.76,100.32 194.74,100.34 194.74,101.65 194.26,102.13 192.96,102.13 192.7,102.38 192.7,103.15 192.89,103.33 195.95,103.33
GND on BOTTOM (solid shape): 81.33,189.51 81.33,188.24 80.92,187.83 80.92,187.32 80.82,187.22 78.91,187.22 78.66,187.47 78.66,187.98 79.17,188.49 80.31,188.49 80.56,188.74 80.56,189.51 80.69,189.63 81.2,189.63
GND on BOTTOM (solid shape): 166.67,126.01 166.67,125.48 166.46,125.27 165.75,125.27 165.63,125.15 165.63,124.68 165.56,124.61 164.13,124.61 163.91,124.82 163.9,124.88 163.88,124.92 163.88,126.01 164,126.13 166.54,126.13
GND on BOTTOM (solid shape): 126.03,179.6 126.03,178.08 125.99,178.03 125.31,178.03 125.23,177.95 124.76,177.95 124.63,177.82 124.63,177.31 124.51,177.19 124.25,177.19 123.87,177.57 123.87,178.33 125.14,178.33 125.39,178.58 125.39,179.47 125.65,179.73 125.9,179.73
GND on BOTTOM (solid shape): 52.34,188.57 52.34,185.67 52.5,185.52 54.68,185.52 55.21,184.98 55.21,182.67 54.83,182.67 54.79,182.68 54.55,182.68 53.54,183.69 49.96,183.69 49.58,184.07 49.58,188.86 49.58,189.2 51.71,189.2
GND on BOTTOM (solid shape): 16.29,134.99 16.28,134.94 16.27,134.91 16.27,134.53 16.28,134.48 16.31,134.43 16.32,134.42 16.32,134.12 16.43,134.01 16.43,133.52 16.19,133.29 14.9,133.29 14.8,133.39 14.8,134.77 15.19,135.16 16.13,135.16
GND on BOTTOM (solid shape): 24.74,39.86 24.74,39.53 25.13,39.14 25.57,39.14 25.83,39.39 26.21,39.39 26.33,39.27 26.33,38.76 26.21,38.63 23.84,38.63 23.72,38.5 23.56,38.5 23.16,38.1 22.91,38.1 22.77,38.23 22.77,39.59 23.09,39.91 24.69,39.91
GND on BOTTOM (solid shape): 31.78,192.3 32.69,192.3 32.81,192.17 32.81,191.58 33.26,191.13 35.58,191.13 35.99,191.54 38.27,191.54 38.49,191.32 38.49,190.04 38.26,189.82 30.56,189.82 30.17,190.21 30.17,192.23 30.34,192.4 31.69,192.4
GND on BOTTOM (solid shape): 172,134.13 172,132.94 172.01,132.88 173.17,131.72 173.43,131.72 173.63,131.52 173.63,130.35 173.53,130.25 173.22,130.25 173.15,130.32 173.15,130.58 172.89,130.83 172.64,130.83 171.86,131.62 171.86,131.74 170.99,132.61 170.99,134.13 171.11,134.26 171.88,134.26
GND on BOTTOM (solid shape): 74.34,186.71 74.34,186.59 74.09,186.33 73.32,186.33 73.07,186.08 73.07,184.81 73.2,184.68 74.85,184.68 74.98,184.55 74.98,183.79 74.85,183.66 70.28,183.66 70.15,183.79 70.15,184.55 70.28,184.68 72.18,184.68 72.31,184.81 72.31,186.33 72.82,186.84 74.21,186.84
GND on BOTTOM (solid shape): 90.01,113.31 90.01,110.31 89.45,109.75 87.04,109.75 87.02,109.78 86.87,109.94 86.66,110 86.62,110 86.56,109.99 85.73,110.83 85.73,113.09 86.07,113.43 89.89,113.43
GND on BOTTOM (solid shape): 92.91,196.21 92.91,195.45 92.91,195.45 92.49,195.04 89.61,195.04 89.51,194.95 89.48,194.92 89.46,194.89 89.33,194.76 89.33,193.57 88.79,193.04 88.79,191.28 88.62,191.11 87.59,191.11 87.42,191.28 87.42,195.6 87.98,196.16 89.61,196.16 89.81,196.36 92.76,196.36
GND on BOTTOM (solid shape): 157.14,117.65 156.19,116.69 154.87,116.69 154.77,116.79 154.77,117.18 154.9,117.31 154.9,118.09 154.99,118.17 155.35,118.17 155.44,118.08 155.44,117.98 155.7,117.73 155.92,117.73 156.13,117.73 156.41,118.01 156.41,118.23 157.14,118.23
GND on BOTTOM (solid shape): 75.24,191.28 75.24,190 75.36,189.89 77.52,189.89 77.64,189.76 77.64,188.74 77.52,188.62 77.28,188.62 77.2,188.64 77.13,188.64 77.07,188.64 76.99,188.62 76.37,188.62 75.74,189.25 74.68,189.25 74.55,189.38 74.55,191.24 74.72,191.41 75.12,191.41
GND on BOTTOM (solid shape): 229.76,104.36 229.76,102.08 229.54,101.86 228.73,101.86 228.51,102.08 228.51,102.6 229.51,102.6 229.51,103.74 229.26,103.74 229.26,102.6 229.01,102.6 229.01,103.74 228.76,103.74 228.76,102.6 228.51,102.6 228.51,104.33 228.7,104.52 229.61,104.52
GND on BOTTOM (solid shape): 108.12,188.12 109.6,188.12 109.66,188.07 109.66,188 109.65,187.95 109.65,187.9 109.65,187.84 109.65,187.78 109.65,187.73 109.66,187.68 109.66,186.69 109.4,186.43 106.46,186.43 106.24,186.64 106.24,188.26 106.34,188.36 107.88,188.36
GND on BOTTOM (solid shape): 186.73,125.29 186.73,123.97 186.62,123.83 186.58,123.66 186.6,123.55 186.64,123.45 186.59,123.39 185.55,123.39 185.46,123.47 185.15,123.47 185.15,123.5 183.67,123.5 183.61,123.55 183.61,125.24 183.75,125.37 186.64,125.37
GND on BOTTOM (solid shape): 138.9,210.48 138.9,209.59 138.79,209.48 138.79,207.44 138.71,207.36 136.73,207.36 136.57,207.52 136.57,207.82 136.57,207.87 136.55,207.93 136.55,208.55 136.57,208.61 136.57,208.66 136.57,208.96 136.57,209.01 136.55,209.07 136.55,210.51 136.61,210.57 138.81,210.57
GND on BOTTOM (solid shape): 118.31,166.08 118.31,164.65 118.41,164.55 118.41,164.28 118.34,164.18 118.23,164.2 117.96,164.47 117.96,165.7 117.59,166.07 117.58,166.13 117.63,166.16 117.69,166.16 117.8,166.27 118.12,166.27
GND on BOTTOM (solid shape): 221.6,111.68 221.6,107.96 221.57,107.95 221.4,107.83 221.31,107.63 221.31,107.62 220.76,107.06 219.81,107.06 219.42,107.45 219.42,108.53 219.94,109.05 219.94,109.58 219.98,109.63 220.55,109.63 220.58,109.66 220.77,109.66 220.95,109.83 220.95,111.69 221.12,111.86 221.43,111.86
GND on BOTTOM (solid shape): 22.64,168.02 22.64,163.51 22.24,163.11 18.7,163.11 18.33,163.47 18.33,164.23 18.26,164.31 13.18,164.31 13,164.49 13,164.87 14.98,164.87 15.29,165.17 17.91,165.17 18.15,165.41 18.15,167.91 18.37,168.13 22.53,168.13
GND on BOTTOM (solid shape): 34.57,69.14 34.57,66.88 34.49,66.81 33.91,66.81 33.19,66.09 30.12,66.09 30.1,66.06 29.64,66.06 29.64,67.21 29.76,67.21 29.81,67.25 29.81,67.63 29.85,67.63 30.04,67.82 31,67.82 31.08,67.9 31.1,67.9 31.67,68.48 32.28,68.48 32.76,68.95 33.93,68.95 34.2,69.22 34.48,69.22
GND on BOTTOM (solid shape): 147.62,208.68 147.7,208.68 148.53,207.85 148.73,207.85 148.99,207.58 148.99,203.96 148.73,203.7 146.63,203.7 146.48,203.86 146.48,204.28 146.83,204.63 146.83,206.53 146.91,206.61 146.91,207.45 146.7,207.67 146.65,207.71 146.25,207.71 146.15,207.82 146.15,208.13 146.27,208.25 146.8,208.25 146.98,208.43 146.98,208.81 147.11,208.94 147.37,208.94
GND on BOTTOM (solid shape): 72.8,175.14 72.79,175.13 72.79,174.8 73.03,174.56 73.22,174.56 73.98,174.56 73.99,174.55 74.82,174.55 75.52,173.85 75.52,170.22 75.37,170.06 70.99,170.06 70.92,170.14 70.92,174.65 71.48,175.21 72.78,175.21
GND on BOTTOM (solid shape): 47.21,170.66 47.29,170.61 47.3,170.52 47.27,170.44 47.26,170.35 47.26,170.31 47.27,170.24 47.02,169.98 46.11,169.98 46.09,170 46.07,170.03 46.04,170.05 46.01,170.06 46.01,170.2 44.57,170.2 44.57,170.45 46.01,170.45 46.01,170.59 46.04,170.6 46.07,170.62 46.09,170.64 46.11,170.66
GND on BOTTOM (solid shape): 162.89,155.06 162.89,153.03 163.11,152.8 163.62,152.8 163.75,152.68 163.75,152.17 163.49,151.91 163.24,151.91 162.73,151.41 162.73,150.01 162.61,149.88 161.59,149.88 160.83,150.64 160.84,150.67 160.85,150.72 160.85,150.77 160.73,151.06 160.45,151.18 159.97,151.66 159.81,151.66 159.56,151.91 159.56,157.41 159.69,157.54 160.41,157.54
GND on BOTTOM (solid shape): 46.77,155.02 46.76,154.95 46.76,154.91 46.78,154.77 46.86,154.66 46.88,154.54 46.79,154.48 46.11,154.48 46.09,154.5 46.07,154.53 46.04,154.55 46.01,154.56 46.01,154.7 44.33,154.7 44.33,154.86 44.41,154.95 46.01,154.95 46.01,155.09 46.04,155.1 46.07,155.12 46.09,155.14 46.11,155.16 46.63,155.16
GND on BOTTOM (solid shape): 17.95,129.46 17.95,126.9 17.83,126.77 17.32,126.77 17.27,126.82 17.27,126.84 17.15,127.12 16.86,127.24 16.68,127.2 16.54,127.08 16.46,127.04 16.38,127.07 16.3,127.15 13.63,127.15 13.51,127.27 13.51,129.65 13.63,129.76 17.65,129.76
GND on BOTTOM (solid shape): 116.64,207.61 116.64,206.41 116.51,206.29 116.45,206.3 116.35,206.28 116.25,206.24 115.71,206.24 115.7,206.23 115.68,206.23 115.58,206.19 115.54,206.08 115.54,205.7 115.54,205.67 115.51,205.6 115.44,205.57 115.16,205.57 115.09,205.64 115.09,205.88 114.72,206.24 114.19,206.24 114.08,206.35 114.08,207.59 114.21,207.72 116.52,207.72
GND on BOTTOM (solid shape): 137.24,112.51 138.9,112.51 139.18,112.23 139.9,112.23 139.99,112.14 139.99,111.34 139.92,111.27 139.84,111.26 139.78,111.24 139.72,111.25 139.45,111.14 139.34,110.87 139.34,110.8 139.36,110.74 139.37,110.71 138.91,110.26 138.28,110.26 136.76,111.78 135.81,111.78 135.57,112.02 135.57,112.39 135.57,112.4 135.57,112.56 135.81,112.8 136.95,112.8
GND on BOTTOM (solid shape): 44.22,125.1 44.25,125.09 44.25,124.95 46.01,124.95 46.01,125.09 46.19,125.09 46.32,124.96 46.5,124.92 46.6,124.93 46.69,124.97 46.77,124.99 46.83,124.94 46.86,124.89 46.45,124.48 46.11,124.48 46.09,124.5 46.07,124.53 46.04,124.55 46.01,124.56 46.01,124.7 44.25,124.7 44.25,124.65 44.03,124.65 43.93,124.55 43.68,124.55 43.58,124.65 43.58,125.03 43.65,125.1
GND on BOTTOM (solid shape): 154.12,118.94 154.12,116.96 154.35,116.74 154.35,114.96 154.03,114.64 153.33,114.64 153.21,114.77 153.21,115.08 153.1,115.2 153.11,115.26 153.11,115.3 152.99,115.58 152.7,115.7 152.45,115.62 152.31,115.4 152.3,115.38 152.26,115.34 151.81,115.34 151.68,115.47 151.68,117.37 151.89,117.57 151.89,118.82 152.18,119.11 153.61,119.11 153.63,119.12 153.94,119.12
GND on BOTTOM (solid shape): 46.01,151.49 46.04,151.53 46.09,151.52 46.14,151.48 46.19,151.44 46.25,151.43 46.63,151.43 46.85,151.21 46.83,151.14 46.83,151.1 46.85,150.98 46.92,150.87 46.93,150.76 46.84,150.7 46.37,150.7 46.14,150.94 46.11,150.96 46.08,151.01 46.04,151.05 46.01,151.06 46.01,151.2 44.33,151.2 44.33,151.45 46.01,151.45
GND on BOTTOM (solid shape): 167.37,165.92 167.71,165.71 168.05,165.92 168.55,165.92 168.95,162.59 169.65,159.31 169.65,159.31 169.65,159.1 169.48,158.92 168.47,158.92 168.34,159.18 168.07,159.28 168.02,159.28 168.02,159.98 167.15,160.85 167.15,165.75 167.32,165.92
GND on BOTTOM (solid shape): 108.25,195.48 111.68,195.48 111.81,195.35 111.81,194.43 111.95,194.28 113.03,194.28 113.33,194.59 113.66,194.59 113.91,194.33 113.91,193.01 113.65,192.75 113.64,192.75 113.57,192.7 113.54,192.63 113.53,192.63 108.55,192.63 108.3,192.38 108.3,192.22 108,191.92 106.21,191.92 106,192.12 106,193.26 106.03,193.34 106.03,193.5 106,193.58 106,193.94 106.03,194.03 106.04,194.1 106.03,194.18 106,194.26 106,194.67 106,194.67 106,195.01 106.45,195.45 106.59,195.45 107.13,195.98 107.74,195.98
GND on BOTTOM (solid shape): 19.73,72.16 19.79,72.16 19.79,72.05 19.84,71.94 19.95,71.9 20.25,71.9 20.3,71.91 20.35,71.93 20.4,71.91 20.45,71.9 20.75,71.9 20.8,71.91 20.85,71.93 20.89,71.91 20.94,71.9 20.97,71.9 21.22,71.64 21.85,71.64 22.09,71.41 22.09,71.26 22.14,71.2 22.14,68.86 22.02,68.73 17.9,68.73 17.9,70.31 17.98,70.43 18.01,70.58 17.98,70.73 17.9,70.85 17.9,72.02 17.91,72.16 18.03,72.29 19.6,72.29
GND on BOTTOM (solid shape): 179.14,130.83 179.14,124.83 179.1,124.75 179,124.74 178.93,124.76 178.86,124.76 178.45,124.36 178.86,123.95 178.93,123.95 179,123.97 179.1,123.96 179.14,123.88 179.14,123.36 177.46,121.69 173.91,121.69 172.38,123.21 172.38,125.12 172.83,125.56 173.85,125.56 174.72,126.44 177.9,126.44 178,126.54 178,127.86 177.67,128.19 177.67,131.01 178.96,131.01
GND on BOTTOM (solid shape): 137.86,175.03 137.95,174.99 137.96,174.9 137.95,174.84 137.94,174.77 138.06,174.49 138.35,174.37 138.47,174.39 138.59,174.44 138.77,174.26 138.77,174.2 138.89,173.91 139.17,173.8 139.22,173.8 139.26,173.8 139.34,173.78 139.38,173.7 139.38,171.08 142.03,168.42 142.03,166.14 141.78,165.88 139.36,165.88 138.98,166.27 138.98,167.54 135.94,170.58 130.22,170.58 129.46,171.35 129.46,173.12 130.35,174.01 135.28,174.01 136.29,175.03
GND on BOTTOM (solid shape): 199.42,131.46 203.42,130.97 207.45,130.91 207.47,130.91 207.74,130.64 207.74,129.99 207.61,129.87 206.61,129.87 206.4,130.08 206.39,130.08 206.35,130.12 204.44,130.12 204.03,130.53 201.71,130.53 201.59,130.42 201.59,129.08 201.65,129.02 202.49,129.02 202.49,129.02 202.49,128.85 202.46,128.82 201.78,128.82 201.78,128.82 201.71,128.82 201.6,128.71 201.6,126.87 201.64,126.83 201.64,126.82 202.32,126.14 202.75,126.14 203.09,125.8 203.1,125.8 204.09,125.8 204.15,125.74 204.15,125.06 204.04,124.95 203.06,124.95 201.86,126.15 201.01,126.15 200.86,126.3 198.9,126.3 198.54,126.66 198.54,127.32 198.61,127.4 200.59,127.4 200.7,127.5 200.7,130.43 200.53,130.6 200.36,130.6 200.34,130.63 198.62,130.63 198.56,130.69 198.56,131.25 198.77,131.46 199.41,131.46
GND on BOTTOM (solid shape): 86.53,186.2 86.53,185.93 86.71,185.76 88.21,185.76 88.29,185.68 88.29,185.38 88.29,185.34 88.31,185.27 88.51,185.07 88.51,185.07 88.92,184.66 88.92,184.64 89.01,184.4 89.23,184.26 89.25,184.26 89.26,184.24 89.4,184.24 89.4,184.19 89.79,183.79 90.22,184.16 91.04,184.16 91.1,184.11 91.1,182.39 89.6,182.39 89.53,182.41 89.45,182.42 89.38,182.41 89.31,182.39 87.8,182.39 87.8,182.65 87.7,182.75 86.53,182.75 86.33,182.95 86.33,184.88 85.9,185.32 85.52,185.32 85.39,185.44 85.39,186.2 85.52,186.33 86.41,186.33
GND on BOTTOM (solid shape): 102.53,197.86 102.65,197.86 102.76,197.76 102.76,197.68 103.38,197.06 103.46,197.06 104.3,196.22 104.34,196.14 104.4,196.08 104.4,194.99 104.23,194.82 103.78,194.82 103.76,194.84 103.55,195.05 103.38,195.12 103.2,195.06 103.2,195.05 102.99,194.85 102.95,194.8 102.13,193.98 101.92,193.98 101.77,193.82 101.52,193.82 101.04,194.31 101.05,194.34 101.06,194.48 100.99,194.61 100.94,194.67 100.73,194.88 100.72,194.88 100.66,194.93 100.58,194.95 100.56,194.95 100.51,195 100.51,196.29 100.65,196.29 100.83,196.37 100.91,196.55 100.91,196.92 100.91,196.95 100.92,196.97 100.92,197.03 101.98,198.09 102.29,198.09
GND on BOTTOM (solid shape): 101.67,122.81 101.7,122.78 101.74,122.75 101.92,122.57 101.92,122.35 101.75,122.17 101.51,122.17 101.32,122.13 101.23,121.95 101.3,121.78 101.49,121.7 101.5,121.66 101.5,120.86 101.38,120.73 101.38,120.71 101.2,120.53 100.9,120.53 100.59,120.85 100.59,120.92 100.62,120.99 100.69,121.03 100.96,121.29 100.72,121.58 100.7,121.59 100.46,121.83 100.43,121.9 100.89,122.35 100.9,122.35 101.01,122.43 101.07,122.55 101.08,122.56 101.34,122.83 101.63,122.83
GND on BOTTOM (solid shape): outline of 86 points within 12.77,77.93 17.37,84.73
GND on BOTTOM (solid shape): 160.57,131.72 160.57,131.64 160.56,131.59 160.55,131.54 160.55,131.26 160.61,131.1 160.76,131.01 160.78,131.01 160.95,130.83 161.57,130.83 161.57,130.76 161.57,130.48 161.64,130.3 161.82,130.23 162,130.23 162.17,130.06 162.17,130.04 162.29,129.75 162.58,129.63 162.87,129.75 162.99,130.04 162.99,130.07 162.98,130.11 163,130.19 163.08,130.23 163.19,130.23 163.37,130.3 163.44,130.48 163.44,130.55 163.73,130.83 164.26,130.83 164.26,129.88 164.14,129.74 164.1,129.56 164.12,129.47 164.15,129.38 164.17,129.34 163.62,128.8 160.07,128.8 159.94,128.93 159.94,131.72 160.07,131.85 160.45,131.85
GND on BOTTOM (solid shape): 20.62,93.88 20.62,93.37 20.54,93.29 20.54,93.28 20.54,92.4 20.82,92.12 21.79,92.12 21.99,91.92 21.99,88.92 20.85,87.78 18.83,87.78 18.22,87.17 17.22,87.17 16.73,87.65 16.73,88.92 16.77,89 16.86,89.02 16.93,89 17.11,89.01 17.21,89.06 17.25,89.08 17.36,88.97 17.43,88.9 18.18,88.9 18.54,88.54 19.12,88.54 19.2,88.62 19.2,88.69 19.2,89 19.35,89.15 19.53,89.15 19.78,88.9 20.2,88.9 20.2,88.9 20.38,88.9 20.52,89.04 20.52,89.8 20.42,89.9 20.42,89.9 19.81,90.51 19.81,90.85 19.71,90.95 19.4,90.95 19.3,91.06 19.3,91.56 19.31,91.57 19.31,93.13 19.02,93.41 17.93,93.41 17.85,93.49 17.85,93.86 17.93,93.94 19.12,93.94 19.22,93.85 19.34,93.8 19.42,93.78 19.51,93.77 19.69,93.81 19.84,93.94 19.84,93.95 19.89,93.97 19.91,93.96 20,93.93 20.09,93.93 20.19,93.94 20.29,93.98 20.33,93.99 20.38,94 20.49,94
GND on BOTTOM (solid shape): 29.5,79.6 29.54,79.6 29.55,79.56 29.6,79.48 29.7,79.45 30.5,79.45 30.6,79.48 30.65,79.56 30.66,79.6 30.7,79.6 30.7,81.15 31,81.15 31,79.6 31.04,79.6 31.05,79.56 31.1,79.48 31.2,79.45 32,79.45 32.1,79.48 32.15,79.56 32.16,79.6 32.2,79.6 32.2,81.15 32.5,81.15 32.5,79.6 32.54,79.6 32.55,79.56 32.6,79.48 32.7,79.45 33.5,79.45 33.6,79.48 33.65,79.56 33.66,79.6 33.7,79.6 33.7,81.15 34,81.15 34,79.6 34.2,79.6 34.2,81.15 35.84,81.15 35.99,81 35.99,78.15 35.65,77.82 35.65,76.56 35.52,76.43 33.91,76.43 33.78,76.56 33.78,77.2 32.77,78.21 28.58,78.21 28.07,78.72 27.7,78.72 27.7,78.86 27.73,78.94 27.73,79.02 27.73,79.09 27.7,79.17 27.7,79.38 27.77,79.45 29,79.45 29.1,79.48 29.15,79.56 29.16,79.6 29.2,79.6 29.2,81.15 29.5,81.15
GND on BOTTOM (solid shape): 172.08,109.24 172.08,106.47 171.13,106.47 171.06,106.49 170.99,106.5 170.92,106.49 170.85,106.47 170.47,106.47 170.4,106.49 170.33,106.5 170.26,106.49 170.19,106.47 169.81,106.47 169.74,106.49 169.67,106.5 169.6,106.49 169.52,106.47 169.27,106.47 169.13,106.61 169.13,106.86 169.29,107.02 169.35,107.01 169.39,107.01 169.68,107.7 168.98,107.41 168.98,107.38 168.99,107.31 168.79,107.11 168.63,107.11 168.4,107.34 168.4,108.35 168.68,108.63 168.7,108.63 168.83,108.66 168.94,108.73 169.01,108.75 169.07,108.73 169.2,108.66 169.34,108.63 169.62,108.74 169.74,109.02 169.74,109.04 170.07,109.37 171.96,109.37
GND on BOTTOM (solid shape): outline of 114 points within 124,103.53 130.35,109.65
GND on BOTTOM (solid shape): 13.92,192.77 13.92,191.78 13.92,191.7 13.92,190.7 12.91,190.7 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.31,194.89 10,195.69 11,195.69
GND on BOTTOM (solid shape): 14.66,102.5 14.72,102.49 15.61,102.49 16.3,101.79 16.3,95.27 15.79,94.76 13.88,94.76 13.76,94.89 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.25 13.8,102.33 13.88,102.34 13.99,102.32 14.1,102.32 14.37,102.36 14.61,102.48
GND on BOTTOM (solid shape): 11.41,121.63 12.41,121.63 13.17,120.87 13.17,116.6 14.27,115.96 14.77,114.78 15.87,113.67 15.87,112.7 15.12,111.94 14.68,111.94 14.65,111.95 14.61,111.96 14.37,112.08 14.1,112.12 13.99,112.12 13.88,112.1 13.8,112.11 13.76,112.19 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78 10.31,122.11 10.38,122.18 10.86,122.18
GND on BOTTOM (solid shape): 120.68,151.77 120.78,151.7 120.9,151.66 120.96,151.63 120.99,151.56 120.99,151.51 120.96,151.44 120.9,151.41 120.59,151.06 120.94,150.75 120.97,150.75 121,150.7 120.99,150.62 121.04,150.47 121.18,150.37 121.24,150.32 121.24,150.24 121.22,150.15 121.22,150.06 121.22,150.03 121.2,150.01 121.17,149.98 121.14,149.94 121.03,149.85 120.99,149.71 120.96,149.65 120.9,149.62 120.8,149.59 120.71,149.52 120.44,149.52 120.33,149.64 120.33,149.76 120.37,149.76 120.63,150.13 120.29,150.42 120.2,150.46 120.19,150.55 120.18,150.72 120.07,150.84 120.04,150.86 120.04,151.28 120.2,151.43 120.2,151.63 120.22,151.65 120.25,151.67 120.36,151.7 120.45,151.77
GND on BOTTOM (solid shape): 12.36,52.73 12.36,52.4 12.32,52.32 12.23,52.3 12.17,52.32 12.11,52.32 11.84,52.21 11.73,51.94 11.76,51.79 11.84,51.67 11.85,51.63 11.84,51.6 11.76,51.48 11.73,51.33 11.76,51.18 11.84,51.06 11.85,51.03 11.84,50.99 11.76,50.87 11.73,50.72 11.75,50.59 11.82,50.47 11.85,50.4 11.83,50.34 11.76,50.23 11.74,50.1 11.75,50.04 11.73,49.99 11.73,49.93 11.74,49.86 11.76,49.78 11.76,49.7 11.71,49.65 11.54,49.51 11.48,49.3 11.5,49.15 11.59,49.03 11.6,48.99 11.59,48.95 11.5,48.83 11.48,48.68 11.48,48.61 11.5,48.55 11.49,48.45 11.41,48.41 11.09,48.41 10.94,48.56 10.94,49.29 10.9,49.4 10.79,49.44 10.08,49.44 9.6,49.93 9.6,52.22 11.35,52.22 11.93,52.8 12.02,52.79 12.13,52.81 12.23,52.85 12.24,52.85
GND on BOTTOM (solid shape): 15.99,83.32 15.99,81.74 15.93,81.68 14.53,81.68 13.82,80.97 13.82,80.35 13.17,79.7 12.62,79.7 11.98,79.85 11.42,80.2 9.9,80.2 9.19,79.49 9.19,76.09 10.97,74.32 10.97,72.79 10.84,72.67 10.79,72.67 10.76,72.7 10.42,72.7 10.38,72.67 9.44,72.67 9.19,72.41 9.19,71.2 8.93,70.95 8.83,70.95 7.91,70.67 8.17,69.75 8.17,69.49 8.05,69.36 7.92,69.36 7.75,69.31 7.64,69.18 6.93,69.18 6.93,71.34 6.18,72.31 5.05,71.85 0.51,71.85 0.51,73.33 1.22,73.63 1.51,74.34 1.51,78.63 4.23,81.81 9.16,81.81 9.17,81.77 9.44,81.37 9.9,81.21 11.88,81.21 13.01,80.75 13.76,81.72 13.76,83.61 13.92,83.77 15.54,83.77
GND on BOTTOM (solid shape): 132.15,217.44 132.23,217.4 132.25,217.31 132.24,217.26 132.23,217.19 132.35,216.9 132.64,216.78 132.68,216.79 132.72,216.79 132.8,216.77 132.84,216.69 132.84,213.7 132.41,213.27 132.31,213.24 132.24,213.3 132.09,213.5 131.86,213.57 131.65,213.52 131.5,213.37 131.42,213.32 131.33,213.36 131.27,213.42 131.2,213.47 131.1,213.52 130.98,213.54 130.7,213.42 130.58,213.13 130.64,212.92 130.8,212.77 130.9,212.72 131.01,212.71 131.21,212.76 131.36,212.91 131.42,212.96 131.5,212.95 131.62,212.81 131.77,212.74 131.79,212.68 131.76,212.62 131.51,212.37 131.51,210.02 131.47,209.98 130.54,209.98 130.43,210.08 130.43,211.43 129.8,212.06 129.77,212.15 129.82,212.22 129.96,212.37 130.01,212.57 129.89,212.86 129.61,212.98 129.41,212.93 129.26,212.79 129.22,212.76 129.17,212.79 129.15,212.83 129.15,213.86 129.15,213.87 129.57,215.05 129.72,216.3 129.72,217.42 129.74,217.44
GND on BOTTOM (solid shape): 8.3,63.78 8.3,63.64 7.88,62.74 8.81,62.38 8.81,62.38 9.07,62.38 9.19,62.25 9.19,60.98 9.7,60.47 10.33,60.47 10.71,60.86 12.24,60.86 12.36,60.73 12.36,59.33 12.21,59.17 8.48,59.17 5.52,56.21 4.83,55.7 4,55.52 2.52,55.52 2.52,55.17 2.52,55.17 2.52,45.47 2.52,45.47 2.52,43.38 3.25,42.71 3.52,41.75 3.52,35.53 2.52,35.53 2.52,31.27 3.73,31.27 4,31.27 4.72,31.14 5.35,30.76 5.42,30.69 5.49,30.62 5.49,30.33 5.35,30.19 4.36,30.19 4.18,30.24 4,30.26 1.51,30.26 1.51,36.54 2.51,36.54 2.51,41.75 2.27,42.32 1.7,42.56 1.51,42.56 1.51,56.54 4,56.54 4.71,56.83 5.01,57.54 5.01,59.05 4.71,59.76 4,60.05 0.51,60.05 0.51,61.49 5.05,61.49 6.18,61.03 6.93,62 6.93,63.9 8.17,63.9
GND on BOTTOM (solid shape): outline of 197 points within 194.48,120.16 200.45,124.1
GND on BOTTOM (solid shape): outline of 183 points within 44.88,92.35 60.9,99.59
GND on BOTTOM (solid shape): outline of 350 points within 1.51,132.29 18.71,177.99
GND on BOTTOM (solid shape): outline of 353 points within 140.15,206.8 148.34,217.47
GND on BOTTOM (solid shape): outline of 289 points within 106.27,126.04 116.07,128.64
GND on BOTTOM (solid shape): outline of 306 points within 100.52,129.56 106.09,137.37
GND on BOTTOM (solid shape): outline of 969 points within 127.43,139.21 155.48,167.36
GND on BOTTOM (solid shape): outline of 1440 points within 106.09,157.74 118.84,174.97
GND on BOTTOM (solid shape): outline of 426 points within 1.01,0.51 237.49,218.99
GND on BOTTOM (solid shape): outline of 1520 points within 101.17,136.81 107.55,149.47
GND on BOTTOM (solid shape): outline of 2358 points within 100.91,149.69 110.6,165.15
GND on BOTTOM (solid shape): outline of 13390 points within 43.48,105.04 69.9,175.28
GND on SGND (solid shape): outline of 5717 points within 0.51,0.51 237.49,218.99
GND on IN1 (solid shape): 30.62,62.15 30.62,59.3 30.37,59.05 29.87,59.05 29.87,62.26 29.88,62.27 30.5,62.27
GND on IN1 (solid shape): 128.44,174.39 124.76,174.39 124.12,175.03 124.12,177.57 124.51,177.95 128.44,177.95
GND on IN1 (solid shape): 90.72,113.05 90.72,110.79 90.32,110.39 85.9,110.39 85.64,110.64 85.64,113.05 86.02,113.43 90.34,113.43
GND on IN1 (solid shape): 33.83,171.35 33.83,167.54 32.05,167.54 31.54,167.03 30.91,167.03 30.4,167.54 30.4,171.47 30.53,171.6 33.57,171.6
GND on IN1 (solid shape): 131.59,125.53 131.59,122.05 131.09,121.56 129.08,121.56 128.94,121.69 128.94,125.16 129.16,125.37 129.97,125.37 130.02,125.43 130.23,125.43 130.68,125.88 131.24,125.88
GND on IN1 (solid shape): outline of 87 points within 8.55,65.94 13.63,71.4
GND on IN1 (solid shape): outline of 86 points within 14.67,58.44 16.94,67.08
GND on IN1 (solid shape): 12.85,65.07 12.85,64.88 12.89,64.68 13.01,64.51 13.24,64.28 13.24,64.27 13.68,63.83 13.68,61.49 13.14,60.95 12.05,60.95 11.89,60.92 11.74,60.82 11.52,60.6 9.95,60.6 9.82,60.73 9.82,60.98 10.21,61.36 10.21,63.14 9.82,63.52 9.82,63.82 10.32,64.31 10.56,64.64 10.7,65.02 10.7,65.04 10.77,65.1 10.84,65.13 10.92,65.1 11.03,65.02 11.17,64.99 11.2,65 11.28,64.97 11.31,64.89 11.31,64.88 11.67,64.52 12.02,64.88 12,65.01 11.92,65.13 11.9,65.24 12,65.3 12.62,65.3
GND on IN1 (solid shape): 13.92,192.77 13.92,191.78 13.92,191.7 13.92,190.7 12.91,190.7 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.31,194.89 10,195.69 11,195.69
GND on IN1 (solid shape): 14.66,102.5 14.72,102.49 15.61,102.49 16.45,101.64 16.45,100.55 15.47,99.57 15.47,94.62 14.77,93.93 14.71,93.85 14.61,93.86 14.37,93.98 14.1,94.02 13.99,94.02 13.88,94 13.8,94.01 13.76,94.09 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.25 13.8,102.33 13.88,102.34 13.99,102.32 14.1,102.32 14.37,102.36 14.61,102.48
GND on IN1 (solid shape): 10.31,122.57 10.38,122.66 10.5,122.62 10.73,122.4 11.12,122.32 11.2,122.34 12.66,122.34 13.17,121.82 13.17,116.6 14.27,115.96 14.77,114.78 15.87,113.67 15.87,112.7 15.12,111.94 14.68,111.94 14.65,111.95 14.61,111.96 14.37,112.08 14.1,112.12 13.99,112.12 13.88,112.1 13.8,112.11 13.76,112.19 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78
GND on IN1 (solid shape): outline of 297 points within 23.59,60.35 26.72,66.82
GND on IN1 (solid shape): outline of 346 points within 1.51,132.29 16.3,177.99
GND on IN1 (solid shape): outline of 133 points within 0.51,30.19 15.99,83.82
GND on IN1 (solid shape): outline of 295 points within 1.01,0.51 237.49,218.99
GND on SVCC (solid shape): 3.76,15.12 3.76,14.35 3.78,14.25 3.84,14.17 4.09,13.92 4.17,13.86 4.27,13.85 8.81,13.85 8.91,13.86 8.99,13.92 9.16,14.09 12.13,14.09 12.23,14.11 12.31,14.16 12.44,14.3 13.66,14.3 11.16,12.96 10.17,10.3 10.17,5.43 7.81,6.01 5.64,4.94 5.7,5.22 5.72,5.51 5.72,5.99 5.1,7.49 3.6,8.11 3.31,8.09 3.03,8.04 3.03,15.24 3.65,15.24
GND on SVCC (solid shape): 104.44,204.75 104.46,204.65 104.51,204.57 110.03,199.05 110.03,198.76 109.67,198.4 104.23,198.4 104.11,198.61 103.88,198.7 103.65,198.61 103.53,198.4 100.47,198.4 100.36,198.63 100.12,198.73 99.87,198.62 99.76,198.37 99.77,198.28 99.81,198.19 94.35,192.73 94.3,192.65 94.28,192.55 94.28,191.03 87.42,191.03 87.32,191.01 87.24,190.96 85.21,188.92 85.16,188.84 85.14,188.74 85.14,184.28 81.98,181.12 47.4,181.12 46.27,182.25 46.27,183.66 46.25,183.76 46.2,183.84 44.68,185.37 44.59,185.42 44.5,185.44 44.33,185.44 44.19,185.64 43.96,185.71 43.73,185.64 43.6,185.44 40.37,185.44 40.37,189.51 48.56,189.51 48.85,189.56 49.1,189.73 52.94,193.57 61.77,193.57 62.06,193.63 62.31,193.8 64.08,195.57 64.25,195.82 64.31,196.11 64.31,205.72 98.24,205.72 98.64,205.75 99.03,205.84 99.07,205.84 99.11,205.84 99.31,205.89 99.47,206.03 99.77,206.23 104.44,210.87
GND on SVCC (solid shape): 226.67,130.8 227.41,129.01 229.2,128.27 235.97,128.27 235.97,106.31 234.83,105.5 235.97,104.69 235.97,87.37 235.68,86.69 235,86.4 232,86.4 231.32,86.69 231.03,87.37 231.03,87.87 230.29,89.66 228.5,90.4 227.38,90.4 227.38,103.83 227.65,103.94 227.76,104.21 227.65,104.48 227.38,104.59 227.43,104.7 227.45,104.82 227.43,104.94 227.38,105.05 227.38,120.83 227.76,121.21 227.38,121.59 227.38,121.94 227.36,122.04 227.3,122.12 224.76,124.66 224.68,124.72 224.58,124.74 215.29,124.74 212.9,127.13 212.9,131.52 214.58,131.87 216.24,132.3 216.63,132.45 216.98,132.68 224.24,138.57 226.67,138.57
GND on SVCC (solid shape): outline of 117 points within 43.48,109.5 111.93,173
GND on SVCC (solid shape): outline of 521 points within 3.03,14.33 36.07,79.78
GND on SVCC (solid shape): outline of 107 points within 2.86,73.43 17.06,175.54
GND on SVCC (solid shape): outline of 708 points within 125.01,112.29 202.48,217.47
GND on IN2 (solid shape): 106.47,113.85 106.24,113.62 106.24,113.56 102.92,113.56 102.92,115.21 106.47,115.21
GND on IN2 (solid shape): 128.44,174.39 124.51,174.39 124,174.9 124,177.44 124.51,177.95 128.44,177.95
GND on IN2 (solid shape): 33.83,171.35 33.83,167.54 32.05,167.54 31.54,167.03 30.91,167.03 30.4,167.54 30.4,171.47 30.53,171.6 33.57,171.6
GND on IN2 (solid shape): 132,125.12 132,121.56 131.62,121.18 129.2,121.18 128.75,121.64 128.75,124.68 128.7,124.73 128.7,125.12 129.4,125.82 129.44,125.81 129.51,125.78 129.59,125.78 129.72,125.8 129.84,125.88 131.24,125.88
GND on IN2 (solid shape): 18.22,72.16 18.26,72.15 18.29,72.12 18.54,72.03 18.78,72.12 18.82,72.15 18.86,72.16 18.88,72.16 18.92,72.15 18.95,72.12 19.2,72.03 19.44,72.12 19.48,72.15 19.52,72.16 19.54,72.16 19.62,72.12 19.66,72.03 19.65,71.99 19.7,71.67 19.99,71.52 21.51,71.52 21.51,70.66 22.27,69.89 22.27,69.11 21.89,68.73 17.9,68.73 17.9,71.56 18.08,71.74 18.09,71.99 18.08,72.03 18.11,72.12 18.2,72.16
GND on IN2 (solid shape): 107.51,134.97 107.51,134.63 107.47,134.55 107.38,134.54 107.3,134.56 107.22,134.57 107,134.49 106.88,134.3 106.88,134.29 106.88,134.13 106.95,133.98 106.97,133.92 106.95,133.87 106.93,133.84 106.87,133.69 106.87,133.53 107,133.34 107.3,133.28 107.37,133.31 107.47,133.3 107.51,133.21 107.51,132.15 107.5,132.1 107.46,132.07 107.34,132.16 107.19,132.19 106.94,132.08 106.84,131.84 106.85,131.74 106.88,131.66 106.88,131.65 106.88,131.59 106.86,131.55 106.77,131.51 106.7,131.46 106.59,131.43 106.52,131.53 106.52,134.58 106.98,135.03 107.45,135.03
GND on IN2 (solid shape): 13.92,192.77 13.92,191.78 13.92,191.7 13.92,190.7 12.91,190.7 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.31,194.89 10,195.69 11,195.69
GND on IN2 (solid shape): 14.66,102.5 14.72,102.49 15.61,102.49 16.45,101.64 16.45,100.55 15.47,99.57 15.47,94.62 14.77,93.93 14.71,93.85 14.61,93.86 14.37,93.98 14.1,94.02 13.99,94.02 13.88,94 13.8,94.01 13.76,94.09 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.25 13.8,102.33 13.88,102.34 13.99,102.32 14.1,102.32 14.37,102.36 14.61,102.48
GND on IN2 (solid shape): 10.31,122.57 10.38,122.66 10.5,122.62 10.73,122.4 11.12,122.32 11.2,122.34 12.66,122.34 13.17,121.82 13.17,116.6 14.27,115.96 14.77,114.78 15.87,113.67 15.87,112.7 15.12,111.94 14.68,111.94 14.65,111.95 14.61,111.96 14.37,112.08 14.1,112.12 13.99,112.12 13.88,112.1 13.8,112.11 13.76,112.19 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78
GND on IN2 (solid shape): outline of 342 points within 1.51,132.29 16.3,177.99
GND on IN2 (solid shape): outline of 145 points within 0.51,30.19 15.99,83.77
GND on IN2 (solid shape): outline of 307 points within 1.01,0.51 237.49,218.99
GND on IN2 (solid shape): outline of 12473 points within 131.16,171.7 168.42,207.34
GND on IN2 (solid shape): outline of 26495 points within 44.37,104.74 109.65,177.06
GND on IN3 (solid shape): 106.47,113.65 106.46,113.64 102.92,113.64 102.92,115.21 106.47,115.21
GND on IN3 (solid shape): 21.59,70.13 22.14,69.57 22.14,68.98 21.89,68.73 17.95,68.73 17.95,72.16 21.59,72.16
GND on IN3 (solid shape): 33.83,171.35 33.83,167.54 32.05,167.54 31.54,167.03 30.91,167.03 30.4,167.54 30.4,171.47 30.53,171.6 33.57,171.6
GND on IN3 (solid shape): 128.44,174.39 128.36,174.39 124.68,174.39 124.12,174.95 124.12,177.57 124.2,177.64 124.33,177.64 124.63,177.95 128.44,177.95
GND on IN3 (solid shape): 90.85,112.93 90.85,110.77 90.47,110.39 86.15,110.39 85.77,110.77 85.77,113.05 86.15,113.43 90.34,113.43
GND on IN3 (solid shape): 131.56,125.43 131.59,125.27 131.59,125.02 131.64,124.97 131.78,124.16 131.61,123.2 131.79,122.19 131.61,121.18 129.26,121.18 129.26,121.34 128.88,121.72 128.88,125.12 129.14,125.37 129.14,125.56 129.4,125.82 129.44,125.81 129.51,125.78 129.59,125.78 129.72,125.8 129.84,125.88 131.11,125.88
GND on IN3 (solid shape): 13.92,192.77 13.92,191.78 13.92,191.7 13.92,190.7 12.91,190.7 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.31,194.89 10,195.69 11,195.69
GND on IN3 (solid shape): outline of 122 points within 95.8,99.84 98.22,102.26
GND on IN3 (solid shape): 14.66,102.5 14.72,102.49 15.61,102.49 16.45,101.64 16.45,100.55 15.47,99.57 15.47,94.62 14.77,93.93 14.71,93.85 14.61,93.86 14.37,93.98 14.1,94.02 13.99,94.02 13.88,94 13.8,94.01 13.76,94.09 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.25 13.8,102.33 13.88,102.34 13.99,102.32 14.1,102.32 14.37,102.36 14.61,102.48
GND on IN3 (solid shape): 10.31,122.57 10.38,122.66 10.5,122.62 10.73,122.4 11.12,122.32 11.2,122.34 12.66,122.34 13.17,121.82 13.17,116.6 14.27,115.96 14.77,114.78 15.87,113.67 15.87,112.7 15.12,111.94 14.68,111.94 14.65,111.95 14.61,111.96 14.37,112.08 14.1,112.12 13.99,112.12 13.88,112.1 13.8,112.11 13.76,112.19 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78
GND on IN3 (solid shape): outline of 337 points within 1.51,132.29 16.3,177.99
