# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Nets (continued)
M_A_DQ11: JDIM1.169 U6539.CL53
M_A_DQ12: JDIM1.174 U6539.CH49
M_A_DQ13: JDIM1.186 U6539.CH50
M_A_DQ14: JDIM1.183 U6539.CH52
M_A_DQ15: JDIM1.182 U6539.CH53
M_A_DQ16: JDIM1.249 U6539.CV41
M_A_DQ17: JDIM1.236 U6539.CT41
M_A_DQ18: JDIM1.245 U6539.CV42
M_A_DQ19: JDIM1.232 U6539.CT42
M_A_DQ20: JDIM1.246 U6539.CV45
M_A_DQ21: JDIM1.237 U6539.CT45
M_A_DQ22: JDIM1.250 U6539.CV47
M_A_DQ23: JDIM1.233 U6539.CT47
M_A_DQ24: JDIM1.212 U6539.CK41
M_A_DQ25: JDIM1.224 U6539.CM41
M_A_DQ26: JDIM1.225 U6539.CM42
M_A_DQ27: JDIM1.215 U6539.CK42
M_A_DQ28: JDIM1.229 U6539.CM45
M_A_DQ29: JDIM1.216 U6539.CK45
M_A_DQ30: JDIM1.228 U6539.CM47
M_A_DQ31: JDIM1.211 U6539.CK47
M_A_DQ32: JDIM1.79 U6539.BH49
M_A_DQ33: JDIM1.80 U6539.BH50
M_A_DQ34: JDIM1.84 U6539.BH52
M_A_DQ35: JDIM1.83 U6539.BH53
M_A_DQ36: JDIM1.66 U6539.BF49
M_A_DQ37: JDIM1.67 U6539.BF50
M_A_DQ38: JDIM1.71 U6539.BF52
M_A_DQ39: JDIM1.70 U6539.BF53
M_A_DQ40: JDIM1.62 U6539.BC49
M_A_DQ41: JDIM1.63 U6539.BC50
M_A_DQ42: JDIM1.58 U6539.BC52
M_A_DQ43: JDIM1.59 U6539.BC53
M_A_DQ44: JDIM1.46 U6539.AY49
M_A_DQ45: JDIM1.50 U6539.AY50
M_A_DQ46: JDIM1.49 U6539.AY52
M_A_DQ47: JDIM1.45 U6539.AY53
M_A_DQ48: JDIM1.24 U6539.BH41
M_A_DQ49: JDIM1.37 U6539.BK41
M_A_DQ50: JDIM1.41 U6539.BK42
M_A_DQ51: JDIM1.29 U6539.BH42
M_A_DQ52: JDIM1.28 U6539.BH45
M_A_DQ53: JDIM1.25 U6539.BH47
M_A_DQ54: JDIM1.42 U6539.BK45
M_A_DQ55: JDIM1.38 U6539.BK47
M_A_DQ56: JDIM1.4 U6539.BD41
M_A_DQ57: JDIM1.17 U6539.BD42
M_A_DQ58: JDIM1.8 U6539.BB41
M_A_DQ59: JDIM1.20 U6539.BB42
M_A_DQ60: JDIM1.3 U6539.BB45
M_A_DQ61: JDIM1.21 U6539.BD45
M_A_DQ62: JDIM1.7 U6539.BB47
M_A_DQ63: JDIM1.16 U6539.BD47
M_A_DQSN0: JDIM1.198 U6539.CR50
M_A_DQSN1: JDIM1.177 U6539.CK50
M_A_DQSN2: JDIM1.240 U6539.CV44
M_A_DQSN3: JDIM1.219 U6539.CM44
M_A_DQSN4: JDIM1.74 U6539.BG50
M_A_DQSN5: JDIM1.53 U6539.BA50
M_A_DQSN6: JDIM1.32 U6539.BH44
M_A_DQSN7: JDIM1.11 U6539.BD44
M_A_DQSN8: JDIM1.95 R232.1
M_A_DQSP0: JDIM1.200 U6539.CR51
M_A_DQSP1: JDIM1.179 U6539.CK51
M_A_DQSP2: JDIM1.242 U6539.CT44
M_A_DQSP3: JDIM1.221 U6539.CK44
M_A_DQSP4: JDIM1.76 U6539.BG51
M_A_DQSP5: JDIM1.55 U6539.BA51
M_A_DQSP6: JDIM1.34 U6539.BK44
M_A_DQSP7: JDIM1.13 U6539.BB44
M_A_DQSP8: JDIM1.97 R231.1
M_A_PARITY: JDIM1.143 U6539.BV45
M_A_RAS#: JDIM1.152 U6539.CB47
M_A_WE#: JDIM1.151 U6539.CB45
M_B_A0: JDIM02.144 U6539.U41
M_B_A1: JDIM02.133 U6539.AC52
M_B_A2: JDIM02.132 U6539.U47
M_B_A3: JDIM02.131 U6539.AA53
M_B_A4: JDIM02.128 U6539.AA51
M_B_A5: JDIM02.126 U6539.U50
M_B_A6: JDIM02.127 U6539.U52
M_B_A7: JDIM02.122 U6539.W50
M_B_A8: JDIM02.125 U6539.U53
M_B_A9: JDIM02.121 U6539.P50
M_B_A10: JDIM02.146 U6539.U42
M_B_A11: JDIM02.120 U6539.N51
M_B_A12: JDIM02.119 U6539.P53
M_B_A13: JDIM02.158 U6539.AE41
M_B_ACT#: JDIM02.114 U6539.N53
M_B_ALERT#: JDIM02.116 U6539.AU53
M_B_BG#0: JDIM02.115 U6539.J52
M_B_BG#1: JDIM02.113 U6539.K50
M_B_BS#0: JDIM02.150 U6539.U44
M_B_BS#1: JDIM02.145 U6539.AA42
M_B_CAS#: JDIM02.156 U6539.AA44
M_B_CB0: JDIM02.92 R25602.2
M_B_CB1: JDIM02.91 R25603.2
M_B_CB2: JDIM02.101 R25604.2
M_B_CB3: JDIM02.105 R25605.2
M_B_CB4: JDIM02.88 R25606.2
M_B_CB5: JDIM02.87 R25608.2
M_B_CB6: JDIM02.100 R25609.2
M_B_CB7: JDIM02.104 R25610.2
M_B_CKE0: JDIM02.109 U6539.J50
M_B_CKE1: JDIM02.110 U6539.P52
M_B_CLKN0: JDIM02.139 U6539.Y53
M_B_CLKN1: JDIM02.140 U6539.R42
M_B_CLKP0: JDIM02.137 U6539.Y52
M_B_CLKP1: JDIM02.138 U6539.R41
M_B_CS#0: JDIM02.149 U6539.AE47
M_B_CS#1: JDIM02.157 U6539.AE42
M_B_DIM0_ODT0: JDIM02.155 U6539.AE45
M_B_DIM0_ODT1: JDIM02.161 U6539.AE44
M_B_DQ0: JDIM02.190 U6539.AP49
M_B_DQ1: JDIM02.204 U6539.AP50
M_B_DQ2: JDIM02.207 U6539.AP52
M_B_DQ3: JDIM02.203 U6539.AP53
M_B_DQ4: JDIM02.191 U6539.AL49
M_B_DQ5: JDIM02.195 U6539.AL50
M_B_DQ6: JDIM02.194 U6539.AL52
M_B_DQ7: JDIM02.208 U6539.AL53
M_B_DQ8: JDIM02.174 U6539.AH49
M_B_DQ9: JDIM02.187 U6539.AH50
M_B_DQ10: JDIM02.183 U6539.AH52
M_B_DQ11: JDIM02.186 U6539.AH53
M_B_DQ12: JDIM02.182 U6539.AF49
M_B_DQ13: JDIM02.173 U6539.AF50
M_B_DQ14: JDIM02.169 U6539.AF52
M_B_DQ15: JDIM02.170 U6539.AF53
M_B_DQ16: JDIM02.250 U6539.AV47
M_B_DQ17: JDIM02.232 U6539.AR47
M_B_DQ18: JDIM02.246 U6539.AV45
M_B_DQ19: JDIM02.236 U6539.AR45
M_B_DQ20: JDIM02.245 U6539.AV41
M_B_DQ21: JDIM02.233 U6539.AR42
M_B_DQ22: JDIM02.249 U6539.AV42
M_B_DQ23: JDIM02.237 U6539.AR41
M_B_DQ24: JDIM02.228 U6539.AL47
M_B_DQ25: JDIM02.224 U6539.AL45
M_B_DQ26: JDIM02.211 U6539.AJ47
M_B_DQ27: JDIM02.215 U6539.AJ45
M_B_DQ28: JDIM02.225 U6539.AL42
M_B_DQ29: JDIM02.229 U6539.AL41
M_B_DQ30: JDIM02.212 U6539.AJ42
M_B_DQ31: JDIM02.216 U6539.AJ41
M_B_DQ32: JDIM02.38 U6539.E47
M_B_DQ33: JDIM02.41 U6539.D46
M_B_DQ34: JDIM02.37 U6539.B46
M_B_DQ35: JDIM02.42 U6539.A46
M_B_DQ36: JDIM02.28 U6539.E44
M_B_DQ37: JDIM02.24 U6539.D43
M_B_DQ38: JDIM02.29 U6539.B43
M_B_DQ39: JDIM02.25 U6539.A43
M_B_DQ40: JDIM02.17 U6539.A40
M_B_DQ41: JDIM02.20 U6539.B40
M_B_DQ42: JDIM02.16 U6539.D40
M_B_DQ43: JDIM02.8 U6539.E41
M_B_DQ44: JDIM02.21 U6539.A38
M_B_DQ45: JDIM02.4 U6539.B38
M_B_DQ46: JDIM02.3 U6539.D38
M_B_DQ47: JDIM02.7 U6539.E38
M_B_DQ48: JDIM02.80 U6539.J47
M_B_DQ49: JDIM02.71 U6539.G47
M_B_DQ50: JDIM02.83 U6539.J45
M_B_DQ51: JDIM02.66 U6539.G45
M_B_DQ52: JDIM02.79 U6539.J42
M_B_DQ53: JDIM02.84 U6539.J41
M_B_DQ54: JDIM02.67 U6539.G41
M_B_DQ55: JDIM02.70 U6539.G42
M_B_DQ56: JDIM02.58 U6539.N38
M_B_DQ57: JDIM02.59 U6539.L38
M_B_DQ58: JDIM02.50 U6539.L36
M_B_DQ59: JDIM02.46 U6539.N36
M_B_DQ60: JDIM02.63 U6539.H38
M_B_DQ61: JDIM02.49 U6539.H36
M_B_DQ62: JDIM02.45 U6539.G36
M_B_DQ63: JDIM02.62 U6539.G38
M_B_DQSN0: JDIM02.198 U6539.AN50
M_B_DQSN1: JDIM02.177 U6539.AG50
M_B_DQSN2: JDIM02.240 U6539.AR44
M_B_DQSN3: JDIM02.219 U6539.AL44
M_B_DQSN4: JDIM02.32 U6539.D45
M_B_DQSN5: JDIM02.11 U6539.C39
M_B_DQSN6: JDIM02.74 U6539.J44
M_B_DQSN7: JDIM02.53 U6539.K38
M_B_DQSN8: JDIM02.95 R25611.2
M_B_DQSP0: JDIM02.200 U6539.AN51
M_B_DQSP1: JDIM02.179 U6539.AG51
M_B_DQSP2: JDIM02.242 U6539.AV44
M_B_DQSP3: JDIM02.221 U6539.AJ44
M_B_DQSP4: JDIM02.34 U6539.C45
M_B_DQSP5: JDIM02.13 U6539.D39
M_B_DQSP6: JDIM02.76 U6539.G44
M_B_DQSP7: JDIM02.55 U6539.K36
M_B_DQSP8: JDIM02.97 R25607.2
M_B_PARITY: JDIM02.143 U6539.U45
M_B_RAS#: JDIM02.152 U6539.AA47
M_B_WE#: JDIM02.151 U6539.AA45
MAIND: PC51.1 PQ6.3 PQ9.2 PQ9087.2 PR59.2
MAINON: PQ16.2 PR120.1 PR5006.1 PR6016.1 PR6028.1 PR6417.1 PR7082.1 PR9268.1 PR9270.1 R890.1 R68841.2 R68852.1 R68950.2 U37.30
MAINON_ON_G: PQ6.2 PQ12.2 PQ16.3 PQ19.2 PQ9050.2 PQ9088.2 PR116.2 PR118.1
MB_GSENSOR_INT: R25641.2 R68994.2 U6516.D5
MBCLK: PC11.1 PD4.1 PR12.2 PR17.2 Q13.3 R361.1 U37.110
MBCLK_THM: Q6564.4 R67858.2 U2.8 U6517.8
MBDATA: PC10.1 PD3.1 PR13.2 PR19.2 Q13.6 R369.1 U37.111
MBDATA_THM: Q6564.1(S) R67857.2 U2.7 U6517.7
MBP0#: R68308.2 U6539.Y2
MBP1#: R68309.2 U6539.AB4
MBP2#: R68310.2 U6539.M4
MBP3#: R68311.2 U6539.Y1
MCT1: R516.2 U25.24
MCT2: R517.2 U25.21
MCT3: R518.2 U25.18
MCT4: R519.2 U25.15
MDI0+: U25.9 U6521.13
MDI0+_1: CN8.1 U25.16
MDI0-: U25.8 U6521.14
MDI0-_1: CN8.2 U25.17
MDI1+: U25.12(TD4-) U6521.17
MDI1+_1: CN8.3 U25.13
MDI1-: U25.11 U6521.18
MDI1-_1: CN8.6 U25.14
MDI2+: U25.2 U6521.20
MDI2+_1: CN8.4 U25.23
MDI2-: U25.3 U6521.21
MDI2-_1: CN8.5 U25.22
MDI3+: U25.6 U6521.23
MDI3+_1: CN8.7 U25.19
MDI3-: U25.5 U6521.24
MDI3-_1: CN8.8 U25.20
ME_WR#: Q6649.2 U37.109
MEM_VREF_CTL_QA: Q20.3 R411.2 R25283.2
MIC2-VREFO: R468.1 R471.1 U20.29
MINICAR_PME#: CN17.55 Q33.3 R651.1 R69029.1
MIPI60_CFG0#: R68323.1 U6539.E7
MIPI60_CFG0#_R: R68291.2 R68323.2 R68324.1 TP13286.1
MIPI60_CFG1#: R68292.2 R68331.1 U6539.D9
MIPI60_CFG2#: R68293.2 R68325.1 U6539.E9
MIPI60_CFG3#: R68294.2 R68332.1 U6539.H5
MIPI60_CFG4#: R68295.2 R68326.1 U6539.E6
MIPI60_CFG5#: R68296.2 R68333.1 U6539.H9
MIPI60_CFG6#: R68297.2 R68334.1 U6539.K8
MIPI60_CFG7#: R68298.2 R68327.1 U6539.H7
MIPI60_CFG8#: R68299.2 R68335.1 U6539.K7
MIPI60_CFG9#: R68300.2 R68322.1 U6539.T17
MIPI60_CFG10#: R68301.2 R68328.1 U6539.K9
MIPI60_CFG11#: R68302.2 R68317.1 U6539.K12
MIPI60_CFG12#: R68303.2 R68320.1 U6539.K11
MIPI60_CFG13#: R68304.2 R68321.1 U6539.U15
MIPI60_CFG14#: R68306.2 R68329.1 U6539.V17
MIPI60_CFG15#: R68307.2 R68330.1 U6539.T15
MIPI60_CFG16_STB_DN: R68312.2 U6539.H11
MIPI60_CFG17_STB_DP: TP13268.1 U6539.U17
MODE1: Q6631.3 Q6638.3 R69087.1 U6556.12
MODE1_HUB: Q6631.4 R68992.2 U6516.A3
MODE1_ISH: Q6638.4 R69016.1 U6539.DR24
MODE2: Q6631.6 Q6638.6 R69085.1 U6556.11
MODE2_HUB: Q6631.1(S) R68993.2 U6516.B2
MODE2_ISH: Q6638.1(S) R69017.1 U6539.DU25
MODEM_CLKREQ: R68472.2 R68873.2 U36.1 U36.2 U6539.DL49
MODEM_CLKREQ_L: CN17.14 R678.1 R68873.1 U36.4
MX0: C725.1 CN18.10 CN19.10 U37.58
MX1: C727.1 CN18.9 CN19.9 U37.59
MX2: C723.1 CN18.8 CN19.8 U37.60
MX3: C722.1 CN18.7 CN19.7 U37.61
MX4: C720.1 CN18.6 CN19.6 U37.62
MX5: C726.1 CN18.5 CN19.5 U37.63
MX6: C721.1 CN18.4 CN19.4 TP13180.1 U37.64
MX7: C724.1 CN18.3 CN19.3 TP13181.1 U37.65
MY0: C719.1 CN18.26 CN19.26 U37.36
MY1: C716.1 CN18.25 CN19.25 U37.37
MY2: C717.1 CN18.24 CN19.24 U37.38
MY3: C708.1 CN18.23 CN19.23 U37.39
MY4: C718.1 CN18.22 CN19.22 U37.40
MY5: C707.1 CN18.21 CN19.21 U37.41
MY6: C706.1 CN18.20 CN19.20 U37.42
MY7: C709.1 CN18.19 CN19.19 U37.43
MY8: C711.1 CN18.18 CN19.18 U37.44
MY9: C713.1 CN18.17 CN19.17 U37.45
MY10: C714.1 CN18.16 CN19.16 U37.46
MY11: C715.1 CN18.15 CN19.15 U37.51
MY12: C728.1 CN18.14 CN19.14 U37.52
MY13: C729.1 CN18.13 CN19.13 U37.53
MY14: C730.1 CN18.12 CN19.12 U37.54
MY15: C731.1 CN18.11 CN19.11 U37.55
MY16: C732.1 CN18.28 CN19.28 U37.56
MY17: C733.1 CN18.27 CN19.27 U37.57
N12E_SCL: R367.1 U8.C9
N12E_SDA: R368.1 U8.C8
NBSWON#: C6615.2 C96346.1 CN52.4 R720.2 R25314.1 R67861.2 SW5.1 SW5.2 U37.107
NBSWON#_R: CN18.1 CN19.1 D33.2 R720.1
NFC_DWL_REQ: CN58.5 Q6558.1(S) R67563.2 R67567.2
NFC_I2C_SCL: CN58.8 Q6556.1(S) R67568.2 R67570.2
NFC_I2C_SDA: CN58.9 Q6559.1(S) R67564.2 R67571.2
NFC_INT: CN58.11 Q6555.1(S) R67561.2
NFC_RST#: Q6557.3 R67566.1 R67572.2 U6539.DJ25
NFC_RST#_Q: CN58.6 Q6557.1(S) R67566.2 R67573.2
NFC_SWP: CN58.13 TP13163.1
NOVRP1: R68552.1 U6544.25
NOVRP2: R68553.1 U6544.24
NOVRP3: R68554.1 R69072.1 U6544.20
NOVRP4: R68557.1 R69002.1 U6544.19
NTC1N_R: PR7060.1 PR7061.1 PR7062.2
NV_PLLVDD: C457.2 C458.2 L7.2 U8.L6
PBA_FP_PWREN#: CN52.11 R609.1 R69107.1
PCBEEP_EC: D6543.2 U37.34
PCH_AZ_CODEC_BITCLK: C587.2 R68451.2 U20.6
PCH_AZ_CODEC_RST#: Q21.1(S) R738.1 R68454.2
PCH_AZ_CODEC_SDIN0: R69059.2 U6539.DV37
PCH_AZ_CODEC_SDOUT: R68453.2 U20.5
PCH_AZ_CODEC_SYNC: R68452.2 U20.10
PCH_BLON_C: Q6521.5 R440.2 R25365.2 R25366.2 R25369.1
PCH_BLON_EC: R25366.1 U37.88
PCH_DISP_ON: R445.2 U6539.DM8
PCH_DPST_PWM: R443.1 U6539.DG10
PCH_DSWROK: R68476.1 R68479.2 R68482.1 U6539.DK35
PCH_IST_TP_0: TP13260.1 U6539.DU53
PCH_IST_TP_1: TP13255.1 U6539.DT52
PCH_JTAGX: R68265.1 U6539.D8
PCH_LVDS_BLON: R25365.1 U6539.DN8
PCH_OPI_RCOMP: R68264.2 U6539.CB9
PCH_PWROK: R68593.1 U37.78
PCH_PWROK_R: D13108.2 R68466.1 R68467.1 R68593.2 R68918.2 U6539.DN35
PCH_SMBCLK: Q6585.6 R68346.1 R68362.2 U6539.DK21
PCH_SMBDATA: Q6585.3 R68347.1 R68360.2 U6539.DM19
PCH_SPI0_CLK: R68336.1 R68571.1 U6539.DJ37
PCH_SPI0_CLK_R: R68571.2 R68572.2 R68583.1 R68584.2
PCH_SPI0_CS0#: R68581.1 U6539.DG37
PCH_SPI0_CS0#_R: R68581.2 R68582.1 R68589.1
PCH_SPI0_IO2: R68381.1 R68577.1 U6539.DJ39
PCH_SPI0_IO2_R: R68577.2 R68578.1
PCH_SPI0_IO3: R68378.1 R68384.1 R68579.1 U6539.DG35
PCH_SPI0_IO3_R: R68579.2 R68580.1
PCH_SPI0_SI: R68370.1 R68573.1 U6539.DJ35
PCH_SPI0_SI_R: R68573.2 R68574.2 R68585.1 R68586.2
PCH_SPI0_SO: R68575.1 U6539.DJ33
PCH_SPI0_SO_R: R68575.2 R68576.2 R68587.1 R68588.2
PCH_SPI1_CLK_R: R68584.1 U37.105
PCH_SPI1_SI_R: R25303.1 R68586.1 U37.102
PCH_SPI1_SO_R: R25316.1 R68588.1 U37.103
PCH_SPI_CS0#_R: R68589.2 U37.101
PCH_TBT_PERST#: R68408.2 R68411.1 R68685.2 U6539.DN43 U6554.2
PCH_TCK: R68276.1 TP13247.1 U6539.A7
PCH_TDI: R68266.1 R68269.1 U6539.B12
PCH_TDO: R68263.1 R68268.1 U6539.E12
PCH_TMS: R68261.1 R68267.1 U6539.A9
PCH_TRST#: R68271.1 R68275.1 U6539.H4
PCIE4_RCOMPN: R68426.1 U6539.V12
PCIE4_RCOMPP: R68426.2 U6539.Y12
PCIE_CLKREQ_#5: R68439.2 U6539.DG25
PCIE_CLKREQ_#6: R68442.2 U6539.DF23
PCIE_CLKREQ_LAN#: Q6531.1(S) R25446.1 R68437.2 U6539.DT24
PCIE_CLKREQ_SSD#: CN16.52 R68436.2 U6539.DT30
PCIE_CLKREQ_VGA#: Q9.3 R25487.1 R68441.2 U6539.DW30
PCIE_CLKREQ_WLAN#: Q63.1(S) R68440.2 U6539.DV30
PCIE_RCOMPN: R68421.1 U6539.DT9
PCIE_RCOMPP: R68421.2 U6539.DV9
PCIE_REQ_LAN#_R: Q6531.3 R25445.1 R25446.2 U6521.48
PCIE_RXN3_WLAN: CN17.43 U6539.CT1
PCIE_RXN5_SSD: R2652.1 U6539.CN1
PCIE_RXN5_SSD_C: CN16.5 R2652.2
PCIE_RXN6_SSD: R2654.1 U6539.CL3
PCIE_RXN6_SSD_C: CN16.17 R2654.2
PCIE_RXN7_SSD: R2656.1 U6539.CK2
PCIE_RXN7_SSD_C: CN16.29 R2656.2
PCIE_RXN8_SSD: R646.1 U6539.CK4
PCIE_RXN8_SSD_C: CN16.43 R646.2
PCIE_RXN9_LAN: C96306.2 U6539.CG4
PCIE_RXN_LAN_L: C96306.1 U6521.39
PCIE_RXP3_WLAN: CN17.41 U6539.CT2
PCIE_RXP5_SSD: R2653.1 U6539.CN2
PCIE_RXP5_SSD_C: CN16.7 R2653.2
PCIE_RXP6_SSD: R2655.1 U6539.CL4
PCIE_RXP6_SSD_C: CN16.19 R2655.2
PCIE_RXP7_SSD: R2657.1 U6539.CK1
PCIE_RXP7_SSD_C: CN16.31 R2657.2
PCIE_RXP8_SSD: R647.1 U6539.CK5
PCIE_RXP8_SSD_C: CN16.41 R647.2
PCIE_RXP9_LAN: C96307.2 U6539.CG5
PCIE_RXP_LAN_L: C96307.1 U6521.38
PCIE_TXN3_WLAN: C203.2 U6539.CU7
PCIE_TXN3_WLAN_C: C203.1 CN17.37
PCIE_TXN5_SSD: C788.1 U6539.CJ7
PCIE_TXN5_SSD_C: C788.2 CN16.11
PCIE_TXN6_SSD: C790.1 U6539.CG7
PCIE_TXN6_SSD_C: C790.2 CN16.23
PCIE_TXN7_SSD: C792.1 U6539.CD8
PCIE_TXN7_SSD_C: C792.2 CN16.35
PCIE_TXN8_SSD: C794.1 U6539.CB7
PCIE_TXN8_SSD_C: C794.2 CN16.47
PCIE_TXN9_LAN: C96792.2 U6521.42
PCIE_TXN9_LAN_C: C96792.1 U6539.BY8
PCIE_TXP3_WLAN: C202.2 U6539.CU8
PCIE_TXP3_WLAN_C: C202.1 CN17.35
PCIE_TXP5_SSD: C789.1 U6539.CJ8
PCIE_TXP5_SSD_C: C789.2 CN16.13
PCIE_TXP6_SSD: C791.1 U6539.CG8
PCIE_TXP6_SSD_C: C791.2 CN16.25
PCIE_TXP7_SSD: C793.1 U6539.CD9
PCIE_TXP7_SSD_C: C793.2 CN16.37
PCIE_TXP8_SSD: C795.1 U6539.CB8
PCIE_TXP8_SSD_C: C795.2 CN16.49
PCIE_TXP9_LAN: C96791.2 U6521.41
PCIE_TXP9_LAN_C: C96791.1 U6539.BY7
PCIE_WAKE#: CN49.9 Q33.1(S) R67506.2 R68463.1 R69099.2 U6539.DK39
PD#: C595.1 D12.2 D13.2 R478.1 R479.1 U20.47
PEDET: CN16.69 TP13376.1
PEG_RXN1: C358.1 U6539.V2
PEG_RXN1_C: C358.2 U8.AB9
PEG_RXN2: C384.1 U6539.T2
PEG_RXN2_C: C384.2 U8.AC10
PEG_RXN3: C6554.1 U6539.R2
PEG_RXN3_C: C6554.2 U8.AC11
PEG_RXN4: C6557.1 U6539.N2
PEG_RXN4_C: C6557.2 U8.AB12
PEG_RXP1: C370.1 U6539.V1
PEG_RXP1_C: C370.2 U8.AC9
PEG_RXP2: C382.1 U6539.T1
PEG_RXP2_C: C382.2 U8.AB10
PEG_RXP3: C6556.1 U6539.R1
PEG_RXP3_C: C6556.2 U8.AD11
PEG_RXP4: C6555.1 U6539.N1
PEG_RXP4_C: C6555.2 U8.AC12
PEG_TXN1: C96708.2 U8.AG7
PEG_TXN1_C: C96708.1 U6539.Y7
PEG_TXN2: C96704.2 U8.AE7
PEG_TXN2_C: C96704.1 U6539.V7
PEG_TXN3: C96707.2 U8.AF9
PEG_TXN3_C: C96707.1 U6539.T7
PEG_TXN4: C96703.2 U8.AG10
PEG_TXN4_C: C96703.1 U6539.P7
PEG_TXP1: C96706.2 U8.AG6
PEG_TXP1_C: C96706.1 U6539.Y5
PEG_TXP2: C96702.2 U8.AF7
PEG_TXP2_C: C96702.1 U6539.V5
PEG_TXP3: C96705.2 U8.AE9
PEG_TXP3_C: C96705.1 U6539.T5
PEG_TXP4: C96701.2 U8.AG9
PEG_TXP4_C: C96701.1 U6539.P5
PEGX_RST#: R296.2 R305.2 R306.2 R384.1
PEGX_RST#_C: R305.1 U9.4
PEX_CLKREQ#: Q9.1(S) R297.1 R25487.2 U8.AC6
PEX_TERMP: R312.2 U8.AF25
PEX_TSTCLK: R307.2 U8.AF22
PEX_TSTCLK#: R307.1 U8.AE22
PGANG: R68560.2 U6544.23
PINSET_TSEN: PR7021.2 PR7023.1 PR7028.1
PLTRST#: CN49.8 CN66.2 D13110.1(CATHODE) Q6620.3 R601.1 R2665.2 R68483.1 R68683.2 R68932.1 R69097.1 U9.2 U6539.DD41 U6554.1 U6565.1
PLTRST#_LAN: Q6620.1(S) R68929.1 R68932.2 U6521.36
PM_EXTTS#0: JDIM1.134 Q6639.1(EMITTER) R224.1
PM_EXTTS#1: JDIM02.134 Q124.1(EMITTER) R69024.1
PM_THRMTRIP#: Q86.1(EMITTER) Q124.3 Q6639.3 Q6640.3 R822.1 U6539.M5
PMON: PC18.2 PR23.1 PR25.2 PR7051.1
PP: R600.2 U33.4
PRE_SEL: R68215.1 U6537.27
PRIVACY_EN: CN29.14 R68881.1 R68883.2
PROCHOT#_CPU: R68260.2 U6539.E2
PROCHOT_EC: C6610.2 Q6509.2 R25298.2 U37.17
PROCPWRGD: R68480.2 U6539.BM9
PS_FB_CLAMP: R313.1 U8.F3
PSELF: R68556.1 R69003.2 U6544.22
PULSAR_38P4M_REFCLK: CN17.64 TP13354.1
PVADPTR: PC1.1 PC5.1 PD8001.1 PD9002.2 PQ1.5 PQ8006.1 PQ8006.2 PQ8006.3(S3) PQ8007.1 PQ8007.2 PQ8007.3(S3) PR31.1 PR9278.2 PR9279.1
PWM-VID: PR9015.1 R370.2
PWRLED#: CN48.20 CN52.12 CN55.10 R67484.1 U37.24
R_SPK+: R67367.1 R69068.1 U20.45
R_SPK+_1: C603.1 CN63.1 R67367.2
R_SPK+_1_VIKI: C96928.1 CN64.1 R69068.2
R_SPK-: R67368.1 R69069.1 U20.44
R_SPK-_1: C604.1 CN63.2 R67368.2
R_SPK-_1_VIKI: C96925.1 CN64.2 R69069.2
REGN6V: PC9.1 PR39.1 PU1.24
REQ_WLAN#: CN17.53 Q63.3 R652.1
RESET#_USB: C96779.1 D13110.2 R68551.1 R68558.2 U6544.17
RF_EN: R25318.2 R68691.2
RF_OFF#: CN17.56 R672.1 R68691.1 R68693.1
RING2: C591.2 C96265.1 CN51.2 D13094.1 R471.2 U20.17
ROM_CS: TP67.1 U8.D12
ROM_SCLK: R342.1 R352.2 U8.C12
ROM_SI: R341.1 R350.2 U8.B12
ROM_SO: R343.1 R351.2 U8.A12
RREF: R752.2 U40.1
RREF_U2_HUB: R68561.2 U6544.8
RSET: R4009.1 R67477.2 U6521.12
RSMRST#: R68954.1 U37.112
RSMRST#_R: R68470.2 R68476.2 R68954.2 U6539.DM35
RSVD_TP_2: TP13276.1 U6539.AL10
RSVD_TP_3: TP13277.1 U6539.AM12
RSVD_TP_4: TP13279.1 U6539.AH12
RSVD_TP_5: TP13281.1 U6539.AJ10
RSVD_TP_6: TP13282.1 U6539.AR1
RSVD_TP_7: TP13258.1 U6539.A51
RSVD_TP_8: TP13256.1 U6539.B51
RSVD_TP_9: TP13253.1 U6539.C1
RSVD_TP_10: TP13254.1 U6539.D2
RSVD_TP_11: TP13259.1 U6539.CP39
RSVD_TP_12: TP13261.1 U6539.CU40
RSVD_TP_13: TP13263.1 U6539.DV4
RSVD_TP_14: TP13264.1 U6539.DW3
RSVD_TP_15: TP13267.1 U6539.DU1
RSVD_TP_16: TP13269.1 U6539.DT2
RSVD_TP_17: TP13270.1 U6539.DW2
RSVD_TP_18: TP13271.1 U6539.DV2
RSVD_TP_19: TP13272.1 U6539.E1
RSVD_TP_20: TP13273.1 U6539.F1
RSVD_TP_21: TP13274.1 U6539.DR1
RSVD_TP_22: TP13275.1 U6539.DR2
RSVD_TP_23: TP13278.1 U6539.DR53
RSVD_TP_24: TP13280.1 U6539.DW5
RSVD_TP_26: TP13426.1 U6539.CY15
RSVD_TP_39: TP13425.1 U6539.CY28
RT3612_ALERT#: PR7049.2 PU7000.3
RT3612_BOOT1: PC7012.2 PU7000.25
RT3612_BOOT2: PC7027.2 PU7000.1
RT3612_COMP: PC7040.2 PR7054.1 PU7000.15
RT3612_FB: PC7040.1 PC7041.2 PR7054.2 PR7055.1 PU7000.16
RT3612_IMON: PR7061.2 PU7000.11
RT3612_ISEN1N: PR7039.2 PU7000.19
RT3612_ISEN1P: PC7034.2 PR7036.1 PR7038.1 PU7000.20
RT3612_ISEN2N: PR7048.2 PU7000.18
RT3612_ISEN2P: PC7036.2 PR7044.1 PR7047.1 PU7000.17
RT3612_LG1: PQ7000.8 PU7000.28
RT3612_LG2: PQ7001.8 PU7000.30
RT3612_PHASE1: PC7012.1 PL7001.1 PQ7000.5 PQ7000.6 PQ7000.7 PR7010.2 PR7011.1 PU7000.27
RT3612_PHASE2: PC7027.1 PL7000.1 PQ7001.5 PQ7001.6 PQ7001.7 PR7029.2 PR7030.1 PU7000.31
RT3612_PSYS: PC7042.2 PR7051.2 PR7053.1 PU7000.9
RT3612_PVCC: PC7011.1 PR7008.1 PU7000.29
RT3612_RGND: PC7043.2 PC7044.1 PR7057.1 PU7000.13
RT3612_SET1: PR7018.2 PR7026.1 PU7000.8
RT3612_SET2: PR7019.2 PR7027.2 PU7000.7
RT3612_SET3: PR7000.1 PR7020.2 PU7000.6
RT3612_TSEN: PR7022.1 PR7025.1 PU7000.21
RT3612_UG1: PR7009.1 PU7000.26
RT3612_UG1_R: PQ7000.1 PR7009.2
RT3612_UG2: PR7024.1 PU7000.32
RT3612_UG2_R: PQ7001.1 PR7024.2
RT3612_VCC: PC7002.1 PR7002.1 PU7000.10
RT3612_VCLK: PR7043.2 PU7000.5
RT3612_VDIO: PR7046.2 PU7000.4
RT3612_VIN: PC7003.2 PR7003.2 PU7000.22
RT3612_VR_READY: PR7041.2 PU7000.24
RT3612_VRHOT: PR7042.2 PU7000.2(V\R\H\O\T\)
RT3612_VRON: PC7038.2 PR7050.2 PR9289.1 PU7000.23 PU9006.4
RT3612_VSEN: PC7039.1 PC7041.1 PC7043.1 PR7055.2 PR7056.1 PU7000.14
RT6543_BOOT: PC7053.2 PU7001.10
RT6543_COMP: PC7067.1 PC7069.1 PU7001.5
RT6543_CS_DSI: PR7070.2 PU7001.1
RT6543_EN: PC7066.2 PR7078.2 PR7080.2 PR7082.2 PU7001.19
RT6543_FB: PC7068.1 PC7069.2 PR7083.2 PR7087.1 PU7001.6
RT6543_FSWSEL: PR7086.2 PR7089.2 PU7001.9
RT6543_ISN: PR7079.2 PU7001.3
RT6543_ISP: PR7079.1 PU7001.2
RT6543_LG: PQ7003.4 PU7001.13
RT6543_PG: PR7073.2 PR7074.2 PU7001.4
RT6543_PH: PC7053.1 PL7002.1 PQ7002.1 PQ7002.2 PQ7002.3(S3) PQ7003.5 PR7075.2 PU7001.12
RT6543_RGND: PR7090.1 PR7091.1 PU7001.7
RT6543_UG: PR7071.1 PU7001.11
RT6543_VCC: PC7054.1 PR7072.1 PU7001.15 PU7001.16
RT6543_VID0: PR7077.2 PU7001.18
RT6543_VID1: PR7076.2 PU7001.17
RT6543_VOUT: PR7081.2 PU7001.8
RT6543_VSYS: PC7045.2 PR7066.1 PU7001.20(VSYS)
RT_I2C_INT: Q6629.1(S) R68897.1 R68982.2 U6549.A10
RT_I2C_INT_C: Q6629.3 R68885.1 R68970.2 R68974.1 R68982.1 R68984.2 U6555.29
RT_I2C_SCL: Q6623.1(S) R68888.2 R68895.1 U6549.C9
RT_I2C_SDA: Q6621.1(S) R68887.2 R68896.1 U6549.E7
RT_PWR_EN+RESET: D13160.1(CATHODE) R68968.1 R68971.2 R68976.1 U6564.2
RT_PWR_EN_P1: R68634.1 R68719.2 R68972.2 U6550.C2
RT_RESET_P1: Q6612.3 R68630.2 R68969.2 R68970.1
RTC_RST#: C1217.1 J9007.1 Q22.3 R979.2 U6539.DN37
RTC_X1: R68433.1 R68434.1 U6539.DR47
RTC_X1_R: C96709.2 R68433.2 Y5.1
RTC_X2: R68434.2 R68438.1 U6539.DT47
RTC_X2_R: C96710.2 R68435.1 R68438.2
S5_ON: PR566.2 PR6015.1 PR6027.1 PU9005.1 R25309.1 U37.100
SATA_LED#: R68355.2 U6539.DV11
SATA_RXN0_CN: C6596.1 CN11.16
SATA_RXN0_HDD: C6588.2 U6539.CF3
SATA_RXN0_IN: C6588.1 U42.4
SATA_RXN_OUT: C6596.2 U42.12
SATA_RXP0_CN: C6597.1 CN11.15
SATA_RXP0_HDD: C6589.2 U6539.CF4
SATA_RXP0_IN: C6589.1 U42.5
SATA_RXP_OUT: C6597.2 U42.11
SATA_TXN0_CN: C6595.1 CN11.18
SATA_TXN0_HDD: C6587.2 U6539.BV9
SATA_TXN0_IN: C6587.1 U42.2
SATA_TXN_OUT: C6595.2 U42.14
SATA_TXP0_CN: C6594.1 CN11.19
SATA_TXP0_HDD: C6586.2 U6539.BT9
SATA_TXP0_IN: C6586.1 U42.1
SATA_TXP_OUT: C6594.2 U42.15
SC_PWRSV#: R25557.2 R67606.1 U6539.DK25
SCARDC6: CN53.4 U6509.2
SCARDC8: CN53.3 U6509.1
SCARDCLK: CN53.6 U6509.6
SCARDDATA: C20053.1 CN53.5 R25558.1
SCARDFCB: CN53.7 U6509.3
SCARDRST: CN53.8 U6509.5
SCL_GSENSOR: CN67.4 R25636.2 R25638.2 U6516.E5
SCL_GSENSOR_MB: Q6567.1(S) R25638.1 R67875.2 U6515.12
SCL_HUB_TO_CPU: Q6632.1(S) R25631.2 R25632.2 U6516.C4
SCL_SRC: R68200.2 U6537.34
SD_CDZ: Q6565.3 U40.13
SD_CDZ_R: CN62.11 R67539.2
SD_CLK: R67532.1 U40.15
SD_CLK_R: C1648.1 CN62.6 R67532.2
SD_CMD: R67899.1 U40.18
SD_CMD_R: C1647.1 CN62.3 R67899.2
SD_D0/MS_D6: R67897.1 U40.11
SD_D0/MS_D6_R: C1643.1 CN62.8 R67897.2
SD_D1/MS_D7: R67898.1 U40.10
SD_D1/MS_D7_R: C1644.1 CN62.9 R67898.2
SD_D2/MS_D5: R67895.1 U40.21
SD_D2/MS_D5_R: C1645.1 CN62.1 R67895.2
SD_D3/MS_D4: R67896.1 U40.20
SD_D3/MS_D4_R: C1646.1 CN62.2 R67896.2
SD_WP/MS_D1: Q6570.3 U40.8
SD_WP/MS_D1_R: CN62.10(WP SW) R67887.2
SDA_GSENSOR: CN67.3 R25635.2 R25637.2 U6516.E4
SDA_GSENSOR_MB: Q6567.4 R25637.1 R67873.2 U6515.2
SDA_HUB_TO_CPU: Q6633.1(S) R25629.2 R25630.2 U6516.C5
SDATA_SRC: R68201.2 U6537.33
SDREG: C1651.1 U40.6
SENSEA: R451.1 R452.1 U20.13
SET1_1: PR7014.2 PR7018.1
SET1_2: PR7026.2 PR7032.2
SET2_1: PR7015.2 PR7019.1
SET2_2: PR7027.1 PR7033.1
SET3_1: PR7016.2 PR7020.1
SET3_2: PR7000.2 PR7034.1
SIO_EXT_SCI#: U37.23 U6539.CY49
SKTOCC#: R68314.1 U6539.D52
SLEEVE: C590.2 C96268.1 CN51.1 D10.1 R468.2 U20.18
SLP_A#: R68933.2 U6539.DR41
SLP_LAN#: C96905.1 R67507.1 U6539.DN39
SLP_S0#: R592.1 R68485.1 R68486.1 R68750.1 R68953.2 U6539.DD42
SLP_S5#: R338.1 R68628.2 U6539.DM43
SLP_SUS#_EC: PU9005.2 R68475.2 R68765.1 U6539.DV49
SM_VREF: C266.1 R242.1 U6539.AU49
SMARTCARD_ON: Q6605.2 U37.4
SMB_ALERT#: R68388.2 R68389.2 R68395.1 U6539.DN19
SMB_ME1_CLK: Q6624.1(S) R68350.1 R68729.1 U6539.DK17
SMB_ME1_CLK_D: Q6624.3 R68729.2 R68731.1 U6555.4
SMB_ME1_DAT: Q6622.1(S) R68351.1 R68732.1 U6539.DJ17
SMB_ME1_DAT_D: Q6622.3 R68732.2 R68733.1 U6555.3
SMB_RUN_CLK: JDIM1.253 JDIM02.253 Q6585.1(S) R25531.2 R68362.1 R68363.1
SMB_RUN_DAT: JDIM1.254 JDIM02.254 Q6585.4 R25530.2 R68360.1 R68361.1
SMB_SML0_CLK: Q6616.4 R68893.1 R68898.1 U6549.A7
SMB_SML0_DAT: Q6616.1(S) R68894.1 R68899.1 U6549.B7
SMDDR_VREF_DQ1_M3: C20130.1 R67514.1 U6539.AU52
SML0_ALERT#: R68536.2 R68540.1 U6539.DN17
SN_VCORE1: PC7019.2 PR7010.1
SN_VCORE2: PC7033.2 PR7029.1
SNDW_RCOMP: R68458.1 U6539.DF33
SP2: TP100.1 U40.9
SP5: TP101.1 U40.12
SP7: TP102.1 U40.14
SP9: TP103.1 U40.16
SP11: TP97.1 U40.19
SP14: TP98.1 U40.22
SP_PLLVDD: C459.2 C460.2 C461.1 C462.1 L8.2 R329.1 U8.M6
SPI0_CLK_R: C96795.2 R68572.1 TP13312.1(TP) U6546.6 U6547.6 U6548.6
SPI0_CS0#_R: R68582.2 TP13311.1(TP) U6546.1 U6547.1 U6548.1
SPI0_SI_R: R68574.1 TP13313.1(TP) U6546.5 U6547.5 U6548.5
SPI0_SO_R: R68576.1 TP13314.1(TP) U6546.2 U6547.2 U6548.2
SPI_TPM_CS#: R68921.2 U6539.DF39
SPI_TPM_CS#_TPM: R586.1 R68921.1 U33.20
SPL_WLAN#: R68934.2 R68942.1 U6539.DT44
SRTC_RST#: C1211.1 Q6520.3 R971.2 U6539.DK37
SSD_DET_A12: TP13423.1 U6539.DF41
SSD_DET_E0: TP13422.1 U6539.DP4
SSD_MS_PWR_EN_GPPA11: U6539.DL52 U6565.2
SSD_MS_PWR_EN_GPPD16: R69100.1 U6539.DV25
SSD_PLTRST#: CN16.50 R69097.2 U6565.4(Y)
STRAP0: R344.1 R353.2 U8.D1
STRAP1: R345.1 R354.2 U8.D2
STRAP2: R346.1 R355.2 U8.E4
STRAP3: R347.1 R356.2 U8.E3
STRAP4: R348.1 R357.2 U8.D3
STRAP5: R349.1 R358.2 U8.C1
SUSB#: D13107.1(CATHODE) D13108.1(CATHODE) PU9006.2 R68474.2 R68849.1 R68951.2 R69086.1 U6539.DJ43
SUSC#: R68473.2 R69089.2 U6539.DJ41
SUSCLK_32K: R670.2 R69098.2 U6539.DW41
SUSCLK_32KHZ: CN17.50 R670.1
SUSLED#: CN48.21 CN52.13 CN55.11 R67486.1 U37.28
SUSON: PR5004.2 PR5023.1 PR7078.1 PR9285.2 PR9287.2 R25320.1 R68949.2 U37.120
SWP_PWR: CN58.4 TP13164.1
SYS_HWPG: D60.1(CATHODE) PR6004.1 PR6022.1 PR8041.1 PR8060.2 U37.124
SYS_PWROK: R68478.1 U6539.DF10
SYS_RESET#: R68469.2 U6539.DD10
SYS_SHDN#: PR3022.2 PR6002.1 PR6009.1 PR6020.1 Q86.3 U37.85
TABLET_MODE: CN4.2 R69084.1 U6525.1 U6556.13
TBT1_CC1: C96868.2 CN10.B5 D13118.1 U6555.9
TBT1_CC2: C96867.2 CN10.A5 D13119.1 U6555.7
TBT_FORCE_PWR: R68609.1 R68613.1 R68686.1 R68718.2 U6549.B10
TBT_FORCE_PWR_GPPB3: R68686.2 U6539.DB41
TBT_I2C_INT#: Q6625.1(S) R68728.1 R68734.1 U6539.CW40
TBT_I2C_INT#_D: Q6625.3 R68730.1 R68734.2 U6555.5
TBT_LSX0_RXD: R68816.2 R68874.1 U6549.L7
TBT_LSX0_RXD_SOC: R68365.2 R68372.1 R68816.1 U6539.DV8
TBT_LSX0_TXD: R68610.1 R68815.2 U6549.M7
TBT_LSX0_TXD_SOC: R68815.1 U6539.DU8
TBT_LSX1_RXD: R68366.2 R68373.1 U6539.DD6
TBT_LSX2_RXD: R68367.2 R68374.1 R68908.2 U6539.DM23
TBT_LSX3_RXD: R68368.2 R68375.1 U6539.DN21
TBTA_RX1_N: C96802.2 CN10.A10 R68671.2
TBTA_RX1_P: C96801.2 CN10.A11 R68670.2
TBTA_RX2_N: C96809.2 CN10.B10 R68673.2
TBTA_RX2_P: C96808.2 CN10.B11 R68672.2
TBTA_SBU1_CCG5_L: R68713.1 U6555.38
TBTA_SBU1_CCG5_R: R68715.1 U6555.36
TBTA_SBU1_CON_CCG5: CN10.B8 D13146.1 R68955.1 U6555.35
TBTA_SBU1_TX_BB: R68612.1 R68713.2 R68715.2 U6549.M10
TBTA_SBU2_CCG5_L: R68714.1 U6555.39
TBTA_SBU2_CCG5_R: R68716.1 U6555.37
TBTA_SBU2_CON_CCG5: CN10.A8 D13147.1 R68956.1 U6555.34
TBTA_SBU2_RX_BB: R68611.1 R68714.2 R68716.2 U6549.L10(PB_SBU2)
TBTA_SSRX1_N: R68596.1 U6549.J11
TBTA_SSRX1_N_C: C96802.1 D13152.1 R68596.2
TBTA_SSRX1_P: R68594.1 U6549.J12
TBTA_SSRX1_P_C: C96801.1 D13151.1 R68594.2
TBTA_SSRX2_N: R68601.1 U6549.C11
TBTA_SSRX2_N_C: C96809.1 D13156.1 R68601.2
TBTA_SSRX2_P: R68600.1 U6549.C12
TBTA_SSRX2_P_C: C96808.1 D13155.1 R68600.2
TBTA_SSTX1_N: R68599.1 U6549.G11
TBTA_SSTX1_N_C: C96805.1 D13154.1 R68599.2
TBTA_SSTX1_P: R68598.1 U6549.G12
TBTA_SSTX1_P_C: C96804.1 D13153.1 R68598.2
TBTA_SSTX2_N: R68605.1 U6549.E11
TBTA_SSTX2_N_C: C96813.1 D13158.1 R68605.2
TBTA_SSTX2_P: R68604.1 U6549.E12
TBTA_SSTX2_P_C: C96812.1 D13157.1 R68604.2
TBTA_TX1_N: C96805.2 CN10.B3 R68667.2
TBTA_TX1_P: C96804.2 CN10.B2 R68666.2
TBTA_TX2_N: C96813.2 CN10.A3 R68669.2
TBTA_TX2_P: C96812.2 CN10.A2 R68668.2
TBTB_HPD: TP13240.1 U6539.DF47
TCP0_AUX_DN: R68608.1 U6539.AP5
TCP0_AUX_DN_R: R68608.2 U6549.M8
TCP0_AUX_DP: R68606.1 U6539.AP7
TCP0_AUX_DP_R: R68606.2 U6549.L8
TCP0_FLASH_CLK: TP13351.1 U6549.C7 U6551.6
TCP0_FLASH_CS#: R68639.1 TP13350.1 U6549.B6 U6551.1
TCP0_FLASH_DI: TP13348.1 U6549.C6 U6551.5
TCP0_FLASH_DO: R68637.1 TP13349.1 U6549.B4 U6551.2
TCP0_FLASH_HOLD#: R68636.1 TP13346.1 U6551.7
TCP0_FLASH_MSTR_SLV: R68617.1 R68875.1 R68877.2 U6549.A5
TCP0_FLASH_SHARE_EN: R68614.1 R68876.2 U6549.A4
TCP0_FLASH_WP#: R68638.1 TP13347.1 U6551.3(W\P\(IO2))
TCP0_GPIO_5: R68597.1 U6549.B9
TCP0_GPIO_6: R68602.2 R68603.1 U6549.A8
TCP0_GPIO_12: R68616.1 R68620.1 U6549.A6
TCP0_JTAG_TCK: R68623.1 R68631.1 TP13342.1 U6549.B5
TCP0_JTAG_TDI: R68621.1 TP13340.1 U6549.A3
TCP0_JTAG_TDO: R68624.1 TP13343.1 U6549.C5
TCP0_JTAG_TMS: R68622.1 TP13341.1 U6549.C3
TCP0_RESET#: Q6612.1(S) R68625.1 R68626.1 R68628.1 R68630.1 R68884.1 U6549.L11
TCP0_TEST_PWRGD: R68595.1 U6549.B3
TCP0_THERMDA: TP13344.1 U6549.M11
TCP0_TX_N0: C96800.1 U6539.AT5
TCP0_TX_N0_C: C96800.2 U6549.J2
TCP0_TX_N1: C96807.1 U6539.AM7
TCP0_TX_N1_C: C96807.2 U6549.C2
TCP0_TX_P0: C96799.1 U6539.AT7
TCP0_TX_P0_C: C96799.2 U6549.J1
TCP0_TX_P1: C96806.1 U6539.AM5
TCP0_TX_P1_C: C96806.2 U6549.C1
TCP0_TXRX_N0: C96803.1 U6539.BB2
TCP0_TXRX_N0_C: C96803.2 U6549.G2
TCP0_TXRX_N1: C96811.1 U6539.AY1
TCP0_TXRX_N1_C: C96811.2 U6549.E2
TCP0_TXRX_P0: C96798.1 U6539.BB1
TCP0_TXRX_P0_C: C96798.2 U6549.G1
TCP0_TXRX_P1: C96810.1 U6539.AY2
TCP0_TXRX_P1_C: C96810.2 U6549.E1
TCP01_FLASH_BUSY#: R68607.1 U6549.A9
TCP_RETIMER_PERST#: R68683.1 R68684.1 R68685.1 U6549.B8 U6554.4
TCRCOMP_DN: R68242.2 U6539.AN1
TCRCOMP_DP: R68242.1 U6539.AN2
TCT1: C645.1 C96313.1 U25.1 U25.4 U25.7 U25.10
TEMP_MBAT#: PR8.1 PR14.2 PR18.1 U37.73
TESTMODE: R311.1 U8.AD9
THERM+: TP68.1 U8.F12(THERMDP)
THERM-: TP69.1 U8.E12
THERMAL_SHDN#: Q6640.1(EMITTER) R67422.1 R69027.1 U2.4
TOUCHPANEL_PWR: Q6592.2 U37.80
TP_3: TP13283.1 U6539.DW52
TP_4: TP13284.1 U6539.DV53
TP_DP1: TP13262.1 U6539.CY30
TP_INTH#_L: CN33.7 R573.1 R25473.1
TP_L34: TP13285.1 U6539.DD13
TP_M34: TP13257.1 U6539.DF53
TP_SMB_CLK: C699.1 CN33.6 R558.1
TP_SMB_DATA: C698.1 CN33.5 R560.1
TPCLK: L23.1 R566.1 U37.89
TPCLK-1: C696.1 CN33.2 L23.2
TPD_EN: R572.2 R574.1 R895.2
TPD_INT#: R573.2 R68737.1 U6539.DT21
TPD_INT#_EC: R25308.2 R25323.1 R25473.2
TPDAT-1: C697.1 CN33.3 L24.2
TPDATA: L24.1 R567.1 U37.90
TPM_LRESET#: R601.2 U33.17
TPM_PIRQ#: R580.1 R593.1 U6539.DU19
TPM_SPI0_CLK: R68583.2 U33.19
TPM_SPI0_SI: R68585.2 U33.21
TPM_SPI0_SO: R583.1 R68587.2 U33.24
TS_EN: R436.2 R956.1
TS_EN_C: C1210.1 R956.2 U37.81
TS_EN_R: CN29.28 R436.1
TS_INT#: CN29.11 TP13179.1
TS_ON: TP13368.1 U6539.DK29
TSEN_1: PR7017.2 PR7021.1
TSEN_2: PR7028.2 PR7035.1
TX0_HDMI+: R68232.1 U6537.17
TX0_HDMI-: R68233.1 U6537.16
TX1_HDMI+: R68230.1 U6537.20
TX1_HDMI-: R68231.1 U6537.19
TX2_HDMI+: R68228.1 U6537.23
TX2_HDMI-: R68229.1 U6537.22
TXC_HDMI+: LH1.1 U6537.14
TXC_HDMI-: LH1.4 U6537.13
TYPE C_ADP_IN: R68760.1 R68871.1
TYPEC1_OUT_1-5A: Q6617.2 R68903.1 U37.48
TYPEC1_USB0: C96855.2 C96856.2 C96857.2 C96858.2 C96859.2 CN10.A4 CN10.A9 CN10.B4 CN10.B9(VBUS_4) D13096.1 PC8000.1 PD8003.2 PD8007.2 PQ8002.1 PQ8002.2 PQ8002.3(S3) PQ8004.1(S) PR8003.2 PR8004.1 PR8006.1 R68696.1 R69057.1 U6553.15
TYPEC1_USB0_PD: PQ8002.5 PQ8006.5 PR9281.2
TYPEC_FAULT: C96911.2 R68868.2 R69010.2 R69011.1 U6553.10
UART1_RXD: TP13400.1 U6539.DT19
UART1_TXD: TP13399.1 U6539.DV19
UART2_RXD: TP13252.1 U6539.DG23
UART2_TXD: TP13251.1 U6539.DJ21
ULT_EDP_HPD: C6616.2 R25467.1 R68243.2 U6539.DR5
ULT_EDP_HPD_R: CN29.25 R25467.2
USB2_COMP: R68424.1 U6539.DE1
USB30_RX1+: C518.2 R422.2 U6539.CV2
USB30_RX1+_C: CN2.6 R422.1 U6530.2 U6530.9
USB30_RX1-: C513.2 R421.2 U6539.CV1
USB30_RX1-_C: CN2.5 R421.1 U6530.1 U6530.10(NC#4)
USB30_RX2+: C526.2 R428.2 U6539.CU3
USB30_RX2+_C: CN3.6 R428.1 U6531.2 U6531.9
USB30_RX2-: C523.2 R427.2 U6539.CT4
USB30_RX2-_C: CN3.5 R427.1 U6531.1 U6531.10(NC#4)
USB30_RX4+: CN48.14 U6539.CN5
USB30_RX4-: CN48.13 U6539.CN4
USB30_TX1+: C520.1 U6539.DA8
USB30_TX1+_C: C520.2 R432.2
USB30_TX1+_C_R: C522.1 CN2.9 R432.1 U6530.5 U6530.6
USB30_TX1-: C519.1 U6539.DA7
USB30_TX1-_C: C519.2 R424.2
USB30_TX1-_C_R: C521.1 CN2.8 R424.1 U6530.4 U6530.7
USB30_TX2+: C531.1 U6539.CW8
USB30_TX2+_C: C531.2 R430.2
USB30_TX2+_C_R: C533.1 CN3.9 R430.1 U6531.5 U6531.6
USB30_TX2-: C530.1 U6539.CW7
USB30_TX2-_C: C530.2 R429.2
USB30_TX2-_C_R: C532.1 CN3.8 R429.1 U6531.4 U6531.7
USB30_TX4+: CN48.18 U6539.CR8
USB30_TX4-: CN48.17 U6539.CR7
USB_BC_ON: U14.4 U37.97
USB_CHARGE_ON: R416.1 U14.5 U37.96
USB_CLT1: U14.6 U37.79
USB_ID: R68423.2 U6539.DF1
USB_OC0#: R68418.1 U14.13 U6539.DD8
USB_OC2#: R68248.2 U18.3 U6539.DK45
USB_OC3#: R68419.1 U15.3 U6539.DJ45
USB_VBUSSENSE: R68422.2 U6539.DC12
USBON#: U15.4 U18.4 U37.99
USBP1+_CR: U40.3 U6539.DC11
USBP1-_CR: U40.2 U6539.DC9
USBP2+_TPC: U6539.DA5 U6555.23
USBP2+_TPC_BOT: CN10.A6 D13144.1 U6555.26
USBP2+_TPC_TOP: CN10.B6 D13142.1 U6555.28
USBP2-_TPC: U6539.DA4 U6555.24
USBP2-_TPC_BOT: CN10.A7 D13145.1 U6555.25
USBP2-_TPC_TOP: CN10.B7 D13143.1 U6555.27
USBP3+_LTE: CN49.19 U6539.DB4
USBP3-_LTE: CN49.20 U6539.DB3
USBP4+: R25518.2 U6539.DC8
USBP4+_R: CN2.3 D13162.1 R25518.1
USBP4-: R25517.2 U6539.DC7
USBP4-_R: CN2.2 D13163.1 R25517.1
USBP5+_CAM: R25289.1 U6539.DA12
USBP5+_CAM_C: CN29.8 D13111.2 R25289.2
USBP5-_CAM: R25288.1 U6539.DA11
USBP5-_CAM_C: CN29.7 D13112.2 R25288.2
USBP6+_HUB: R68565.1 U6539.DA1
USBP6+_HUB_R: R68565.2 U6544.2
USBP6+_HUB_SM: R25560.1 U6544.7
USBP6+_HUB_SM_R: R25560.2 U6509.9
USBP6+_HUB_TS: R67414.1 U6544.4
USBP6+_HUB_TS_R: CN29.5 D13114.2 R67414.2
USBP6-_HUB: R68564.1 U6539.DA2
USBP6-_HUB_R: R68564.2 U6544.1
USBP6-_HUB_SM: R25559.1 U6544.6
USBP6-_HUB_SM_R: R25559.2 U6509.8
USBP6-_HUB_TS: R67415.1 U6544.3
USBP6-_HUB_TS_R: CN29.4 D13113.2 R67415.2
USBP7+_FP: R67492.1 R67497.2 U6539.DD1
USBP7+_FP_P2: CN14.7 EC7.2 R67492.2
USBP7+_FP_P4: CN52.7 EC16.2 R67497.1
USBP7-_FP: R67493.1 R67496.2 U6539.DD2
USBP7-_FP_P2: CN14.6 EC8.1 R67493.2
USBP7-_FP_P4: CN52.8 EC17.1 R67496.1
USBP8+: U14.3 U6539.CW9
USBP8+_C: R425.2 U14.10
USBP8+_C_R: CN3.3 D13165.1 R425.1
USBP8-: U14.2 U6539.DA9
USBP8-_C: R426.2 U14.11
USBP8-_C_R: CN3.2 D13164.1 R426.1
USBP9+_DB: R67462.2 R69071.2 U6539.DD5
USBP9+_DB_RS232: CN55.8 R69071.1
USBP9+_DB_USB: CN48.10 R67462.1
USBP9-_DB: R67461.2 R69070.2 U6539.DD4
USBP9-_DB_RS232: CN55.7 R69070.1
USBP9-_DB_USB: CN48.9 R67461.1
USBP10+_BT: CN17.3 U6539.CV4
USBP10-_BT: CN17.5 U6539.CY3
USIM_DET: CN49.11 R69065.2 U37.68
VA2: PC2.1 PQ1.1 PQ1.2 PQ1.3(S3) PQ9054.1 PQ9054.2 PQ9054.3(S3) PR28.1
VADJ1: C558.1 CN29.27 R441.2 R442.1
VADPBL: PQ8001.5 PQ8007.5 PR9280.2
VCOREI: R68796.1 U6556.8
VGA_DDC_CLK_RT: C20006.2 CN21.15 ESD4.5 ESD4.6 R25529.2 U67.15
VGA_DDC_DAT_RT: C20004.1 CN21.12 ESD4.1 ESD4.10(NC#4) R25528.2 U67.16
VGA_DDI2_AUXN_C: C20014.2 U67.3
VGA_DDI2_AUXP_C: C20015.2 U67.2
VGA_DDI2_TXN0_C: C20017.2 U67.6
VGA_DDI2_TXN1_C: C20019.2 U67.8
VGA_DDI2_TXP0_C: C20016.2 U67.5
VGA_DDI2_TXP1_C: C20018.2 U67.7
VGA_OVT#: Q15.1(S) R395.1 U8.A6
VGA_RST#: C364.1 R296.1 U8.AC7
VGA_SDA: R458.2 R25530.1 U67.29
VGA_SLK: R25531.1 R25533.2 U67.30
VGA_VCCSENSE: PR9026.2 PR9028.2 U8.F2
VGA_VSSSENSE: PR9029.2 PR9031.2 U8.F1
VL: PR3020.1 PR6025.1 PR8050.2
VMA_CLK0: R25488.2 U8.D24 VRAM1.J12
VMA_CLK0#: R25488.1 U8.D25 VRAM1.J11
VMA_CLK1: R25489.2 U8.N22 VRAM2.J12
VMA_CLK1#: R25489.1 U8.M22 VRAM2.J11
VMA_DQ0: U8.E18 VRAM1.E2
VMA_DQ1: U8.F18 VRAM1.F2
VMA_DQ2: U8.E16 VRAM1.A2
VMA_DQ3: U8.F17 VRAM1.B2
VMA_DQ4: U8.D20 VRAM1.F4
VMA_DQ5: U8.D21 VRAM1.B4
VMA_DQ6: U8.F20 VRAM1.E4
VMA_DQ7: U8.E21 VRAM1.A4
VMA_DQ8: U8.E15 VRAM1.B11
VMA_DQ9: U8.D15 VRAM1.E13
VMA_DQ10: U8.F15 VRAM1.A13
VMA_DQ11: U8.F13 VRAM1.A11
VMA_DQ12: U8.C13 VRAM1.E11
VMA_DQ13: U8.B13 VRAM1.F11
VMA_DQ14: U8.E13 VRAM1.B13
VMA_DQ15: U8.D13 VRAM1.F13
VMA_DQ16: U8.B15 VRAM1.N11
VMA_DQ17: U8.C16 VRAM1.U11
VMA_DQ18: U8.A13 VRAM1.M11
VMA_DQ19: U8.A15 VRAM1.T11
VMA_DQ20: U8.B18 VRAM1.U13
VMA_DQ21: U8.A18 VRAM1.T13
VMA_DQ22: U8.A19 VRAM1.N13
VMA_DQ23: U8.C19 VRAM1.M13
VMA_DQ24: U8.B24 VRAM1.N4
VMA_DQ25: U8.C23 VRAM1.U4
VMA_DQ26: U8.A25 VRAM1.M4
VMA_DQ27: U8.A24 VRAM1.T4
VMA_DQ28: U8.A21 VRAM1.T2
VMA_DQ29: U8.B21 VRAM1.U2
VMA_DQ30: U8.C20 VRAM1.M2
VMA_DQ31: U8.C21 VRAM1.N2
VMA_DQ32: U8.R22 VRAM2.U11
VMA_DQ33: U8.R24 VRAM2.N11
VMA_DQ34: U8.T22 VRAM2.U13
VMA_DQ35: U8.R23 VRAM2.M11
VMA_DQ36: U8.N25 VRAM2.N13
VMA_DQ37: U8.N26 VRAM2.M13
VMA_DQ38: U8.N23 VRAM2.T11
VMA_DQ39: U8.N24 VRAM2.T13
VMA_DQ40: U8.V23 VRAM2.M4
VMA_DQ41: U8.V22 VRAM2.N4
VMA_DQ42: U8.T23 VRAM2.U4
VMA_DQ43: U8.U22 VRAM2.T4
VMA_DQ44: U8.Y24 VRAM2.N2
VMA_DQ45: U8.AA24 VRAM2.T2
VMA_DQ46: U8.Y22 VRAM2.M2
VMA_DQ47: U8.AA23 VRAM2.U2
VMA_DQ48: U8.AD27 VRAM2.F2
VMA_DQ49: U8.AB25 VRAM2.B2
VMA_DQ50: U8.AD26 VRAM2.E2
VMA_DQ51: U8.AC25 VRAM2.A2
VMA_DQ52: U8.AA27 VRAM2.B4
VMA_DQ53: U8.AA26 VRAM2.A4
VMA_DQ54: U8.W26 VRAM2.E4
VMA_DQ55: U8.Y25 VRAM2.F4
VMA_DQ56: U8.R26 VRAM2.B13
VMA_DQ57: U8.T25 VRAM2.A13
VMA_DQ58: U8.N27 VRAM2.F13
VMA_DQ59: U8.R27 VRAM2.E13
VMA_DQ60: U8.V26 VRAM2.A11
VMA_DQ61: U8.V27 VRAM2.B11
VMA_DQ62: U8.W27 VRAM2.F11
VMA_DQ63: U8.W25 VRAM2.E11
VMA_WCK01: U8.D18 VRAM1.D4
VMA_WCK01#: U8.C18 VRAM1.D5
VMA_WCK23: U8.D17 VRAM1.P4
VMA_WCK23#: U8.D16 VRAM1.P5
VMA_WCK45: U8.T24 VRAM2.P4
VMA_WCK45#: U8.U24 VRAM2.P5
VMA_WCK67: U8.V24 VRAM2.D4
VMA_WCK67#: U8.V25 VRAM2.D5
VNN_CTRL: TP13402.1 U6539.DV12
VR_SVID_ALERT#: PR7005.2 PR7049.1 R68283.1 R68285.2
VR_SVID_CLK: PR7006.2 PR7043.1 R68286.2
VR_SVID_DATA: PR7004.2 PR7046.1 R68284.1 R68287.2
VRALERT#: Q6654.3 R68513.1 R68514.1 R68913.1 U6539.DB39
VREF_RC: PC7018.2 PR7013.2
VRON: PR7050.1 PU9006.1 R25311.1 U37.69
VSTBY_3.3V_R: R68795.2 U6556.18
VSTBY_FSPI: R359.2 R25330.2 U37.106
WIGIG_LED: CN17.6 TP9029.1
WLAN_PCIE_WAKE#: R69029.2 U6539.DJ19
WLAN_RST#: CN17.52 R2665.1
WLANPWR#: Q6601.1(S) R68758.1 R68764.2
WRST#: C6571.1 D63.2 R25300.1 U37.14(WRST#)
WRST#_8350: C20142.1 D13093.2 R25633.2 U6516.A2(WRST#)
WRST_IT8013: C96881.1 D13148.2 R68799.1 R69014.1 U6556.4(WRST#)
XD_CD#: TP99.1 U40.7
XD_D7: TP96.1 U40.23(XD_D7)
XDP_TCK: R68265.2 R68274.1 TP13246.1 U6539.B6
XDP_TDI_CPU: R68269.2 TP13245.1 U6539.A12
XDP_TDO_CPU: R68268.2 TP13244.1 U6539.D12
XDP_TMS_CPU: R68267.2 TP13243.1 U6539.B9
XDP_TRST#: R68271.2 TP13242.1 U6539.K4
XIN: C96778.1 U6544.10 Y7.1
XOUT: C96777.1 U6544.11(XOUT) Y7.3
XTAL1: R511.1 U6521.9
XTAL2: R512.1 U6521.10
XTAL_38P4M_IN: R68444.2 R68446.1 U6539.DL1
XTAL_38P4M_IN_R: C96711.2 R68444.1 Y6.1
XTAL_38P4M_OUT: R68446.2 R68447.2 U6539.DM1
XTAL_38P4M_OUT_R: C96713.2 R68447.1 Y6.3
XTAL_SSIN: R331.1 U8.A10
XTAL_TCP0_25MHZ_IN: C96814.2 U6549.L9 Y8.1
XTAL_TCP0_25MHZ_OUT: C96815.2 U6549.M9 Y8.3
N10350616: PC7001.2 PR7001.2 PR7004.1 PR7005.1 PR7006.1 PR7007.2
N10356361: PR7022.2 PR7023.2 PR7025.2
N15767591: C20130.2 R25614.2
N16244674: R1616.2 U67.28
N16251939: R67598.1 U6521.46
N16251941: R67599.1 U6521.47
N16390345: C266.2 R244.2
N16826936: R323.2 R324.2 U11.2
N17011327: C572.2 U20.39
N17011330: C566.2 U20.37
N17011339: C567.1 U20.34
N17011340: C573.1 U20.19
N17011365: R454.2 U20.48
N17011429: R69059.1 U20.8
N17011431: C578.1 U20.7
N17011437: R738.2 U20.11
N17011447: C846.1 U20.12
N17011480: C566.1 U20.35
N17061276: PJ1.3 PR13.1
N17061293: PQ9054.5 PR1.2 PR3.1
N17061294: PR5.1 PU1.20
N17061299: PR6.1 PU1.19
N17061317: PJ1.5 PR14.1
N17061319: PC17.1 PL5.2 PQ2.1 PQ2.2 PQ2.3(S_3) PR7.1 PR209.1 PR210.1
N17061327: PC1.2 PC2.2 PQ1.4 PQ9054.4 PR29.1
N17061416: PC19.1 PR33.2
N17061438: PC15.2 PR11.2
N17061451: PJ1.4 PR12.1
N17061494: PC17.2 PQ2.4 PR4.1
N17072870: PC9080.1 PC9081.1 PC9082.1 PC9083.1 PC9084.1 PC9085.1 PC9086.1 PC9087.1 PJ9002.1 PL9002.2 PR9263.1
N17073105: PC9089.2 PR9094.1 PR9263.2
N17184837: D11.1(CATHODE) D6543.1(CATHODE) R735.1
N17326408: PQ17.2 PR230.1 PR235.2 PR9276.2
N17412621: PR30.1 PU1.5
N17419587: PC8003.2 PQ8001.4 PQ8003.3 PR8002.2 PR8008.1
N17419880: PC8000.2 PQ8002.4 PQ8004.3 PR8004.2 PR8009.1
N17421868: PQ8012.3 PR8022.1
N17421870: PQ8006.4 PQ8012.6 PR8000.2
N17421874: PQ8012.2 PQ8012.5 PR8031.1
N17421890: PD8001.2 PQ8009.2 PQ8010.2 PR8023.2
N17421892: PQ8013.3 PR8024.1
N17421946: PQ8013.2 PQ8013.5 PR8032.1
N17421950: PQ8007.4 PQ8013.6 PR8030.2
N17421954: PQ8013.1 PR9278.1
N17421956: PQ8010.1(S) PQ8013.4(E2)
N17422036: PQ8009.1(S) PQ8012.4(E2)
N17423044: PQ8005.6 PR9277.1
N17423573: PQ8012.1 PR9279.2
N17424509: PQ8010.3 PR9280.1
N17424572: PQ8009.3 PR9281.1
N17424918: PR19.1 PU1.11
N17424920: PR17.1 PU1.12
N17424921: PR32.1 PU1.7
N17424925: PR25.1 PU1.9
N17424950: PR8.2 PR205.2 PU1.15
N17661815: PR26.1 PU1.8
N17755724: PC7070.2 PR7081.1 PR7084.1 PR7085.1 PR7087.2 PR7088.1
N18453595: CN11.13 R67866.1
N18723876: C646.2 R516.1 R517.1 R518.1 R519.1
N18867651: PC6020.1 PC6021.1 PR9245.2 PU6001.8
N18867812: PC6042.1 PC6043.1 PR9249.2 PU6002.8
N18922914: C425.2 C429.2 C431.2 R299.2 U8.AA8 U8.AA9
N19138106: R321.2 U8.F22
N19138109: R322.2 U8.J22
N19521323: PQ6000.3 PR6006.1
N19521733: PQ6000.2 PR6012.1 PR9268.2 PR9269.2 PR9285.1
N19549602: PQ6001.2 PR6024.1 PR9270.2 PR9271.2 PR9287.1
N19634328: R67886.1 U37.83
N20910893: Q6565.2 R67539.1 R67865.2
N20911229: Q6570.2 R67887.1 R67888.2
N21263014: TP65.1 U8.E10
N21263017: TP66.1 U8.F10
N22317721: CN62.5 F1.2
N22358547: CN53.10 F2.2
N23734831: PC9067.1 PC9068.1 PC9069.1 PJ9003.1 PQ9008.1 PQ9008.2 PQ9008.3(S3) PR9073.1
N24164996: TP13238.1 U6539.DM29
N24164998: TP13239.1 U6539.DK27
N24182417: R68313.2 U6539.AR2
N24199172: Q28.2 R67361.2 R67362.1
N24203006: TP13303.1 U6544.27
N24212326: Q6591.1(S) R68790.2
N24212345: Q6591.2 Q6592.3 R68567.2
N24507636: PC229.1 PC6230.1 PC6231.1 PJ3008.1 PL14.2 PR6414.2
N24507642: PC9097.1 PR283.1 PR6418.2 PU3003.6
N24507664: PC9097.2 PR6414.1 PR6418.1
N24507676: PC6229.2 PR6417.2 PU3003.1
N24507691: PR284.2 PU3003.5
N24586142: TP13352.1 U6539.DN4
N24586144: TP13353.1 U6539.DT6
N24690147: C375.2 C380.2 C386.2 L4.2 U8.F11
N24716276: TP13407.1 U6555.1
N24716283: TP13408.1 U6555.40
N24717383: R68712.1 R69081.1 U6555.30
N24718994: R68718.1 U6555.14
N24719030: R68719.1 R68971.1 U6555.13
N24720119: Q6623.3 R68721.1 R68888.1 U6555.21
N24720120: Q6621.3 R68720.1 R68887.1 U6555.20
N24742096: PD9001.2 PQ9011.3 PR9075.2
N24742104: PQ9009.2 PQ9010.3 PQ9011.2 PR9074.2 PR9077.1
N24742107: PC9055.1 PC9056.1 PR9067.1 PU9002.13(VOUT1)
N24742118: PR9078.2 PU9003.3
N24742123: PQ9009.3 PR9073.2
N24742126: PC9073.1 PQ9010.2 PR9079.2 PU9003.4
N24742146: PC9071.1 PR9080.2
N24742173: PC9059.1 PR9069.2 PU9002.4
N24742207: PC9063.1 PU9002.10
N24742208: PC9062.1 PU9002.12
N24742222: PC9060.1 PR9070.1 PU9002.5
N24742230: PC9064.1 PR9072.2 PU9002.3
N24846908: R25619.2 R25620.1 R67507.2 R67508.2
N24846932: C20132.2 Q23.2 R25620.2
N24915888: C20011.2 R69051.1 U67.26
N24995566: PC6228.1 PR3020.2 PU3002.5(VCC)
N24995570: PR3021.2 PU3002.1
N24995581: PR3022.1 PU3002.3
N25112700: TP13365.1 U6539.DF8
N25115277: Q85.1(S) R821.2 R825.2
N25115299: Q86.2 R821.1
N25121416: C96870.2 C96878.2 Q6600.2 Q6601.3 R68752.2 R68757.2 R68758.2
N25121434: Q6601.2 R68755.1 R68941.2 R68942.2
N25121442: Q6601.5 Q6601.6 R68751.2
N25125657: R68750.2 U37.35
N25126048: Q6603.3 R68759.2 R68761.1
N25130063: C1208.2 R960.1 U37.82
N25130097: C6580.2 R895.1 U37.98
N25130580: R68764.1 R68769.1 R68870.1 U37.20
N25235355: PQ8005.2 PR8015.2 PR8017.2
N25257440: PQ8005.3 PR8007.2 PR9277.2
N25257697: PQ8005.5 PR8006.2 PR8014.1 PR8016.1
N25318825: PQ8000.3 PR8005.1
N25318883: PQ8000.2 PR8010.1 PR8011.2 PR8012.1
N25318964: PQ8000.1(S) PR8012.2 PR8013.1
N25319146: PQ8003.2 PR8001.2 PR8005.2
N25365001: PQ9084.3 PR9103.2
N25415674: Q6604.2 Q6605.3 R68792.2
N25430988: PQ12.3 PR106.2
N25430994: PQ19.3 PR126.2
N25431520: PQ9050.3 PR9227.2
N25498070: R68881.2 U6556.15
N25498073: R68867.2 U6556.14
N25804343: PR9027.2 PR9030.2
N25817818: PQ9085.3 PR9099.2
N25817820: PQ9085.2 PQ9086.3 PR9100.2 PR9101.1
N25821251: PC9088.1 PR9092.2
N25875824: R68844.1 R68846.2 U6562.2
N25875922: R68846.1 U6561.4
N25875939: Q6610.2 Q6611.3 R68845.1
N25875956: R68849.2 R68852.2 U6561.1
N25876028: Q6611.2 R68848.2 R68850.2 R68851.2
N25876122: R68853.1 U6562.4
N25876250: R68856.1 U6563.4
N26318025: CN50.5 CN50.6 R69050.2
N26402629: PC561.1 PC562.1 PC563.1 PC9098.1 PJ9005.1 PL551.2 PR569.2
N26712738: R69083.2 R69084.2 U37.126
N26812254: PQ9088.3 PR9286.2
N26985789: TP13391.1 U6539.DK10
N27093787: R68878.1 U6549.J6
N27303190: TP13392.1 U6539.DF6
N27303193: TP13393.1 U6539.DK23
N27407759: R68919.1 R68920.1 U6554.5(VCC)
N27485779: TP13394.1 U6539.BV7
N27485780: TP13395.1 U6539.BV8
N27485781: TP13396.1 U6539.CG2
N27485782: TP13397.1 U6539.CG1
N27487756: TP13398.1 U6539.DF35
N27533429: Q6618.3 R67505.1 R67506.1 R68925.1
N27664004: R68939.2 U6539.DW38
N27752748: R450.2 R736.2
N27826847: CN17.42 R68945.1
N27826858: CN17.40 R68944.1
N27826869: CN17.38 R68943.1
N27947671: R68946.1 U6539.DV15
N27947696: TP13401.1 U6539.DJ10
N27947896: R68947.2 U6539.DF25
N27947914: R68948.2 U6539.DF27
N28099262: R68828.2 R68834.1 R68838.1 R68950.1 R68951.1 R68952.2 R68953.1
N28099429: R68831.1 R68832.2 U6559.2
N28099505: R68832.1 U6558.4
N28099527: R68834.2 U6558.1
N28099545: Q6608.3 R68833.2
N28099579: R68857.1 U6559.4
N28099660: D13149.3(COMMON ANODE) D13150.3(COMMON ANODE) R68837.1
N28099672: D13149.1 R68838.2
N28379472: PC9025.1 PR9021.2 PR9023.1 PR9024.1
N28379477: PC9024.1 PR9019.1
N28380796: PR9017.1 TP9000.1
N28380828: PC9004.1 PR9000.2 PR9002.2
N28433042: PR9033.1 PR9274.1 PU9000.13
N28477601: R339.2 R341.2 R342.2 R343.2
N28607521: PR9034.1 PU9000.22
N28835637: R68765.2 R68871.2 U37.5
N29093947: Q14.2 Q16.3 R386.1
N29227824: C96906.2 D13160.2 R68969.1 R68976.2
N30140264: C842.1 D13092.2 HE1.2(VCC) R25519.2
N30263848: C20140.2 U6516.B3
N30263849: TP9067.1 U6516.A1
N30263851: TP9068.1 U6516.D1
N30263855: TP9071.1 U6516.B1
N30263859: TP9072.1 U6516.E1
N30330849: PC9074.1 PC9076.1 PC9077.1 PC9078.1 PJ9009.1 PR9086.2 PU9004.8 PU9004.9 PU9004.22 PU9004.24
N30330942: PC9079.2 PR9089.1
N30344538: R69004.1 U6553.14
N30344562: R68681.1 R68902.1 U6553.13
N30344604: C96909.1 U6553.12
N30344614: Q6617.3 R68902.2
N30344643: R69008.1 U6553.8
N30344645: R69009.1 U6553.9
N30344649: C96908.1 R69005.1 U6553.11
N30345632: Q6593.3 R68677.2 R68680.1 U6553.4
N30355139: C96910.2 U6553.7(VREG)
N30442036: PC6040.1 PC6041.1 PR9248.1 PU6002.13(VOUT1)
N30442060: PC6051.1 PR6023.1 PU6002.4
N30442062: PC6056.1 PU6002.12
N30442063: PC6057.1 PU6002.10
N30452871: PC6053.1 PR6028.2 PU6002.5
N30452875: PC6052.1 PR6027.2 PU6002.3
N30586955: PC6024.2 PR6010.1 PR6014.2 PU6000.12
N30586967: PC6024.1 PR6011.1
N30587068: PC6059.2 PR6030.1 PR6031.2 PU6003.9
N30587073: PC6059.1 PR6029.1
N30587125: PC6054.1 PR6025.2 PU6003.12
N30587150: PQ6001.3 PR6021.1
N30587190: PR6003.2 PR6004.2 PR6005.1 PR6007.1
N30789824: TP9073.1 U6516.B4
N30789945: TP9070.1 U6516.D2
N30839245: C750.2 Q32.2 R609.2
N31076875: PC6018.1 PC6019.1 PR9244.1 PU6001.13(VOUT1)
N31161958: PC6025.1 PR6013.1 PU6001.4
N31161974: PC6028.1 PU6001.12
N31161976: PC6029.1 PU6001.10
N31162017: PC6027.1 PR6016.2 PU6001.5
N31162025: PC6026.1 PR6015.2 PU6001.3
N31353100: PC551.2 PR551.2
N31548948: JDIM02.96 R69022.2
N31551497: JDIM1.96 R69023.2
N31552936: Q124.2 R1684.2
N31558072: Q6639.2 R69025.2
N31570187: Q6640.2 R69026.2
N31759245: CN17.8 R69030.1
N31759916: CN17.12 R69031.1
N31760419: CN17.20 R69032.1
N31760441: R69033.2 R69034.2 U6539.DJ27
N31858909: R69035.2 U6556.16
N31870175: C96919.2 Q6642.3 R69045.1
N31870199: C96918.2 Q6642.2 Q6643.3 R69043.2
N31875033: C96921.2 Q6644.3 R69046.1
N31875049: C96920.2 Q6644.2 Q6645.3 R69047.2
N32270324: Q62.3 R68907.1
N32270343: Q62.6 R68906.1
N32484985: PQ8008.2 PR8018.2 PR8021.1
N32484987: PR8021.2 PR8025.2 PR8027.1
N32485009: PQ8008.3 PQ8011.2 PR8028.1
N32485013: PQ8008.1(EMITTER) PQ8011.1(EMITTER) PR8019.2 PR8020.2
N32485017: PQ8011.3 PR8026.1 PR8029.1
N32485347: PQ8004.2 PR8003.1 PR8007.1
N33144601: CN13.2 CN13.4 R69055.2
N33147251: PC5006.1 PR9288.2 PU5001.2(VTTSNS) PU5001.20
N33772426: CN16.10 TP2092.1
N33772437: CN16.68(SUSCLK) R69098.1
N34070491: TP13410.1 U6539.D4
N34070504: TP13411.1 U6539.BF12
N34070780: TP13412.1 U6539.V21
N34070795: TP13413.1 U6539.W20
N34070810: TP13414.1 U6539.U37
N34070825: TP13415.1 U6539.CD39
N34070840: TP13416.1 U6539.U21
N34070855: TP13417.1 U6539.BB12
N34070870: TP13418.1 U6539.W37
N34070885: TP13419.1 U6539.AY12
N34070900: TP13420.1 U6539.W38
N34070915: TP13421.1 U6539.U38
N34108788: R69064.1 U6539.DV51
N34384094: R68972.1 U6564.4
N34859022: Q6646.3 R69073.2
N34933887: L28.1 R449.2 R69075.2
N34933983: Q21.2 R69076.1 R69077.1
N34974672: Q6651.2 Q6651.3 R101.1
N35012653: D13161.1(CATHODE) Q6652.3 R25468.1 R69109.2
N35456412: R68868.1 R69085.2 R69107.2 U37.87
N35456674: R69086.2 R69087.2 R69103.2 U37.119
N35456734: R68568.2 R68883.1 R69014.2 R69088.2 U37.95
N35456780: R68570.1 R68736.1 R69080.1 R69089.1 R69090.1 U37.18
N35630525: R68975.1 U6555.18
N35745518: PR7063.2 PR7064.1 PR7065.1
N35745545: PQ7002.4 PR7071.2
N35745570: PC7068.2 PR7084.2
N35745574: PC7067.2 PR7083.1
N35745601: PC7061.2 PR7075.1
N35785828: Q6649.3 R68392.2 R69091.2
N36079396: C96930.2 Q6655.3 R69092.1
N36079412: C96929.2 Q6655.2 Q6656.3 R69093.2
N36122863: CN16.54 R69099.1
N36201799: R69101.1 U37.93
N36446693: C639.2 R512.2 Y4.3
N36874581: Q6646.2 Q6657.3 R69105.2 R69106.1
N36969721: QG17.2 QG17.3 RG79.2
N36969723: DG4.3(COMMON ANODE) QG15.1(S) QG17.5 RG77.2
N36971051: DG4.1 R69111.2
N36977514: Q30.2 Q31.3 R579.2
N37012493: QG15.3 R69110.1
N37012817: DG4.2 R69112.2
N37162929: R454.1 TP9023.1
N37164070: C844.2 C846.2 R734.2 R25371.1
N37164724: R735.2 R25371.2
N37352433: PC9012.1 PR9004.1
N38680880: Q6523.2 R576.1
N38756671: C6568.2 R25318.1 U37.66
N38756768: R69102.1 U37.76
N38756834: Q81.3 R25321.2 SW2.3 SW2.4
N38757336: C6563.1 R25308.1 U37.128
N38757406: C1044.1 Q81.2 R25310.2 SW4.3 SW4.4
N38758998: C6562.2 R402.1
N38759178: C1190.1 U37.12
N40437801: TP9033.1 U8.V7
N40437812: TP9032.1 U8.W7
N40437815: TP9031.1 U8.W6
N40437818: TP9030.1 U8.Y6
N40911013: R405.2 VRAM1.J13(ZQ)
N40911015: R406.2 VRAM2.J13(ZQ)
N41129495: R68505.1 R68506.1 U6539.DA28
N41131693: Q6582.3 Q6583.2 R68250.2
N41131697: Q6582.2 R68254.2 R68256.2
N41733375: TP13424.1 U6539.DG31
N43472926: R68380.2 R68381.2 R68386.1
N43474340: R68369.2 R68370.2 R68376.1
N43686188: PQ17.3 PR9275.1
N44885066: PD9002.3(COMMON ANODE) PR16.2
N44994019: R25526.1 U67.9
N44994033: R25527.1 U67.10
N44994150: TP2.1 U67.11
N44994160: TP9046.1 U67.12
N44994181: TP9064.1 U67.13
N45124268: Q23.3 R25617.1
N45302727: D12.1(CATHODE) Q21.3
N45366166: C96272.1 U6517.2
N45366191: C96272.2 U6517.3
N45366210: R67422.2 U6517.4
N45497503: PR8015.1 TP13384.1
N45500595: PC8005.1 PR8033.2 PU8000.1(VIN)
N45500603: PC8007.1 PQ8015.3 PR8035.2 PR8040.2 PU8000.3
N45500619: PD8002.1(CATHODE) PD8003.1(CATHODE) PR8033.1 PR8035.1
N45500625: PQ8016.6 PR8042.1 PR8045.1 PR8047.1
N45500627: PQ8016.5 PR8045.2
N45500633: PQ8016.1 PR8046.1 PR8048.1
N45500637: PQ8016.2 PR8047.2
N45500667: PQ8014.3 PR8034.1 PR8037.1
N45500689: PR8036.1 PR8039.1 PU8000.4
N45500733: PQ8015.2 PR8038.2 PR8041.2 PR8043.1
N45509729: PC8008.2 PR8052.1 PU8001.1(VIN)
N45509733: PD8006.1(CATHODE) PD8007.1(CATHODE) PR8052.2 PR8054.1
N45509737: PR8053.2 PR8055.1 PU8001.4
N45509757: PC8011.1 PQ8019.3 PR8054.2 PR8057.1 PU8001.3
N45509773: PQ8019.2 PR8058.2 PR8060.1 PR8064.1
N45509797: PQ8018.6 PR8056.1 PR8061.1 PR8062.1
N45509799: PQ8018.5 PR8061.2
N45509807: PQ8018.2 PR8062.2
N45509836: PQ8018.1 PR8063.1
N45509840: PQ8017.1(S) PR8051.1
N45515909: PD8005.2 PR8049.2 PR8050.1
N45782696: R450.1 U20.20
N46166321: C695.1 CN33.1 R69054.2
N46166544: CN33.8 R572.1
N46207407: R25554.1 R25558.2 U6509.7
N46207590: C20040.1 R25555.2 U6509.23
N46207592: R25556.2 R25557.1 U6509.26
