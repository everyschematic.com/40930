# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ29: length 72.1
  IN4 w0.089: v2(48.43,116.43) 49.18,117.17 50.64,117.17 50.81,117 50.81,116.52 51.1,116.23 51.99,116.23 52.12,116.1 52.12,115.85 52.37,115.59 54.04,115.59 54.36,115.9 54.36,116.23 54.48,116.35 54.78,116.35 55.08,116.06 55.42,116.06 55.54,116.19 55.54,116.48 55.62,116.56 55.94,116.56 56.24,116.26 68.37,116.26 68.46,116.35 68.46,116.61 68.59,116.73 68.82,116.73 68.9,116.65 68.9,116.35 68.99,116.26 69.42,116.26 70.27,117.11 70.27,117.24 70.21,117.3 70.21,117.43 70.4,117.62 70.52,117.62 70.59,117.55 70.71,117.55 70.9,117.74 70.9,117.87 70.84,117.93 70.84,118.06 71.02,118.24 71.15,118.24 71.22,118.18 71.34,118.18 71.71,118.55 73.49,118.55 74.42,119.48 76.58,119.48 77.81,120.71 81.59,120.71 83.51,122.63 85.06,122.63 85.77,123.34 85.77,123.97 88.31,126.51 88.82,126.51 89.45,127.15 91.49,127.15 92.76,128.42 93.64,128.42 94.53,129.31 94.53,130.07 96.06,131.59 96.79,131.59 99.12,133.93 99.84,133.93 100.73,134.82 102.2,134.82 102.68,135.3 103.16,135.3 v1(103.54,134.92)
  BOTTOM w0.102: U6539.CK45 103.86,134.6 v1(103.54,134.92)
  BOTTOM w0.114: JDIM1.216 47.82,115.82 v2(48.43,116.43)
M_A_DQ30: length 70.7
  IN4 w0.089: v2(47.15,113.37) 47.42,113.63 47.42,113.94 47.15,114.2 47.15,114.44 47.54,114.83 48.18,114.83 49.09,113.92 54.27,113.92 54.59,113.59 56.21,113.59 56.73,114.11 57.79,114.11 58.3,113.59 64.4,113.59 65.51,114.71 71.64,114.71 72.6,115.67 74.75,115.67 75.46,116.38 76.27,116.38 76.75,116.86 76.75,117.22 78.62,119.08 78.95,119.08 79.37,118.67 82.24,118.67 83.74,120.16 84.63,120.16 86.66,122.2 87.57,122.2 90.83,125.45 91.69,125.45 93.17,126.93 94.06,126.93 94.28,127.15 94.28,127.8 95.55,129.07 95.55,129.56 96.57,130.58 96.9,130.58 99.44,133.12 100.3,133.12 101.09,133.91 102.87,133.91 v1(102.92,133.95)
  BOTTOM w0.102: v1(102.92,133.95) 102.94,133.93 102.97,133.93 103.21,133.69 U6539.CM47
  BOTTOM w0.114: v2(47.15,113.37) 46.61,112.82 JDIM1.228
M_A_DQ31: length 72
  IN4 w0.089: v1(102.91,134.92) 102.75,134.92 102.45,134.62 100.86,134.62 99.97,133.73 99.19,133.73 96.81,131.34 96.18,131.34 94.79,129.94 94.79,129.29 93.66,128.17 92.88,128.17 91.61,126.9 89.58,126.9 88.95,126.26 88.57,126.26 88.19,125.89 88.19,125.76 88.51,125.44 88.51,125.32 88.32,125.13 88.2,125.13 87.88,125.45 87.75,125.45 87.56,125.26 87.56,125.13 87.88,124.81 87.88,124.69 87.69,124.5 87.57,124.5 87.25,124.82 87.12,124.82 86.15,123.85 86.15,123.09 84.7,121.64 83.69,121.64 82.34,120.29 78.13,120.29 76.47,118.64 75.48,118.64 75,119.12 74.57,119.12 73.66,118.21 72,118.21 69.71,115.91 57.94,115.91 57.85,115.83 57.85,115.55 57.71,115.42 57.54,115.42 57.4,115.55 57.4,115.83 57.31,115.91 57.05,115.91 56.96,115.83 56.96,115.5 56.83,115.37 56.65,115.37 56.51,115.5 56.51,115.83 56.42,115.91 55.87,115.91 55.67,115.72 54.67,115.72 54.2,115.25 53.84,115.25 53.64,115.25 52.21,115.25 51.61,115.85 49.96,115.85 49.79,116.01 v2(49.79,116.48)
  BOTTOM w0.102: U6539.CK47 103.21,134.63 v1(102.91,134.92)
  BOTTOM w0.114: v2(49.79,116.48) 49.79,117.08 50.07,117.36 52.09,117.36 52.37,117.07 JDIM1.211
M_A_DQ32: length 66.4
  IN4 w0.089: v1(94.48,143.61) 94.01,143.13 88.99,143.13 85.92,146.2 84.55,146.2 82.9,147.85 80.18,147.85 76.63,151.41 69.13,151.41 68.9,151.64 66.2,151.64 66.11,151.55 66.11,151.11 66.02,151.03 65.76,151.03 65.67,151.11 65.67,151.55 65.58,151.64 65.31,151.64 65.22,151.55 65.22,151.11 65.13,151.03 64.87,151.03 64.78,151.11 64.78,151.55 64.69,151.64 61.63,151.64 61.58,151.59 58.32,151.59 57.8,151.07 54.73,151.07 52.66,148.99 50.46,148.99 49.86,149.6 v2(49.86,150.84)
  BOTTOM w0.089: U6539.BH49 102.14,144.87 101.94,145.07 101.72,145.07 101.67,145.01 99.44,145.01 99.13,144.7
  BOTTOM w0.102: 99.13,144.7 99.12,144.69 99.12,144.57 97.8,143.24 94.82,143.24 94.48,143.58 v1(94.48,143.61)
  BOTTOM w0.114: v2(49.86,150.84) 50.59,151.57 51.68,151.57 52.19,152.07 JDIM1.79
M_A_DQ33: length 66
  IN4 w0.089: v1(89.79,143.97) 89.42,143.97 86.31,147.09 84.88,147.09 82.98,148.99 80.62,148.99 76.55,153.06 67.36,153.06 67.05,152.75 66.09,152.75 65.96,152.88 65.96,153.02 65.83,153.15 65.53,153.15 65.44,153.06 65.44,152.8 65.35,152.71 65.08,152.71 64.99,152.8 64.99,153.06 64.9,153.15 64.64,153.15 64.55,153.06 64.55,152.8 64.46,152.71 64.19,152.71 64.1,152.8 64.1,153.06 64.01,153.15 61.45,153.15 61.37,153.23 58.17,153.23 57.82,152.88 56.86,152.88 56.77,152.79 56.77,152.26 56.68,152.17 56.42,152.17 56.33,152.26 56.33,152.79 56.24,152.88 55.01,152.88 53.85,151.73 47.81,151.73 v2(47.19,151.1)
  BOTTOM w0.102: U6539.BH50 101.19,143.81 100.59,143.81 100.38,143.6 100.21,143.6 98.78,142.17 92.03,142.17
  BOTTOM w0.114: 92.03,142.17 91.15,142.17 89.79,143.53 v1(89.79,143.97) ; v2(47.19,151.1) 46.47,151.82 JDIM1.80
M_A_DQ34: length 65.1
  IN4 w0.089: v2(48.53,151.1) 48.78,150.86 48.78,150.12 48.89,150.01 49.19,150.01 49.32,150.14 49.32,151.13 49.57,151.38 54.07,151.38 54.44,151.75 57.16,151.75 57.32,151.91 57.32,152.35 57.45,152.47 57.91,152.47 58.31,152.88 61.23,152.88 61.33,152.78 63.18,152.78 63.6,152.37 67.31,152.37 67.61,152.68 67.99,152.68 68.08,152.59 68.08,152.46 68.17,152.37 68.44,152.37 68.53,152.46 68.53,152.59 68.62,152.68 76.37,152.68 80.44,148.61 82.98,148.61 84.88,146.71 86.26,146.71 89.39,143.58 90.63,143.58 v1(91.02,143.96)
  BOTTOM w0.102: U6539.BH52 100.61,144.11 100.34,143.84 100.06,143.84 98.6,142.38 92.39,142.38 92.14,142.63
  BOTTOM w0.114: 92.14,142.63 91.02,143.75 v1(91.02,143.96) ; JDIM1.84 46.03,150.82 46.31,150.54 47.97,150.54 v2(48.53,151.1)
M_A_DQ35: length 64.6
  IN4 w0.089: v2(51.18,150.82) 51.18,150.31 51.35,150.14 52.12,150.14 52.32,150.34 52.32,150.91 52.45,151.04 52.67,151.04 52.79,150.92 52.79,150.39 52.92,150.26 53.13,150.26 53.26,150.39 53.26,150.86 53.39,150.99 54.16,150.99 54.59,151.41 57.66,151.41 58.18,151.93 61.34,151.93 61.47,152.07 61.47,152.35 61.56,152.44 61.87,152.44 61.96,152.35 61.96,152.13 62.04,152.04 62.37,152.04 62.48,152.16 62.48,152.34 62.58,152.44 62.87,152.44 62.96,152.35 62.96,152.14 63.11,151.99 68.7,151.99 69.01,152.3 69.57,152.3 69.65,152.21 69.65,151.88 69.74,151.79 70.01,151.79 70.1,151.88 70.1,152.21 70.19,152.3 70.45,152.3 70.54,152.21 70.54,151.88 70.63,151.79 70.9,151.79 70.99,151.88 70.99,152.21 71.08,152.3 71.34,152.3 71.43,152.21 71.43,151.88 71.52,151.79 71.79,151.79 71.88,151.88 71.88,152.21 71.97,152.3 72.23,152.3 72.32,152.21 72.32,151.88 72.41,151.79 72.68,151.79 72.77,151.88 72.77,152.21 72.85,152.3 76.25,152.3 80.31,148.23 82.93,148.23 84.71,146.45 86.09,146.45 89.19,143.36 91.03,143.36 91.63,143.95 v1(91.63,143.96)
  BOTTOM w0.102: U6539.BH53 100.04,144.11 98.51,142.58 92.82,142.58 92.76,142.64
  BOTTOM w0.114: v1(91.63,143.96) 91.63,143.77 92.76,142.64 ; JDIM1.83 52.45,151.07 52.27,150.9 52.27,150.57 52.07,150.36 51.63,150.36 v2(51.18,150.82)
M_A_DQ36: length 66.5
  IN4 w0.089: v2(47.11,154.91) 47.11,154.38 47.54,153.95 48.96,153.95 49.58,153.33 53.75,153.33 54.62,154.2 57.44,154.2 58.15,154.91 64.59,154.91 64.68,154.82 64.68,154.54 64.77,154.45 65.04,154.45 65.12,154.54 65.12,154.82 65.21,154.91 65.48,154.91 65.57,154.82 65.57,154.54 65.66,154.45 65.92,154.45 66.01,154.54 66.01,154.82 66.1,154.91 66.37,154.91 66.46,154.82 66.46,154.54 66.55,154.45 66.81,154.45 66.9,154.54 66.9,154.82 66.99,154.91 67.26,154.91 67.35,154.82 67.35,154.54 67.44,154.45 77.5,154.45 81.75,150.21 83.54,150.21 85.52,148.23 86.23,148.23 89.67,144.79 94.06,144.79 94.66,144.19 v1(94.69,144.19)
  BOTTOM w0.079: 100.19,145.89 100.46,145.89 100.56,145.8 100.62,145.73 101.3,145.73 101.39,145.64 101.81,145.64 U6539.BF49
  BOTTOM w0.089: 99.13,145.89 100.19,145.89
  BOTTOM w0.102: v1(94.69,144.19) 94.69,144.22 95.04,144.57 96.5,144.57 97.16,145.23 98.25,145.23 98.91,145.89 99.13,145.89
  BOTTOM w0.114: JDIM1.66 46.7,155.32 v2(47.11,154.91)
M_A_DQ37: length 65.5
  IN4 w0.089: v1(97.16,144.69) 96.63,144.69 95.62,145.69 93.52,145.69 93.25,145.42 89.96,145.42 86.01,149.37 85.57,149.37 83.43,151.51 82.29,151.51 78.2,155.6 77.39,155.6 77.26,155.72 77.26,156.11 77.13,156.23 76.82,156.23 76.73,156.14 76.73,155.69 76.64,155.6 76.37,155.6 76.28,155.69 76.28,156.14 76.2,156.23 67.99,156.23 67.74,155.98 65.12,155.98 65.03,156.07 65.03,156.52 64.95,156.61 64.68,156.61 64.59,156.52 64.59,156.07 64.5,155.98 61.26,155.98 60.76,156.48 57.01,156.48 56.78,156.25 56.78,156.02 56.7,155.94 56.4,155.94 56.32,156.03 56.32,156.36 56.19,156.49 55.97,156.49 55.85,156.37 55.85,156.03 55.77,155.94 55.4,155.94 55.3,156.04 55.3,156.35 55.21,156.44 54.88,156.44 54.78,156.34 54.78,155.96 53.54,154.71 51.02,154.71 v2(50.52,154.21)
  BOTTOM w0.079: 100.06,145.72 100.41,145.72 100.56,145.57 101.24,145.57 U6539.BF50
  BOTTOM w0.089: 99.13,145.62 99.23,145.72 100.06,145.72
  BOTTOM w0.102: 99.13,145.62 98.97,145.46 98.8,145.46 98.03,144.69 v1(97.16,144.69)
  BOTTOM w0.114: v2(50.52,154.21) 50.52,154.76 50.83,155.07 JDIM1.67
M_A_DQ38: length 64.7
  IN4 w0.089: v1(95.96,144.04) 95.93,144.07 95.93,144.82 95.31,145.44 93.61,145.44 93.39,145.21 89.86,145.21 86.08,148.99 85.57,148.99 83.54,151.02 82.08,151.02 77.89,155.22 75.94,155.22 75.85,155.3 75.85,155.64 75.76,155.72 75.5,155.72 75.41,155.64 75.41,155.3 75.32,155.22 75.05,155.22 74.96,155.3 74.96,155.64 74.87,155.72 74.61,155.72 74.52,155.64 74.52,155.3 74.43,155.22 74.16,155.22 74.07,155.3 74.07,155.64 73.99,155.72 73.72,155.72 73.63,155.64 73.63,155.3 73.54,155.22 73.27,155.22 73.19,155.3 73.19,155.64 73.1,155.72 72.83,155.72 72.74,155.64 72.74,155.3 72.65,155.22 72.39,155.22 72.3,155.3 72.3,155.64 72.21,155.72 71.94,155.72 71.85,155.64 71.85,155.3 71.76,155.22 71.42,155.22 70.91,155.72 68.12,155.72 67.99,155.6 60.88,155.6 60.62,155.86 60.62,156.07 60.54,156.14 60.26,156.14 60.17,156.05 60.17,155.69 60.08,155.6 59.82,155.6 59.73,155.69 59.73,156.05 59.64,156.14 59.37,156.14 59.28,156.05 59.28,155.69 59.2,155.6 58.93,155.6 58.84,155.69 58.84,156.05 58.75,156.14 58.48,156.14 58.4,156.05 58.4,155.69 58.3,155.6 58.03,155.6 57.95,155.68 57.95,156.05 57.86,156.14 57.48,156.14 56.94,155.6 54.91,155.6 53.49,154.17 v2(51.91,154.17)
  BOTTOM w0.089: 99.14,145.32 99.37,145.55 100.34,145.55 100.57,145.32 U6539.BF52
  BOTTOM w0.102: v1(95.96,144.04) 95.96,144.01 96.28,143.69 97.36,143.69 98.84,145.17 98.99,145.17 99.14,145.32
  BOTTOM w0.114: JDIM1.71 52.01,154.07 v2(51.91,154.17)
M_A_DQ39: length 64.4
  IN4 w0.089: v1(95.35,144.19) 95.32,144.19 94.51,145.01 89.75,145.01 86.14,148.61 85.52,148.61 83.58,150.55 81.89,150.55 77.6,154.84 71.06,154.84 70.56,155.34 70.29,155.34 70.2,155.25 70.2,154.92 70.11,154.84 69.85,154.84 69.76,154.92 69.76,155.25 69.67,155.34 69.4,155.34 69.31,155.25 69.31,154.92 69.22,154.84 68.96,154.84 68.87,154.92 68.87,155.25 68.78,155.34 68.51,155.34 68.42,155.25 68.42,154.92 68.33,154.84 67.99,154.84 67.57,155.25 55.05,155.25 53.47,153.68 49.72,153.68 48.53,154.86 v2(48.46,154.86)
  BOTTOM w0.089: U6539.BF53 99.45,145.32 99.13,145
  BOTTOM w0.102: 99.13,145 99,144.86 98.83,144.86 97.43,143.46 95.87,143.46 95.34,144 95.34,144.18 v1(95.35,144.19)
  BOTTOM w0.114: JDIM1.70 47.92,154.32 v2(48.46,154.86)
M_A_DQ40: length 69.5
  IN4 w0.089: v1(93.64,146.2) 93.07,145.63 90.19,145.63 88.27,147.55 88.27,147.89 83.99,152.17 82.72,152.17 77.01,157.88 71.85,157.88 71.76,157.79 71.76,157.59 71.67,157.5 71.41,157.5 71.32,157.59 71.32,157.79 71.23,157.88 70.89,157.88 70.8,157.79 70.8,157.46 70.71,157.38 70.44,157.38 70.35,157.46 70.35,157.79 70.26,157.88 70,157.88 69.91,157.79 69.91,157.46 69.82,157.38 69.55,157.38 69.46,157.46 69.46,157.79 69.38,157.88 69.11,157.88 69.02,157.79 69.02,157.46 68.93,157.38 68.66,157.38 68.57,157.46 68.57,157.79 68.49,157.88 68.22,157.88 68.13,157.79 68.13,157.46 68.04,157.38 67.77,157.38 67.69,157.46 67.69,157.79 67.6,157.88 67.33,157.88 66.82,157.38 54.97,157.38 53.03,155.44 49.61,155.44 49.19,155.85 47.54,155.85 47.08,156.32 v2(47.08,156.56)
  BOTTOM w0.102: v1(93.64,146.2) 94.05,146.61 95.58,146.61 95.87,146.9 97.67,146.9 98.37,147.6 101.22,147.6 101.26,147.57 101.64,147.57 101.67,147.6 101.92,147.6 102.02,147.5 102.14,147.39 U6539.BC49
  BOTTOM w0.114: JDIM1.62 46.84,156.32 v2(47.08,156.56)
M_A_DQ41: length 69.1
  IN4 w0.089: v2(51.31,156.18) 51.31,156.31 51.78,156.78 53.41,156.78 54.71,158.09 56.58,158.09 56.71,158.21 56.71,158.67 56.8,158.76 57.05,158.76 57.13,158.67 57.13,158.16 57.21,158.09 57.49,158.09 57.58,158.18 57.58,158.65 57.68,158.76 57.92,158.76 58.01,158.67 58.01,158.16 58.08,158.09 59.61,158.09 60.17,158.65 62.78,158.65 63.16,158.26 63.42,158.26 63.55,158.39 63.55,158.52 63.79,158.76 64.05,158.76 64.13,158.67 64.13,158.23 64.22,158.14 64.42,158.14 64.53,158.24 64.53,158.65 64.64,158.76 67.62,158.76 67.71,158.85 67.71,159.2 67.81,159.3 68.15,159.3 68.24,159.21 68.24,158.73 68.33,158.65 68.6,158.65 68.69,158.73 68.69,159.21 68.78,159.3 69.04,159.3 69.13,159.21 69.13,158.73 69.22,158.65 69.49,158.65 69.58,158.73 69.58,159.21 69.67,159.3 69.93,159.3 70.02,159.21 70.02,158.73 70.11,158.65 70.38,158.65 70.47,158.73 70.47,159.21 70.55,159.3 70.82,159.3 70.91,159.21 70.91,158.73 71,158.65 71.27,158.65 71.35,158.73 71.35,159.21 71.44,159.3 76.71,159.3 83.08,152.93 84.12,152.93 88.91,148.15 88.91,147.76 90.46,146.21 v1(90.52,146.21)
  BOTTOM w0.102: 93.14,144.8 96.44,144.8 97.07,145.44 98.16,145.44 98.84,146.11 100.32,146.11 100.62,146.42 100.98,146.42 101.22,146.66 U6539.BC50
  BOTTOM w0.114: v2(51.31,156.18) 51.63,155.85 52.12,155.85 52.34,156.07 JDIM1.63 ; v1(90.52,146.21) 90.52,146.15 91.87,144.8 93.14,144.8
M_A_DQ42: length 68.3
  IN4 w0.089: v2(48.38,156.46) 49.32,156.46 49.47,156.61 51.12,156.61 51.64,157.13 52.76,157.13 54.73,159.1 60.7,159.1 61.01,159.41 62.84,159.41 63.11,159.14 63.38,159.14 63.47,159.23 63.47,159.55 63.56,159.64 63.82,159.64 63.91,159.55 63.91,159.23 64,159.14 64.27,159.14 64.36,159.23 64.36,159.55 64.45,159.64 64.71,159.64 64.8,159.55 64.8,159.23 64.89,159.14 65.16,159.14 65.25,159.23 65.25,159.55 65.34,159.64 65.6,159.64 65.69,159.55 65.69,159.23 65.78,159.14 66.05,159.14 66.14,159.23 66.14,159.55 66.22,159.64 66.57,159.64 66.66,159.55 66.66,159.24 66.75,159.15 67.01,159.15 67.1,159.24 67.1,159.55 67.19,159.64 76.86,159.64 83.19,153.31 84.15,153.31 89.29,148.18 89.29,147.7 90.39,146.59 91.38,146.59 91.76,146.21 v1(91.76,146.2)
  BOTTOM w0.102: U6539.BC52 100.57,146.66 100.5,146.59 100.5,146.59 100.24,146.33 98.72,146.33 98.1,145.71 96.93,145.71 96.28,145.06 94.91,145.06 94.71,145.26 93.14,145.26
  BOTTOM w0.114: v1(91.76,146.2) 91.76,145.67 92.17,145.26 93.14,145.26 ; v2(48.38,156.46) 47.52,157.32 JDIM1.58
M_A_DQ43: length 67.5
  IN4 w0.089: v1(93.01,146.2) 92.63,145.82 90.33,145.82 88.56,147.58 88.56,148.07 84.09,152.55 82.98,152.55 76.75,158.77 74.68,158.77 74.59,158.68 74.59,158.35 74.51,158.26 74.24,158.26 74.15,158.35 74.15,158.68 74.02,158.82 73.84,158.82 73.71,158.68 73.71,158.35 73.62,158.26 73.35,158.26 73.26,158.35 73.26,158.68 73.13,158.82 72.95,158.82 72.82,158.68 72.82,158.35 72.73,158.26 72.44,158.26 72.31,158.39 72.31,158.73 72.18,158.85 71.93,158.85 71.8,158.73 71.8,158.39 71.67,158.26 66.74,158.26 66.65,158.18 66.65,157.83 66.56,157.74 66.29,157.74 66.2,157.83 66.2,158.33 66.11,158.42 65.85,158.42 65.76,158.33 65.76,157.83 65.67,157.74 65.4,157.74 65.31,157.83 65.31,158.33 65.22,158.42 64.96,158.42 64.87,158.33 64.87,157.83 64.76,157.72 54.83,157.72 52.89,155.78 50.4,155.78 v2(49.99,156.19)
  BOTTOM w0.102: U6539.BC53 100.11,146.58 98.68,146.58 98.01,145.91 96.84,145.91 96.24,145.31 95.04,145.31 94.79,145.56 93.26,145.56 93.2,145.63
  BOTTOM w0.114: 93.2,145.63 93.01,145.82 v1(93.01,146.2) ; JDIM1.59 50.87,157.07 v2(49.99,156.19)
M_A_DQ44: length 69.4
  IN4 w0.089: v2(47.01,160.14) 47.01,159.18 47.7,158.49 52.2,158.49 54.71,161 60.7,161 60.94,161.25 64.01,161.25 64.42,160.85 73.87,160.85 73.96,160.94 73.96,161.22 74.05,161.31 74.31,161.31 74.4,161.22 74.4,160.94 74.49,160.85 74.76,160.85 74.85,160.94 74.85,161.22 74.94,161.31 75.2,161.31 75.29,161.22 75.29,160.94 75.38,160.85 75.65,160.85 75.74,160.94 75.74,161.22 75.82,161.31 76.09,161.31 76.18,161.22 76.18,160.94 76.27,160.85 76.54,160.85 76.62,160.94 76.62,161.22 76.71,161.31 76.98,161.31 77.07,161.22 77.07,160.94 77.16,160.85 77.6,160.85 83.7,154.75 84.04,154.75 90.47,148.32 90.47,147.6 90.85,147.22 94.41,147.22 v1(95.04,147.85)
  BOTTOM w0.079: 99.54,148.43 100.43,148.43 100.62,148.25 101.76,148.25 U6539.AY49
  BOTTOM w0.089: 99.13,148.43 99.54,148.43
  BOTTOM w0.102: v1(95.04,147.85) 95.58,147.85 95.72,147.72 97.17,147.72 97.89,148.43 99.13,148.43
  BOTTOM w0.114: v2(47.01,160.14) 46.83,160.32 JDIM1.46
M_A_DQ45: length 69.3
  IN4 w0.089: v2(47.95,159.1) 48.22,158.84 52.06,158.84 54.56,161.34 60.55,161.34 60.81,161.6 64.15,161.6 64.56,161.19 65.96,161.19 66.54,161.77 67.11,161.77 67.69,161.19 69.7,161.19 69.79,161.28 69.79,161.6 69.87,161.69 70.14,161.69 70.23,161.6 70.23,161.28 70.32,161.19 70.59,161.19 70.67,161.28 70.67,161.6 70.76,161.69 71.03,161.69 71.12,161.6 71.12,161.28 71.21,161.19 71.48,161.19 71.56,161.28 71.56,161.6 71.65,161.69 71.92,161.69 72.01,161.6 72.01,161.28 72.1,161.19 72.36,161.19 72.45,161.28 72.45,161.6 72.54,161.69 72.81,161.69 72.9,161.6 72.9,161.28 72.99,161.19 73.33,161.19 73.85,161.71 77.24,161.71 83.82,155.13 84.14,155.13 90.81,148.46 90.81,147.64 90.98,147.47 93.44,147.47 v1(93.82,147.85)
  BOTTOM w0.079: U6539.AY50 101.27,148.09 100.55,148.09 100.39,148.25 99.93,148.25 99.91,148.22 99.78,148.22
  BOTTOM w0.089: 99.13,148.22 99.78,148.22
  BOTTOM w0.102: 99.13,148.22 98.06,148.22 97.35,147.51 95.34,147.51 95.17,147.34 93.95,147.34 93.82,147.47 v1(93.82,147.85)
  BOTTOM w0.114: JDIM1.50 46.81,159.32 47.03,159.1 v2(47.95,159.1)
M_A_DQ46: length 68.3
  IN4 w0.089: v1(92.59,147.85) 91.47,148.97 91.25,148.97 77.72,162.5 69.24,162.5 69.15,162.59 69.15,163 69.06,163.09 68.8,163.09 68.71,163 68.71,162.59 68.62,162.5 68.28,162.5 68.19,162.58 68.19,163.05 68.1,163.14 67.84,163.14 67.75,163.05 67.75,162.59 67.66,162.5 67.39,162.5 67.3,162.59 67.3,163.05 67.22,163.14 66.41,163.14 66.32,163.05 66.32,162.59 66.23,162.5 65.97,162.5 65.88,162.59 65.88,163.05 65.79,163.14 65.52,163.14 65.43,163.05 65.43,162.08 65.34,161.99 65.08,161.99 64.99,162.08 64.99,163.05 64.9,163.14 64.63,163.14 64.54,163.05 64.54,162.45 64.46,162.37 64.19,162.37 64.1,162.46 64.1,163.05 64.01,163.14 61.06,163.14 60.82,162.9 57.84,162.9 57.58,162.65 54.69,162.65 52.29,160.25 51.33,160.25 v2(50.92,159.84)
  BOTTOM w0.079: U6539.AY52 100.55,147.87 100.33,148.09 100.04,148.09 99.97,148.02 99.54,148.02
  BOTTOM w0.089: 99.13,148.02 99.54,148.02
  BOTTOM w0.102: 99.13,148.02 98.19,148.02 97.48,147.31 95.52,147.31 95.3,147.09 92.76,147.09 92.59,147.25 v1(92.59,147.85)
  BOTTOM w0.114: v2(50.92,159.84) 51.38,159.38 52.24,159.38 52.43,159.57 JDIM1.49
M_A_DQ47: length 68.2
  IN4 w0.089: v1(91.87,147.85) 77.59,162.12 69.44,162.12 69.35,162.04 69.35,161.65 69.27,161.57 69,161.57 68.91,161.65 68.91,162.04 68.82,162.12 68.55,162.12 68.46,162.04 68.46,161.65 68.38,161.57 68.11,161.57 68.02,161.65 68.02,162.04 67.93,162.12 66.39,162.12 65.89,161.62 64.61,161.62 64.29,161.95 61.26,161.95 60.65,162.56 58.16,162.56 57.81,162.21 57.81,161.78 57.72,161.69 57.46,161.69 57.37,161.78 57.37,162.21 57.28,162.3 57.01,162.3 56.92,162.21 56.92,161.78 56.83,161.69 56.57,161.69 56.48,161.78 56.48,162.21 56.39,162.3 54.83,162.3 51.71,159.18 49.62,159.18 49.49,159.31 v2(49.49,159.82)
  BOTTOM w0.102: U6539.AY53 100.12,147.81 98.29,147.81 97.59,147.11 95.7,147.11 95.42,146.83 92.5,146.83 91.87,147.47 v1(91.87,147.85)
  BOTTOM w0.114: v2(49.49,159.82) 50.24,160.57 JDIM1.45
M_A_DQ48: length 78.1
  IN4 w0.089: v2(48.45,165.58) 49.65,165.58 50.26,166.19 52.69,166.19 54.46,167.96 63.71,167.96 64.17,168.42 74.85,168.42 74.94,168.34 74.94,167.75 75.03,167.66 75.3,167.66 75.38,167.75 75.38,168.21 75.47,168.3 75.74,168.3 75.83,168.21 75.83,167.75 75.92,167.66 76.18,167.66 76.27,167.75 76.27,168.21 76.36,168.3 76.63,168.3 76.72,168.21 76.72,167.75 76.81,167.66 78.53,167.66 88.82,157.38 88.82,156.99 90.09,155.72 96.01,155.72 99.48,152.25 99.48,146.94 100.8,145.61 102.32,145.61 102.39,145.69 103.24,145.69 103.45,145.48 105.02,145.48 v1(105.6,144.9)
  BOTTOM w0.102: v1(105.6,144.9) 105.81,144.69 U6539.BH41
  BOTTOM w0.114: JDIM1.24 46.09,165.82 46.33,166.06 47.97,166.06 v2(48.45,165.58)
M_A_DQ49: length 76.8
  IN4 w0.089: v2(51.02,161.41) 51.1,161.49 52.67,161.49 54.87,163.68 57.87,163.68 58.06,163.5 60.57,163.5 60.81,163.74 69.64,163.74 69.77,163.61 69.77,163.35 69.9,163.23 70.15,163.23 70.24,163.32 70.24,164.02 70.33,164.11 70.6,164.11 70.69,164.02 70.69,163.32 70.78,163.23 71.04,163.23 71.13,163.32 71.13,164.02 71.22,164.11 71.49,164.11 71.58,164.02 71.58,163.32 71.67,163.23 71.93,163.23 72.02,163.32 72.02,164.02 72.11,164.11 72.38,164.11 72.47,164.02 72.47,163.31 72.55,163.22 72.82,163.22 72.94,163.34 72.94,163.61 73.07,163.74 77.38,163.74 87.69,153.42 87.69,153.12 91.16,149.65 96.94,149.65 97.26,149.33 97.26,145.92 98.19,145 98.19,144.12 98.27,144.04 99.67,142.64 104.39,142.64 104.58,142.83 104.58,143.23 104.83,143.48 105.06,143.48 v1(105.52,143.94)
  BOTTOM w0.102: U6539.BK41 105.81,143.65 v1(105.52,143.94)
  BOTTOM w0.114: JDIM1.37 51.72,162.57 51.02,161.88 v2(51.02,161.41)
M_A_DQ50: length 76.3
  IN4 w0.089: v1(104.84,143.92) 104.42,143.49 103.39,143.49 102.98,143.08 99.61,143.08 98.55,144.13 98.55,145.01 97.47,146.1 97.47,149.43 96.9,150 91.24,150 88.07,153.17 88.07,153.55 77.54,164.08 73.48,164.08 73.07,164.49 69.85,164.49 69.76,164.4 69.76,164.19 69.67,164.11 69.4,164.11 69.31,164.19 69.31,164.4 69.22,164.49 68.96,164.49 68.87,164.4 68.87,164.19 68.78,164.11 68.51,164.11 68.42,164.19 68.42,164.4 68.33,164.49 67.99,164.49 67.58,164.08 64.84,164.08 64.42,164.5 63.65,164.5 63.56,164.41 63.56,164.19 63.47,164.11 63.21,164.11 63.12,164.19 63.12,164.41 63.03,164.5 62.76,164.5 62.67,164.41 62.67,164.19 62.58,164.11 62.32,164.11 62.23,164.19 62.23,164.41 62.14,164.5 61.87,164.5 61.78,164.41 61.78,164.19 61.69,164.11 61.43,164.11 61.34,164.19 61.34,164.41 61.25,164.5 58.1,164.5 57.62,164.03 54.73,164.03 52.55,161.85 50.03,161.85 v2(49.6,161.41)
  BOTTOM w0.102: v1(104.84,143.92) 105.16,143.6 U6539.BK42
  BOTTOM w0.114: JDIM1.41 51.84,161.57 51.25,160.98 50.03,160.98 v2(49.6,161.41)
M_A_DQ51: length 77.6
  IN4 w0.089: v2(49.69,165.06) 50.48,165.85 52.83,165.85 54.6,167.62 64.13,167.62 64.56,168.04 71.68,168.04 71.76,167.95 71.76,167.37 71.85,167.28 72.12,167.28 72.21,167.37 72.21,167.95 72.3,168.04 72.56,168.04 72.65,167.95 72.65,167.37 72.74,167.28 73.01,167.28 73.1,167.37 73.1,167.95 73.19,168.04 73.45,168.04 73.54,167.95 73.54,167.37 73.63,167.28 73.97,167.28 74.06,167.37 74.06,167.7 74.15,167.79 74.42,167.79 74.51,167.7 74.51,167.37 74.6,167.28 78.4,167.28 88.37,157.31 88.37,156.93 89.94,155.37 95.95,155.37 99.23,152.09 99.23,146.83 100.66,145.41 102.44,145.41 102.52,145.48 103.17,145.48 103.37,145.28 104.57,145.28 v1(104.95,144.9)
  BOTTOM w0.102: U6539.BH42 105.16,144.69 v1(104.95,144.9)
  BOTTOM w0.114: JDIM1.29 50.18,164.57 v2(49.69,165.06)
M_A_DQ52: length 75.4
  IN4 w0.089: v1(103.64,144.9) 103.45,144.9 103.06,145.29 102.65,145.29 102.54,145.18 100.53,145.18 98.98,146.73 98.98,151.92 95.86,155.04 89.76,155.04 87.93,156.87 87.93,157.23 78.26,166.9 71.4,166.9 71.31,166.99 71.31,167.45 71.22,167.54 70.96,167.54 70.87,167.45 70.87,166.99 70.78,166.9 70.51,166.9 70.42,166.99 70.42,167.57 70.34,167.66 64.82,167.66 64.43,167.27 57.31,167.27 56.68,166.64 54.11,166.64 52.97,165.5 51.05,165.5 50.8,165.25 50.8,164.82 50.59,164.61 48.08,164.61 v2(47.13,165.56)
  BOTTOM w0.102: U6539.BH45 103.86,144.69 v1(103.64,144.9)
  BOTTOM w0.114: JDIM1.28 46.39,164.82 v2(47.13,165.56)
M_A_DQ53: length 75.8
  IN4 w0.089: v2(51.27,165.06) 51.71,164.61 52.57,164.61 54.25,166.29 56.97,166.29 57.59,166.91 63.66,166.91 64.05,166.52 64.93,166.52 65.02,166.61 65.02,167.19 65.11,167.28 65.37,167.28 65.46,167.19 65.46,166.61 65.55,166.52 65.82,166.52 65.91,166.61 65.91,167.19 66,167.28 66.26,167.28 66.35,167.19 66.35,166.61 66.44,166.52 66.71,166.52 66.8,166.61 66.8,167.19 66.88,167.28 67.15,167.28 67.24,167.19 67.24,166.61 67.33,166.52 67.6,166.52 67.68,166.61 67.68,167.19 67.77,167.28 68.04,167.28 68.13,167.19 68.13,166.61 68.22,166.52 68.48,166.52 68.57,166.61 68.57,167.19 68.66,167.28 68.93,167.28 69.02,167.19 69.02,166.61 69.11,166.52 69.37,166.52 69.46,166.61 69.46,167.19 69.55,167.28 69.82,167.28 69.91,167.19 69.91,166.61 70,166.52 77.88,166.52 87.55,156.85 87.55,156.74 89.58,154.71 95.8,154.71 98.73,151.78 98.73,146.63 100.56,144.8 102.82,144.8 v1(102.92,144.9)
  BOTTOM w0.102: v1(102.92,144.9) 103.21,144.61 U6539.BH47
  BOTTOM w0.114: JDIM1.25 51.79,165.57 v2(51.27,165.06)
M_A_DQ54: length 74.1
  IN4 w0.089: v2(48.36,161.8) 48.75,162.19 52.4,162.19 54.59,164.37 57.46,164.37 57.94,164.85 64.89,164.85 64.98,164.76 64.98,164.51 65.07,164.42 65.41,164.42 65.5,164.51 65.5,164.76 65.59,164.85 65.86,164.85 65.94,164.76 65.94,164.51 66.03,164.42 66.3,164.42 66.39,164.51 66.39,164.76 66.48,164.85 66.74,164.85 66.83,164.76 66.83,164.51 66.92,164.42 67.19,164.42 67.28,164.51 67.28,164.76 67.37,164.85 73.35,164.85 73.77,164.42 77.71,164.42 88.45,153.68 88.45,153.22 90.07,151.6 93.39,151.6 93.96,151.03 96.56,151.03 97.72,149.87 97.72,146.23 98.86,145.09 98.86,144.44 99.44,143.86 102.24,143.86 102.58,143.53 103.15,143.53 v1(103.54,143.92)
  BOTTOM w0.102: v1(103.54,143.92) 103.86,143.6 U6539.BK45
  BOTTOM w0.114: v2(48.36,161.8) 47.88,161.32 JDIM1.42
M_A_DQ55: length 74.4
  IN4 w0.089: v1(102.89,143.92) 102.71,144.1 99.47,144.1 99.05,144.52 99.05,145.28 97.95,146.38 97.95,151.14 97.08,152.01 90.12,152.01 88.82,153.31 88.82,153.82 77.45,165.19 77.11,165.19 77.02,165.1 77.02,164.86 76.93,164.77 76.66,164.77 76.57,164.86 76.57,165.1 76.48,165.19 76.22,165.19 76.13,165.1 76.13,164.86 76.04,164.77 75.77,164.77 75.68,164.86 75.68,165.1 75.6,165.19 75.33,165.19 75.24,165.1 75.24,164.86 75.15,164.77 74.88,164.77 74.8,164.86 74.8,165.1 74.71,165.19 74.44,165.19 74.35,165.1 74.35,164.86 74.26,164.77 74,164.77 73.57,165.19 57.77,165.19 57.29,164.71 54.44,164.71 52.26,162.53 47.5,162.53 v2(47.09,162.12)
  BOTTOM w0.102: U6539.BK47 103.21,143.6 v1(102.89,143.92)
  BOTTOM w0.114: v2(47.09,162.12) 46.89,162.32 JDIM1.38
M_A_DQ56: length 81.7
  IN4 w0.089: v2(48.9,170.75) 49.24,171.09 49.55,171.09 50.21,171.75 51.38,171.75 52.56,172.94 56.88,172.94 57.43,173.49 58.9,173.49 60.28,174.87 63.32,174.87 64.05,174.14 68.24,174.14 69.03,173.35 79.65,173.35 83.31,169.69 85.9,169.69 91.49,164.11 97.33,164.11 101.39,160.04 101.39,158.77 102.48,157.68 102.48,150.32 102.92,149.88 105.79,149.88 106.01,149.66 106.01,147.13 v1(105.62,146.74)
  BOTTOM w0.102: v1(105.62,146.74) 105.81,146.55 U6539.BD41
  BOTTOM w0.114: v2(48.9,170.75) 48.83,170.82 JDIM1.4
M_A_DQ57: length 81
  IN4 w0.089: v1(104.82,146.79) 104.44,146.42 103.36,146.42 103.09,146.14 102.61,146.14 102.15,146.6 100.65,146.6 100.03,147.21 100.03,152.78 96.32,156.49 90.34,156.49 89.96,156.87 89.96,158.39 83.35,165 83.22,165 83.03,164.81 82.91,164.81 82.72,165 82.72,165.13 82.91,165.32 82.91,165.44 82.67,165.69 82.54,165.69 82.35,165.49 82.22,165.49 82.03,165.68 82.03,165.81 82.23,166 82.23,166.13 81.98,166.37 81.86,166.37 81.6,166.11 81.48,166.11 81.29,166.3 81.29,166.43 81.54,166.68 81.54,166.81 81.36,167 81.23,167 80.97,166.74 80.85,166.74 80.66,166.93 80.66,167.06 80.92,167.31 80.92,167.44 80.73,167.63 80.6,167.63 80.35,167.37 80.22,167.37 80.03,167.56 80.03,167.69 80.29,167.94 80.29,168.07 80.1,168.26 79.97,168.26 79.72,168 79.59,168 79.4,168.19 79.4,168.31 79.66,168.57 79.66,168.7 79.47,168.88 79.34,168.88 79.09,168.63 78.96,168.63 78.77,168.82 78.77,168.94 79.03,169.2 79.03,169.32 78.79,169.57 68.18,169.57 68.09,169.66 68.09,169.85 68,169.94 67.73,169.94 67.64,169.85 67.64,169.66 67.55,169.57 67.29,169.57 67.2,169.66 67.2,169.85 67.11,169.94 66.84,169.94 66.75,169.85 66.75,169.66 66.67,169.57 66.4,169.57 66.31,169.66 66.31,169.85 66.22,169.94 65.95,169.94 65.86,169.85 65.86,169.66 65.78,169.57 65.51,169.57 65.42,169.66 65.42,169.85 65.33,169.94 65.06,169.94 64.98,169.85 64.98,169.66 64.89,169.57 64.62,169.57 64.53,169.66 64.53,169.85 64.44,169.94 64.18,169.94 64.09,169.85 64.09,169.66 64,169.57 63.73,169.57 63.64,169.66 63.64,169.85 63.55,169.94 63.29,169.94 63.2,169.85 63.2,169.66 63.11,169.57 62.84,169.57 62.75,169.66 62.75,169.85 62.66,169.94 62.4,169.94 62.31,169.85 62.31,169.66 62.22,169.57 61.88,169.57 61.48,169.17 57.89,169.17 57.62,168.9 54.05,168.9 52.85,167.7 51.69,167.7 v2(51.26,167.27)
  BOTTOM w0.102: U6539.BD42 105.16,146.45 v1(104.82,146.79)
  BOTTOM w0.114: v2(51.26,167.27) 51.7,167.71 52.2,167.71 52.34,167.57 JDIM1.17
M_A_DQ58: length 82.3
  IN4 w0.089: v2(47.61,170.35) 47.93,170.03 48.84,170.03 49.36,170.55 49.5,170.55 50.33,171.39 51.53,171.39 52.73,172.59 57.08,172.59 57.63,173.14 59.04,173.14 60.43,174.53 62.91,174.53 63.68,173.76 67.99,173.76 68.75,173 79.51,173 84.12,168.39 86.57,168.39 88.44,166.52 88.44,166.39 88.05,166.01 88.05,165.89 88.24,165.7 88.37,165.7 88.75,166.08 88.88,166.08 89.17,165.79 89.17,165.67 88.85,165.35 88.85,165.22 89.04,165.03 89.16,165.03 89.48,165.35 89.61,165.35 89.96,165 89.96,164.83 90.18,164.61 90.34,164.61 91.36,163.6 97.2,163.6 100.38,160.42 100.38,159.28 102.19,157.47 102.19,152.71 102.19,152.71 102.19,149.08 102.79,148.49 103.04,148.49 103.3,148.23 105.01,148.23 v1(105.49,147.76)
  BOTTOM w0.102: U6539.BB41 105.81,147.44 v1(105.49,147.76)
  BOTTOM w0.114: v2(47.61,170.35) 47.08,169.82 JDIM1.8
M_A_DQ59: length 81.8
  IN4 w0.089: v2(48.41,167.35) 48.97,166.79 52.44,166.79 54.21,168.56 57.76,168.56 58.03,168.83 61.63,168.83 61.98,169.19 77.9,169.19 83.16,163.92 83.29,163.92 83.48,164.12 83.6,164.12 83.85,163.87 83.85,163.75 83.65,163.56 83.65,163.43 83.84,163.24 83.97,163.24 84.16,163.43 84.29,163.43 84.47,163.24 84.47,163.12 84.28,162.93 84.28,162.8 84.47,162.61 84.6,162.61 84.79,162.8 84.91,162.8 85.1,162.62 85.1,162.49 84.91,162.3 84.91,162.17 85.1,161.98 85.23,161.98 85.42,162.17 85.54,162.17 85.73,161.99 85.73,161.86 85.54,161.67 85.54,161.54 85.73,161.35 85.85,161.35 86.05,161.55 86.17,161.55 86.36,161.36 86.36,161.23 86.17,161.04 86.17,160.91 86.36,160.73 86.48,160.73 86.67,160.92 86.8,160.92 86.99,160.73 86.99,160.6 86.8,160.41 86.8,160.29 86.99,160.1 87.11,160.1 87.3,160.29 87.43,160.29 89.33,158.39 89.33,156.99 90.22,156.11 96.29,156.11 99.73,152.67 99.73,147.14 100.47,146.4 102.08,146.4 102.56,145.91 103.17,145.91 103.48,146.22 104.86,146.22 105.24,146.61 105.24,147.32 v1(104.82,147.74)
  BOTTOM w0.102: v1(104.82,147.74) 105.16,147.4 U6539.BB42
  BOTTOM w0.114: v2(48.41,167.35) 47.89,166.82 JDIM1.20
M_A_DQ60: length 80.5
  IN4 w0.089: v2(50.17,170.52) 50.7,171.05 51.76,171.05 52.96,172.25 57.22,172.25 57.77,172.8 59.18,172.8 60.57,174.19 62.66,174.19 63.46,173.38 67.74,173.38 68.5,172.62 79.39,172.62 83.98,168.03 85.28,168.03 85.73,167.58 85.86,167.58 86.3,168.02 86.43,168.02 86.62,167.83 86.62,167.71 86.17,167.26 86.17,167.14 86.36,166.95 86.48,166.95 86.93,167.39 87.06,167.39 87.25,167.2 87.25,167.08 86.8,166.63 86.8,166.51 86.99,166.32 87.11,166.32 87.56,166.76 87.69,166.76 87.87,166.57 87.87,166.45 87.43,166 87.43,165.88 87.68,165.63 87.8,165.63 88.06,165.38 88.06,165.25 90.09,163.22 97.07,163.22 99.87,160.42 99.87,159.15 101.26,157.76 101.26,154.48 101.42,154.33 101.42,148.32 101.54,148.2 102.92,148.2 103.36,147.76 v1(103.53,147.76)
  BOTTOM w0.102: v1(103.53,147.76) 103.86,147.43 U6539.BB45
  BOTTOM w0.114: JDIM1.3 50.52,171.07 50.17,170.72 v2(50.17,170.52)
M_A_DQ61: length 79.3
  IN4 w0.089: v2(49.94,167.27) 49.61,167.27 49.48,167.4 49.48,167.92 49.61,168.04 52.62,168.04 54.3,169.72 58.04,169.72 58.6,170.28 68.38,170.28 68.75,169.91 72.44,169.91 72.53,170 72.53,170.33 72.61,170.42 72.88,170.42 72.97,170.33 72.97,170 73.06,169.91 73.33,169.91 73.41,170 73.41,170.33 73.5,170.42 73.77,170.42 73.86,170.33 73.86,170 73.95,169.91 74.21,169.91 74.3,170 74.3,170.33 74.39,170.42 74.66,170.42 74.75,170.33 74.75,170 74.84,169.91 75.1,169.91 75.19,170 75.19,170.33 75.28,170.42 75.55,170.42 75.64,170.33 75.64,170 75.73,169.91 75.99,169.91 76.08,170 76.08,170.33 76.17,170.42 76.51,170.42 76.6,170.33 76.6,170 76.69,169.91 76.96,169.91 77.05,170 77.05,170.33 77.14,170.42 77.4,170.42 77.49,170.33 77.49,170 77.58,169.91 77.85,169.91 77.94,170 77.94,170.33 78.02,170.42 78.57,170.42 91.36,157.63 91.36,157.5 91.99,156.87 96.36,156.87 100.28,152.94 100.28,147.35 100.83,146.8 102.23,146.8 102.68,146.35 102.99,146.35 103.43,146.79 v1(103.53,146.79)
  BOTTOM w0.102: v1(103.53,146.79) 103.86,146.46 U6539.BD45
  BOTTOM w0.114: JDIM1.21 50.64,166.57 v2(49.94,167.27)
M_A_DQ62: length 80.2
  IN4 w0.089: v1(102.83,147.76) 101.61,147.76 101.19,148.17 101.19,153.89 100.88,154.2 100.88,157.5 98.98,159.41 94.28,159.41 90.98,162.71 88.79,162.71 88.06,163.45 88.06,163.8 88.4,164.15 88.4,164.27 88.21,164.46 88.08,164.46 87.63,164 87.5,164 87.31,164.19 87.31,164.32 87.77,164.78 87.77,164.9 87.58,165.09 87.46,165.09 87,164.63 86.87,164.63 86.68,164.82 86.68,164.95 87.14,165.4 87.14,165.53 86.95,165.72 86.83,165.72 86.37,165.26 86.24,165.26 86.05,165.45 86.05,165.57 86.51,166.03 86.51,166.16 86.32,166.35 86.2,166.35 85.74,165.89 85.61,165.89 85.43,166.08 85.43,166.2 85.88,166.66 85.88,166.79 85.69,166.98 85.57,166.98 85.11,166.52 84.99,166.52 84.8,166.71 84.8,166.83 85.25,167.29 85.25,167.42 85.07,167.61 84.94,167.61 84.48,167.15 84.36,167.15 79.22,172.28 68.07,172.28 67.36,173 63.16,173 62.32,173.84 60.71,173.84 59.32,172.46 57.92,172.46 57.37,171.91 53.44,171.91 52.88,171.35 52.88,171.35 52.09,170.55 v2(51.46,170.55)
  BOTTOM w0.102: U6539.BB47 103.21,147.38 v1(102.83,147.76)
  BOTTOM w0.114: v2(51.46,170.55) 51.94,170.07 JDIM1.7
M_A_DQ63: length 78.6
  IN4 w0.089: v1(102.88,146.79) 102.57,146.79 102.33,147.03 101.07,147.03 100.53,147.57 100.53,153.1 98.09,155.55 98.09,157.76 97.55,158.29 91.36,158.29 78.89,170.76 72.39,170.76 72.31,170.84 71.99,170.84 71.9,170.75 71.9,170.42 71.81,170.33 71.54,170.33 71.46,170.42 71.46,170.75 71.37,170.84 71.1,170.84 71.01,170.75 71.01,170.42 70.92,170.33 70.66,170.33 70.57,170.42 70.57,170.75 70.48,170.84 70.21,170.84 70.12,170.75 70.12,170.42 70.03,170.33 69.77,170.33 69.68,170.42 69.68,170.75 69.59,170.84 69.32,170.84 69.23,170.75 69.23,170.42 69.14,170.33 68.88,170.33 68.79,170.42 68.79,170.75 68.7,170.84 68.24,170.84 68.03,170.62 58.46,170.62 57.9,170.07 54.01,170.07 52.33,168.39 48.22,168.39 47.92,168.68 47.42,168.68 47.09,168.35 v2(47.09,167.34)
  BOTTOM w0.102: v1(102.88,146.79) 103.21,146.46 U6539.BD47
  BOTTOM w0.114: v2(47.09,167.34) 46.61,167.82 JDIM1.16
M_A_DQSN0: length 64.2
  IN4 w0.089: v1(89.33,129.44) 88.74,128.85 86.86,128.85 81.78,123.77 80.01,123.77 79.89,123.65 73.68,123.65 71.6,121.56 67.09,121.56 65.11,119.58 57.34,119.58 56.35,120.57 48,120.57 47.86,120.43 47.86,120.2 48.03,120.04 v2(48.56,120.04)
  BOTTOM w0.079: 98.55,131.37 98.57,131.37 98.6,131.4 99.69,131.4 99.88,131.58 101.36,131.58 101.55,131.78 101.55,131.91 101.63,131.99 U6539.CR50
  BOTTOM w0.102: 98.55,131.37 98.06,131.37 97.14,130.45 91.99,130.45 91.37,129.83 89.72,129.83 v1(89.33,129.44) ; JDIM1.198 46.14,120.32 46.23,120.23 47.57,120.23 47.77,120.04 v2(48.56,120.04)
M_A_DQSN1: length 64
  IN4 w0.089: v1(94.78,132.47) 94.71,132.47 94.19,132.99 86.23,132.99 82.12,128.88 70.87,128.88 69.02,127.02 65.67,127.02 65.04,126.39 56.93,126.39 56.18,127.14 52.83,127.14 52.54,126.84 50.76,126.84 50.63,126.97 49.74,126.97 49.43,126.66 49.43,126.37 v2(49.19,126.13)
  BOTTOM w0.079: 98.55,134.11 98.57,134.11 98.6,134.14 99.15,134.14 99.27,134.02 99.85,134.02 99.96,134.14 101.35,134.14 101.57,134.35 101.57,134.49 101.62,134.54 U6539.CK50
  BOTTOM w0.102: v1(94.78,132.47) 94.76,132.47 94.54,132.69 94.54,133.02 95.45,133.93 98.01,133.93 98.19,134.11 98.55,134.11 ; v2(49.19,126.13) 49.6,126.54 49.6,126.74 49.86,127 51.32,127 51.96,126.35 51.96,125.6 52.09,125.47 52.39,125.47 52.49,125.57 JDIM1.177
M_A_DQSN2: length 73.6
  IN4 w0.089: v2(47.41,109.71) 47.92,109.71 48.05,109.59 48.05,109.28 48.35,108.99 49.29,108.99 49.5,109.19 55.99,109.19 56.5,109.7 60.7,109.7 61.24,109.17 64.76,109.17 66.79,111.2 74.35,111.2 75.03,111.88 79.93,111.88 81.22,113.18 83.04,113.18 84.88,115.02 84.88,115.96 85.66,116.74 86.53,116.74 87.04,117.24 87.93,117.24 89.96,119.28 89.96,119.78 90.72,120.55 91.6,120.55 93.63,122.58 94.15,122.58 95.12,123.54 95.12,123.76 96.44,125.08 96.44,126.46 96.69,126.72 96.9,126.72 98.22,128.03 98.22,128.39 101.31,131.48 103.87,131.48 v1(104.19,131.16)
  BOTTOM w0.102: U6539.CV44 104.51,130.84 v1(104.19,131.16) ; JDIM1.240 46,109.82 46.27,109.55 46.8,109.55 47.21,109.14 47.75,109.14 47.9,109.29 47.9,109.47 47.66,109.71 v2(47.41,109.71)
M_A_DQSN3: length 72.1
  IN4 w0.089: v2(49.42,115.15) 49.63,115.15 49.83,114.94 49.83,114.68 50.1,114.41 52.08,114.41 52.16,114.5 56.09,114.5 56.19,114.6 60.02,114.6 60.22,114.8 61.16,114.8 61.36,114.6 63.83,114.6 64.43,115.21 70.01,115.21 70.75,115.95 71.03,115.95 71.43,115.55 71.78,115.55 72.23,116 72.23,116.35 71.89,116.69 71.89,116.95 72.45,117.51 72.8,117.51 73.07,117.24 73.07,116.86 73.45,116.48 74.16,116.48 75.61,117.93 76.75,117.93 78.42,119.59 82.41,119.59 83.92,121.1 84.95,121.1 86.79,122.95 86.79,123.47 87.22,123.9 88.13,123.9 90.57,126.33 91.71,126.33 93.11,127.74 93.89,127.74 95.25,129.1 95.25,129.64 96.44,130.83 96.87,130.83 99.36,133.32 100.2,133.32 101.06,134.19 102.59,134.19 102.73,134.33 103.92,134.33 v1(104.29,133.95)
  BOTTOM w0.102: U6539.CM44 104.51,133.74 v1(104.29,133.95) ; JDIM1.219 52.33,115.07 51.56,115.85 50.12,115.85 v2(49.42,115.15)
M_A_DQSN4: length 65.6
  IN4 w0.089: v1(92.84,144) 92.9,144.05 92.9,144.27 92.79,144.38 89.37,144.38 86.15,147.6 85.1,147.6 83.2,149.5 80.94,149.5 76.8,153.65 61.65,153.65 61.51,153.79 58.02,153.79 57.62,153.38 54.8,153.38 54.05,152.63 49.22,152.63 48.67,153.18 48.18,153.18 48.01,153.02 48.01,152.84 v2(48.56,152.3)
  BOTTOM w0.079: 99.33,143.96 99.35,143.98 99.35,144.02 99.4,144.07 99.75,144.07 100.04,144.35 101.36,144.35 101.56,144.55 101.56,144.69 101.61,144.75 U6539.BG50
  BOTTOM w0.102: v2(48.56,152.3) 48.31,152.3 48.06,152.55 48.06,152.87 47.77,153.16 46.24,153.16 46.07,153.32 JDIM1.74 ; v1(92.84,144) 93,143.84 93,143.31 93.52,142.8 98.17,142.8 99.33,143.96
M_A_DQSN5: length 68.6
  IN4 w0.089: v1(94.87,146.22) 95.03,146.38 95.03,146.68 94.91,146.81 90.59,146.81 89.83,147.56 89.83,148.07 84.07,153.83 83.44,153.83 77.13,160.14 64.12,160.14 63.72,160.55 61.24,160.55 60.99,160.3 55,160.3 52.33,157.63 51.35,157.63 50.84,157.11 49.03,157.11 48.79,157.36 48.79,157.59 v2(48.55,157.83)
  BOTTOM w0.079: U6539.BA50 101.59,147.3 101.54,147.25 101.54,147.1 101.34,146.89 99.19,146.89 99.15,146.85 99.13,146.85
  BOTTOM w0.102: v2(48.55,157.83) 48.74,157.83 48.91,158 48.91,158.43 49.21,158.72 50.71,158.72 50.96,158.48 52.29,158.48 52.39,158.57 JDIM1.53 ; 99.13,146.85 98.67,146.85 97.94,146.13 96.73,146.13 96.15,145.55 95.34,145.55 95.11,145.79 95.11,145.98 v1(94.87,146.22)
M_A_DQSN6: length 76
  IN4 w0.089: v1(104.29,144.9) 103.89,144.5 100.46,144.5 98.47,146.49 98.47,151.44 96.85,153.06 90.12,153.06 89.83,153.34 89.83,153.85 77.68,166.01 63.55,166.01 63.14,166.41 57.81,166.41 57.19,165.79 54.53,165.79 51.98,163.24 48.26,163.24 48.13,163.37 48.13,163.67 48.32,163.86 v2(48.6,163.86)
  BOTTOM w0.102: v2(48.6,163.86) 48.17,163.86 48.07,163.96 48.07,164.28 47.77,164.59 46.88,164.59 46.39,164.11 46.39,163.79 46.28,163.67 46.15,163.67 46,163.82 JDIM1.32 ; v1(104.29,144.9) 104.51,144.69 U6539.BH44
M_A_DQSN7: length 79.8
  IN4 w0.089: v2(50.51,169.25) 50.16,169.25 50.03,169.37 50.03,169.58 50.16,169.71 52.51,169.71 53.7,170.9 58.03,170.9 58.25,171.13 65.78,171.13 65.99,171.33 65.99,172.2 66.08,172.29 66.61,172.29 66.7,172.2 66.7,171.34 66.91,171.13 67.65,171.13 67.99,171.47 74.85,171.47 75.05,171.27 79.24,171.27 88.51,162 90.67,162 92.68,159.99 92.68,159.58 93.61,158.65 98.47,158.65 99.03,158.09 99.03,156.66 99.28,156.41 99.92,156.41 100.05,156.28 100.05,155.73 99.92,155.6 99.57,155.6 99.33,155.35 99.33,154.83 100.76,153.4 100.76,147.93 101.42,147.27 102.45,147.27 102.55,147.16 103.81,147.16 v1(104.18,146.79)
  BOTTOM w0.102: JDIM1.11 52.37,169.07 52.1,168.8 49.88,168.8 49.8,168.88 49.8,169 49.75,169.05 49.75,169.27 49.91,169.43 50.33,169.43 v2(50.51,169.25) ; U6539.BD44 104.51,146.46 v1(104.18,146.79)
M_A_DQSN8: length 3.8
  TOP w0.114: v2(51.39,148.55) 51.39,148.43 50.7,147.74 R232.1
  BOTTOM w0.114: JDIM1.95 51.87,148.07 v2(51.39,148.55)
M_A_DQSP0: length 64.1
  IN4 w0.089: v2(47.38,119.4) 47.79,119.81 47.79,119.99 47.66,120.12 47.66,120.51 47.92,120.77 56.43,120.77 57.42,119.78 65.02,119.78 67.01,121.76 71.51,121.76 73.6,123.85 79.8,123.85 79.93,123.97 81.69,123.97 86.77,129.05 88.31,129.05 v1(88.69,129.44)
  BOTTOM w0.079: U6539.CR51 101.33,131.99 101.39,131.93 101.39,131.85 101.29,131.74 99.81,131.74 99.63,131.56 98.6,131.56 98.57,131.59 98.55,131.59
  BOTTOM w0.102: v1(88.69,129.44) 89.12,129.87 89.44,129.87 89.63,130.06 91.28,130.06 91.9,130.68 97.05,130.68 97.96,131.59 98.55,131.59 ; v2(47.38,119.4) 47.6,119.63 47.6,119.88 47.47,120.01 46.22,120.01 46.04,119.82 JDIM1.200
M_A_DQSP1: length 63.9
  IN4 w0.089: v1(94.17,132.44) 94.24,132.52 94.24,132.65 94.1,132.79 86.32,132.79 82.2,128.67 70.96,128.67 69.1,126.82 65.76,126.82 65.12,126.18 56.85,126.18 56.1,126.93 52.92,126.93 52.62,126.64 50.67,126.64 50.55,126.77 49.83,126.77 49.63,126.57 49.63,126.26 49.76,126.13 v2(50.46,126.13)
  BOTTOM w0.079: U6539.CK51 101.37,134.54 101.41,134.5 101.41,134.41 101.29,134.29 99.89,134.29 99.78,134.18 99.33,134.18 99.22,134.3 98.6,134.3 98.57,134.34 98.55,134.34
  BOTTOM w0.102: 98.55,134.34 98.09,134.34 97.92,134.16 95.36,134.16 94.31,133.11 94.31,132.59 94.17,132.45 v1(94.17,132.44) ; JDIM1.179 52.41,125.07 52.24,125.24 52,125.24 51.73,125.5 51.73,126.26 51.23,126.77 49.96,126.77 49.83,126.64 49.83,126.39 50.08,126.13 v2(50.46,126.13)
M_A_DQSP2: length 73.6
  IN4 w0.089: v2(48.69,109.72) 48.41,109.72 48.26,109.57 48.26,109.37 48.43,109.19 49.21,109.19 49.41,109.39 55.91,109.39 56.41,109.9 60.79,109.9 61.32,109.37 64.67,109.37 66.7,111.4 74.26,111.4 74.95,112.09 79.84,112.09 81.14,113.38 82.95,113.38 84.68,115.11 84.68,116.04 85.57,116.94 86.45,116.94 86.96,117.45 87.85,117.45 89.76,119.36 89.76,119.87 90.64,120.75 91.52,120.75 93.55,122.78 94.07,122.78 94.91,123.63 94.91,123.85 96.24,125.17 96.24,126.55 96.61,126.92 96.82,126.92 98.01,128.11 98.01,128.48 101.22,131.69 104.12,131.69 104.24,131.81 v1(104.24,132.07)
  BOTTOM w0.102: JDIM1.242 46.7,109.32 47.11,108.91 47.85,108.91 48.13,109.19 48.13,109.55 48.31,109.72 v2(48.69,109.72) ; U6539.CT44 104.51,131.81 v1(104.24,132.07)
M_A_DQSP3: length 72
  IN4 w0.089: v1(104.29,134.82) 104,134.54 102.65,134.54 102.5,134.39 100.98,134.39 100.11,133.52 99.28,133.52 96.79,131.04 96.35,131.04 95.04,129.72 95.04,129.18 93.8,127.94 93.03,127.94 91.62,126.54 90.48,126.54 88.04,124.1 87.13,124.1 86.58,123.55 86.58,123.03 84.86,121.31 83.83,121.31 82.32,119.8 78.33,119.8 76.67,118.13 75.53,118.13 74.08,116.68 73.54,116.68 73.27,116.95 73.27,117.33 72.89,117.71 72.36,117.71 71.69,117.04 71.69,116.6 72.03,116.26 72.03,116.08 71.69,115.75 71.51,115.75 71.12,116.15 70.66,116.15 69.92,115.41 64.35,115.41 63.74,114.8 61.45,114.8 61.24,115.01 60.13,115.01 59.93,114.8 56.11,114.8 56,114.7 52.08,114.7 51.99,114.61 50.19,114.61 50.03,114.77 50.03,114.97 50.21,115.15 v2(50.69,115.15)
  BOTTOM w0.102: U6539.CK44 104.51,134.6 v1(104.29,134.82) ; v2(50.69,115.15) 50.18,115.15 50.07,115.26 50.07,115.47 50.21,115.62 51.46,115.62 52.51,114.57 JDIM1.221
M_A_DQSP4: length 65.4
  IN4 w0.089: v1(93.46,144.01) 93.45,144.01 92.87,144.58 89.45,144.58 86.24,147.8 85.19,147.8 83.28,149.7 81.03,149.7 76.88,153.85 61.74,153.85 61.59,153.99 57.94,153.99 57.53,153.58 54.71,153.58 53.96,152.83 49.31,152.83 48.75,153.39 48.09,153.39 47.81,153.1 47.81,152.82 v2(47.29,152.3)
  BOTTOM w0.079: 99.17,144.13 99.19,144.14 99.25,144.14 99.33,144.22 99.69,144.22 99.98,144.51 101.29,144.51 101.4,144.62 101.4,144.69 101.34,144.75 U6539.BG51
  BOTTOM w0.102: v2(47.29,152.3) 47.67,152.3 47.83,152.45 47.83,152.77 47.67,152.93 46.09,152.93 45.98,152.82 JDIM1.76 ; 99.17,144.13 98.07,143.02 93.61,143.02 93.23,143.41 93.23,143.78 v1(93.46,144.01)
M_A_DQSP5: length 68.5
  IN4 w0.089: v2(49.82,157.83) 49.26,157.83 48.99,157.55 48.99,157.45 49.12,157.32 50.75,157.32 51.26,157.83 52.25,157.83 54.91,160.5 60.9,160.5 61.16,160.75 63.8,160.75 64.21,160.34 77.21,160.34 83.52,154.03 84.16,154.03 90.04,148.15 90.04,147.65 90.67,147.01 94.99,147.01 95.24,146.77 95.24,146.46 v1(95.49,146.21)
  BOTTOM w0.079: 99.13,147.08 99.15,147.08 99.19,147.05 101.27,147.05 101.38,147.16 101.38,147.25 101.33,147.3 U6539.BA51
  BOTTOM w0.102: v1(95.49,146.21) 95.47,146.21 95.34,146.07 95.34,145.88 95.44,145.78 96.06,145.78 96.64,146.36 97.85,146.36 98.57,147.08 99.13,147.08 ; JDIM1.55 52.43,158.07 52.25,158.25 50.86,158.25 50.61,158.5 49.3,158.5 49.14,158.34 49.14,157.97 49.29,157.83 v2(49.82,157.83)
M_A_DQSP6: length 75.9
  IN4 w0.089: v2(47.33,163.86) 47.79,163.86 47.92,163.73 47.92,163.29 48.17,163.04 52.07,163.04 54.62,165.59 57.27,165.59 57.89,166.21 63.06,166.21 63.46,165.81 77.59,165.81 89.63,153.77 89.63,153.26 90.04,152.85 96.77,152.85 98.27,151.36 98.27,146.4 100.38,144.29 103.82,144.29 v1(104.19,143.92)
  BOTTOM w0.102: U6539.BK44 104.51,143.6 v1(104.19,143.92) ; v2(47.33,163.86) 47.77,163.86 47.84,163.94 47.84,164.19 47.67,164.36 46.97,164.36 46.62,164.01 46.62,163.69 46.38,163.45 46.12,163.45 46,163.32 JDIM1.34
M_A_DQSP7: length 79.8
  IN4 w0.089: v1(104.17,147.74) 103.79,147.37 102.64,147.37 102.53,147.47 101.51,147.47 100.96,148.01 100.96,153.49 99.53,154.92 99.53,155.27 99.66,155.39 100,155.39 100.25,155.64 100.25,156.37 100,156.61 99.36,156.61 99.23,156.74 99.23,158.17 98.56,158.85 93.69,158.85 92.88,159.66 92.88,160.08 90.76,162.2 88.6,162.2 79.33,171.47 75.14,171.47 74.93,171.68 67.91,171.68 67.56,171.33 66.99,171.33 66.9,171.42 66.9,172.28 66.69,172.49 65.99,172.49 65.78,172.28 65.78,171.42 65.69,171.33 58.17,171.33 57.94,171.1 53.62,171.1 52.42,169.91 50.08,169.91 49.83,169.66 49.83,169.37 49.7,169.25 v2(49.24,169.25)
  BOTTOM w0.102: v1(104.17,147.74) 104.51,147.4 U6539.BB44 ; JDIM1.13 49.78,168.57 49.58,168.78 49.58,168.91 v2(49.24,169.25)
M_A_DQSP8: length 3.6
  TOP w0.114: R231.1 50.7,148.48 v2(50.73,148.51)
  BOTTOM w0.114: v2(50.73,148.51) 51.66,147.57 JDIM1.97
M_A_PARITY: length 66.4
  IN4 w0.102: v2(51.61,136.42) 51.63,136.39 52.56,136.39 52.8,136.63 56.64,136.63 57.9,137.88 61.88,137.88 61.98,137.78 61.98,137.66 62.08,137.56 62.29,137.56 62.39,137.66 62.39,137.78 62.49,137.88 62.69,137.88 62.79,137.78 62.79,137.66 62.9,137.56 63.1,137.56 63.2,137.66 63.2,137.78 63.3,137.88 63.5,137.88 63.61,137.78 63.61,137.66 63.71,137.56 63.91,137.56 64.01,137.66 64.01,137.78 64.11,137.88 64.32,137.88 64.42,137.78 64.42,137.66 64.52,137.56 64.72,137.56 64.83,137.66 64.83,137.87 64.93,137.97 65.13,137.97 65.23,137.87 65.23,137.21 65.33,137.11 65.54,137.11 65.64,137.21 65.64,137.78 65.74,137.88 66.15,137.88 66.21,137.82 68.66,137.82 69.14,137.34 81.17,137.34 81.27,137.24 81.27,136.88 81.37,136.78 81.58,136.78 81.68,136.88 81.68,137.24 81.78,137.34 81.99,137.34 82.09,137.44 85.3,137.44 85.73,137.01 95.25,137.01 96.31,138.07 96.82,138.07 99.11,140.36 99.74,140.36 99.87,140.48 99.87,141.12 99.99,141.25 100.19,141.25 100.29,141.14 100.29,140.46 100.4,140.36 100.6,140.36 100.7,140.46 100.7,141.14 100.8,141.25 101.01,141.25 101.11,141.14 101.11,140.84 101.21,140.74 101.41,140.74 101.51,140.84 101.51,141.14 101.62,141.25 101.9,141.25 102.03,141.12 102.03,140.87 102.15,140.74 103.24,140.74 v1(103.64,140.33)
  BOTTOM w0.102: U6539.BV45 103.86,140.12 v1(103.64,140.33)
  BOTTOM w0.152: JDIM1.143 52.4,136.07 52.24,135.91 52.24,135.33 51.99,135.08 51.73,135.08 51.61,135.2 v2(51.61,136.42)
M_A_RAS#: length 65.1
  IN4 w0.102: v2(48.94,132.48) 49.6,133.14 54.3,133.14 54.48,133.32 58.52,133.32 58.95,132.89 59.89,132.89 60.35,133.35 61.49,133.35 61.64,133.5 61.64,134.13 62.05,134.54 64.01,134.54 64.11,134.44 64.11,133.96 64.21,133.85 64.42,133.85 64.52,133.96 64.52,134.44 64.62,134.54 69.16,134.54 69.39,134.77 70.1,134.77 70.2,134.67 70.2,134.39 70.3,134.29 70.51,134.29 70.61,134.39 70.61,134.67 70.71,134.77 70.91,134.77 71.01,134.67 71.01,134.39 71.12,134.29 71.32,134.29 71.42,134.39 71.42,134.67 71.52,134.77 71.8,134.77 71.93,134.64 71.93,134.36 72.05,134.24 82.32,134.24 83.67,135.59 97.04,135.59 99.8,138.35 102.84,138.35 v1(102.99,138.5)
  BOTTOM w0.102: U6539.CB47 103.21,138.29 v1(102.99,138.5)
  BOTTOM w0.152: JDIM1.152 46.25,131.82 46.91,132.48 v2(48.94,132.48)
M_A_WE#: length 65.4
  IN4 w0.102: v2(51.73,132.07) 52.07,131.73 52.83,131.73 52.93,131.84 52.93,132.23 53.03,132.33 53.23,132.33 53.34,132.23 53.34,131.84 53.44,131.73 53.64,131.73 53.74,131.84 53.74,132.23 53.84,132.33 54.05,132.33 54.15,132.23 54.15,131.84 54.25,131.73 54.95,131.73 55.32,132.11 55.67,132.11 55.8,132.23 55.8,132.36 55.9,132.46 56.21,132.46 56.33,132.33 56.33,132.02 56.44,131.92 56.64,131.92 56.74,132.02 56.74,132.41 56.84,132.51 57.04,132.51 57.15,132.41 57.15,132.02 57.25,131.92 57.45,131.92 57.55,132.02 57.55,132.41 57.65,132.51 57.83,132.51 57.96,132.38 57.96,132.1 58.09,131.98 60.64,131.98 60.77,132.1 60.77,132.43 60.87,132.53 61.07,132.53 61.18,132.43 61.18,132.02 61.28,131.92 61.48,131.92 61.58,132.02 61.58,132.43 61.68,132.53 61.89,132.53 61.99,132.43 61.99,132.02 62.09,131.92 63.75,131.92 63.93,132.1 63.93,132.74 64.05,132.86 64.23,132.86 64.34,132.76 64.34,132.08 64.44,131.98 64.64,131.98 64.74,132.08 64.74,132.79 65.68,133.73 69.67,133.73 69.97,133.42 82.27,133.42 83.94,135.1 97.32,135.1 99.99,137.77 102.24,137.77 102.71,137.3 103.19,137.3 v1(103.5,137.61)
  BOTTOM w0.102: v1(103.5,137.61) 103.5,137.69 U6539.CB45
  BOTTOM w0.152: v2(51.73,132.07) JDIM1.151
M_B_A0: length 63.3
  IN3 w0.102: v2(59.74,135.28) 59.74,135.91 59.86,136.04 61.01,136.04 61.74,136.78 64.08,136.78 64.48,136.38 64.48,136.14 64.58,136.04 64.78,136.04 64.88,136.14 64.88,136.67 64.99,136.78 65.19,136.78 65.29,136.67 65.29,136.14 65.39,136.04 65.59,136.04 65.7,136.14 65.7,136.67 65.96,136.93 67.61,136.93 68.52,137.84 68.52,138.79 85.84,156.11 90.72,156.11 91.74,157.12 96.95,157.12 97.45,157.63 97.45,158.77 97.96,159.28 102.28,159.28 102.53,159.03 105.2,159.03 v1(105.6,158.63)
  BOTTOM w0.102: v1(105.6,158.63) U6539.U41
  BOTTOM w0.152: v2(59.74,135.28) 58.85,135.28 58.3,135.82 JDIM02.144
