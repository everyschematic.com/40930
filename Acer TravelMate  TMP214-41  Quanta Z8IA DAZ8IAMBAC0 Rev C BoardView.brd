# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): outline of 148 points within 0.51,30.19 15.99,83.82
GND on IN3 (solid shape): outline of 297 points within 1.01,0.51 237.49,218.99
GND on SGND1 (solid shape): outline of 3349 points within 0.51,0.51 237.49,218.99
GND on IN4 (solid shape): 106.47,113.56 102.92,113.56 102.92,115.21 106.47,115.21
GND on IN4 (solid shape): 128.44,174.39 124.76,174.39 124.12,175.03 124.12,177.44 124.63,177.95 128.44,177.95
GND on IN4 (solid shape): 33.83,171.35 33.83,167.54 32.05,167.54 31.54,167.03 30.91,167.03 30.4,167.54 30.4,171.47 30.53,171.6 33.57,171.6
GND on IN4 (solid shape): 90.72,113.05 90.72,110.64 90.47,110.39 85.9,110.39 85.64,110.64 85.64,113.05 86.02,113.43 90.34,113.43
GND on IN4 (solid shape): 132,124.99 132,122.2 131.36,121.56 129.08,121.56 128.82,121.82 128.82,125.12 129.2,125.5 130.09,125.5 130.47,125.88 131.11,125.88
GND on IN4 (solid shape): outline of 92 points within 95.93,99.72 97.58,102.13
GND on IN4 (solid shape): 13.92,192.77 13.92,191.78 13.92,191.7 13.92,190.7 12.91,190.7 12.91,191.7 12.7,192.2 12.2,192.41 8.31,192.41 8.31,192.9 8.1,193.4 7.6,193.61 6.2,193.61 5.7,193.4 5.49,192.9 5.49,192.41 2.21,192.41 2.21,193.15 1.91,193.86 1.2,194.16 1.01,194.16 1.01,195.14 4.45,195.14 4.75,194.92 5.12,194.84 7.27,194.84 7.55,194.95 7.77,195.14 8.28,195.14 9.31,194.89 10,195.69 11,195.69
GND on IN4 (solid shape): 14.66,102.5 14.72,102.49 15.61,102.49 16.45,101.64 16.45,100.55 15.47,99.57 15.47,94.62 14.77,93.93 14.71,93.85 14.61,93.86 14.37,93.98 14.1,94.02 13.99,94.02 13.88,94 13.8,94.01 13.76,94.09 13.76,96.52 13.01,97.49 11.88,97.03 9.9,97.03 9.44,96.87 9.17,96.47 9.16,96.43 4.36,96.43 4.36,99.91 9.16,99.91 9.17,99.87 9.44,99.47 9.9,99.31 11.88,99.31 13.01,98.85 13.76,99.82 13.76,102.25 13.8,102.33 13.88,102.34 13.99,102.32 14.1,102.32 14.37,102.36 14.61,102.48
GND on IN4 (solid shape): 10.31,122.57 10.38,122.66 10.5,122.62 10.73,122.4 11.12,122.32 11.2,122.34 12.66,122.34 13.17,121.82 13.17,116.6 14.27,115.96 14.77,114.78 15.87,113.67 15.87,112.7 15.12,111.94 14.68,111.94 14.65,111.95 14.61,111.96 14.37,112.08 14.1,112.12 13.99,112.12 13.88,112.1 13.8,112.11 13.76,112.19 13.76,114.62 13.01,115.59 11.88,115.13 9.9,115.13 9.44,114.97 9.17,114.57 9.16,114.53 3.01,114.53 3.01,119.27 8.22,119.27 9.46,118.7 10.31,119.78
GND on IN4 (solid shape): outline of 337 points within 1.51,132.29 16.3,177.99
GND on IN4 (solid shape): outline of 1245 points within 0.51,30.19 15.99,83.77
GND on IN4 (solid shape): outline of 304 points within 1.01,0.51 237.49,218.99
GND on SGND2 (solid shape): outline of 3482 points within 0.51,0.51 237.49,218.99
V3A_BOOT on BOTTOM (solid shape): 178.46,134.31 178.46,133.73 178.1,133.37 177.57,133.37 176.98,132.79 176.98,131.95 176.8,131.77 176.47,131.77 176.47,133.35 177.59,134.46 178.3,134.46
V5P5A_BOOT on BOTTOM (solid shape): 56.4,179.84 56.21,179.65 55.44,179.65 55.34,179.75 55.34,180.59 55.85,181.1 55.85,181.73 56.1,181.99 56.4,181.99
VCC3V3_FLASH on TOP (solid shape): 33.19,71.78 33.45,71.52 33.45,69.75 33.83,69.36 33.83,65.94 33.57,65.68 32.56,65.68 31.67,64.79 31.29,64.79 31.16,64.92 31.16,66.06 31.29,66.19 31.8,66.19 32.43,66.82 32.43,71.4 32.56,71.52 32.56,73.3 33.19,73.3
VCCK_V12 on TOP (solid shape): 34.98,152.68 35.47,152.68 35.54,152.6 35.54,152.03 35.45,151.94 34.97,151.94 34.84,151.82 34.29,151.82 33.72,152.38 32.49,152.38 32.45,152.42 32.45,152.53 32.49,152.57 33.79,152.57 34.25,153.03 34.63,153.03
VCCK_V12 on TOP (solid shape): 29.48,150.77 29.44,150.68 29.42,150.58 29.42,150.01 28.51,149.09 26.36,149.09 26.21,149.25 26.21,149.76 26.33,149.88 26.48,149.88 26.49,149.88 27.48,149.88 27.53,149.88 27.63,149.89 27.81,149.97 27.89,150.14 27.89,150.28 27.89,150.42 27.87,150.51 27.83,150.58 27.81,150.66 27.86,150.73 27.94,150.79 27.99,150.86 28.68,150.86 28.94,150.9 29.17,151.02 29.21,151.02 29.26,151.08 29.48,151.08
VCCRTC_3 on TOP (solid shape): 7.39,13.71 7.39,13.33 6.5,12.44 6.5,12.32 6.37,12.19 5.74,12.19 5.61,12.32 5.61,12.95 5.74,13.08 6.01,13.08 6.78,13.84 7.26,13.84
VDD_SUPPLY_1P on BOTTOM (solid shape): 15.41,57.3 15.41,55.78 15.29,55.65 15.16,55.65 15.03,55.52 15.03,54.63 14.9,54.51 14.9,54.12 14.78,54 14.52,54 14.4,54.12 14.4,54.63 14.52,54.76 14.52,57.43 14.65,57.55 15.16,57.55
1P35V_PHASE on TOP (solid shape): 88.62,177.94 88.68,177.86 88.76,177.8 89.28,177.29 89.28,176.79 88.29,176.79 88.29,177.34 87.71,177.91 87.71,178.29 87.85,178.43 88.13,178.43
1P35V_PHASE on BOTTOM (solid shape): 84.88,186.2 84.88,185.19 85.01,185.06 85.54,185.06 86.1,184.5 86.1,182.09 85.72,181.71 85.72,180.34 85.57,180.18 83.66,180.18 83.18,179.7 80.39,179.7 79.8,180.29 79.8,182.98 81.25,184.43 82.57,184.43 83.59,185.44 83.61,185.44 83.74,185.57 83.74,186.2 83.99,186.46 84.63,186.46
5213LX_1.8V on TOP (solid shape): 36.65,140.03 36.65,139.14 36.65,139.14 36.65,138.79 36.81,138.63 36.96,138.63 37.05,138.57 37.16,138.55 38.1,138.55 38.18,138.51 38.2,138.44 38.2,138.4 38.23,138.25 38.31,138.12 38.46,137.97 38.86,137.97 38.98,137.84 38.98,137.33 38.71,137.06 34.55,137.06 34.08,137.53 34.08,138.56 34.19,138.67 35.97,138.67 36.34,139.04 36.34,139.14 36.35,139.14 36.35,140.01 36.38,140.04 36.64,140.04
8813BOOT1 on TOP (solid shape): 102.08,200.2 102.08,199.45 101.87,199.25 101.87,198.8 101.81,198.74 101.81,198.03 101.72,197.94 101.6,197.94 101.11,198.42 101.11,198.52 101.34,198.75 101.37,198.75 101.47,198.85 101.47,199.09 101.47,199.31 101.15,199.63 101.15,200.29 101.25,200.39 101.89,200.39
8813BOOT2 on TOP (solid shape): 106.37,195.3 105.75,195.3 104.71,195.3 104.69,195.3 104.48,195.08 103.93,195.63 103.93,195.7 104.22,196 106.37,196
8813PHASE1 on TOP (solid shape): 103.25,200.38 103.25,199.56 102.69,199.01 102.69,198.65 102.88,198.46 102.36,197.94 102.26,197.94 102.15,198.04 102.15,198.75 102.03,198.88 102.03,199.18 102.43,199.59 102.43,200.33 102.51,200.4 103.22,200.4
8813PHASE1 on BOTTOM (solid shape): 107.56,206.27 107.56,205.84 105.84,204.11 105.84,203.04 104.44,201.65 103.17,201.65 103.02,201.8 103.02,204.95 102.41,205.56 102.41,206.38 104.4,208.38 104.4,208.39 104.54,208.53 105.3,208.53
8813PHASE2 on TOP (solid shape): 106.37,196.29 106.24,196.16 104.03,196.16 103.93,196.26 103.93,196.36 104.48,196.91 104.6,196.78 104.67,196.72 104.74,196.64 104.94,196.64 105.2,196.64 105.41,196.85 105.41,197.15 105.58,197.33 106.37,197.33
8813PHASE2 on BOTTOM (solid shape): 113.48,198.85 113.48,197.15 113.36,197.02 111.96,197.02 111.65,196.72 111.65,195.81 111.51,195.67 108.49,195.67 108.4,195.75 108.4,196.21 107.49,197.13 106.78,197.13 106.42,197.48 105.51,197.48 105.35,197.63 105.35,198.45 105.53,198.62 106.79,198.62 106.93,198.62 107.72,198.62 108.61,199.51 112.82,199.51
8813UGATE2 on TOP (solid shape): 104.39,194.87 104.45,194.87 104.47,194.87 104.49,194.87 104.77,195.14 105.79,195.14 106.04,194.89 106.04,194.59 105.94,194.48 105.68,194.48 105.64,194.48 104.36,194.48 103.53,195.32 103.73,195.53
9336ADJ on BOTTOM (solid shape): 99.99,186.69 99.99,185.08 100.24,184.82 101.32,184.82 101.43,184.72 101.43,184.47 101.41,184.47 101.28,184.33 100.07,184.33 99.78,184.63 99.18,184.63 99.05,184.76 99.05,184.91 99.05,184.91 99.05,185.22 99.46,185.63 99.46,186.74 99.51,186.79 99.9,186.79
24780_BST on BOTTOM (solid shape): 155.62,119.71 155.87,119.45 156.39,119.45 156.39,119.45 157.15,119.45 157.2,119.4 157.2,119.33 157.12,119.25 156.39,119.25 155.9,119.25 155.79,119.14 155.74,119.1 155.16,119.1 155.11,119.15 155.11,119.58 155.24,119.71
24780_DH on BOTTOM (solid shape): 155.79,120.32 155.79,120.18 156.12,119.85 157.13,119.85 157.2,119.78 157.2,119.71 157.14,119.66 155.9,119.66 155.66,119.9 155.33,119.9 155.12,120.11 155.12,120.36 155.29,120.53 155.57,120.53
24780_DL on BOTTOM (solid shape): 156.39,118.65 157.17,118.65 157.17,118.46 156.31,118.46 156.23,118.39 156.23,118.06 156.05,117.88 155.76,117.88 155.6,118.04 155.6,118.31 155.8,118.51 155.83,118.54 155.96,118.67 156.39,118.67
24780_LX on BOTTOM (solid shape): 156.23,121 156.23,120.29 156.28,120.24 157.14,120.24 157.17,120.21 157.17,120.09 157.14,120.06 156.13,120.06 155.95,120.24 155.95,120.37 155.62,120.7 155.62,121.05 155.72,121.15 156.08,121.15
24780_LX on BOTTOM (solid shape): 151.66,118.87 151.66,118.02 151.21,117.57 151.21,114.75 150.9,114.44 150.41,114.44 149.61,113.65 149.61,112.89 149.53,112.8 148.48,112.8 148.3,112.98 145.39,112.98 145.27,113.1 145.27,117.48 145.67,117.88 148.13,117.88 148.28,118.03 149.52,118.03 149.8,118.31 149.8,118.89 149.91,119 151.53,119
24780_VCC on BOTTOM (solid shape): 157.2,124.43 157.2,122.74 157.16,122.73 156.92,122.36 157.16,121.98 157.2,121.97 157.2,120.55 157.14,120.49 157.14,120.45 156.38,120.45 156.38,120.83 156.38,120.87 156.38,121.08 156.14,121.32 155.56,121.32 155.49,121.38 155.49,122.27 155.53,122.3 155.55,122.31 155.82,122.43 155.93,122.71 155.9,122.86 155.82,122.99 155.82,124.36 156,124.53 157.09,124.53
+1.03_GFX on BOTTOM (solid shape): 142.25,211.47 143.15,211.47 143.57,211.05 143.57,209.41 143.57,209.41 143.57,208.87 143.12,208.43 142.67,208.43 142.41,208.68 142.41,209.22 142.31,209.32 141.6,209.32 141.5,209.42 141.5,210.59 141.78,210.87 141.78,211.35 141.9,211.48 142.25,211.48
+1.03_GFX on BOTTOM (solid shape): outline of 139 points within 93.42,195.24 97.38,199.4
+1.03_GFX on IN2 (solid shape): outline of 661 points within 135.23,197.99 144.8,211.02
+1.03_GFX on IN3 (solid shape): outline of 2479 points within 93.75,195.37 144.06,217.07
+601_VCC on TOP (solid shape): 233.73,118.51 235.63,118.51 235.91,118.23 235.91,114.02 235.86,113.97 235.63,113.97 235.5,114.09 235.5,116.23 234.36,117.37 233.63,117.37 232.93,116.68 232.93,116.68 232.79,116.65 232.67,116.58 231.47,116.58 231.39,116.66 231.39,117.22 231.43,117.26 231.43,118.75 231.57,118.89 233.34,118.89
+601_VCC on TOP (solid shape): 225.06,118.03 225.11,118 225.1,117.94 225.08,117.92 225.08,117.55 225.14,117.49 225.14,117.47 225.15,117.41 225.19,117.37 225.19,117.04 225.08,116.93 225.08,116.56 225.14,116.5 225.14,116.48 225.15,116.42 225.19,116.38 225.19,116.1 225.08,115.99 225.08,115.62 225.14,115.56 225.14,115.54 225.15,115.48 225.19,115.44 225.19,115.16 225.08,115.05 225.08,114.68 225.14,114.62 225.14,114.6 225.15,114.54 225.19,114.5 225.19,114.42 225.28,114.33 226.77,114.33 226.79,114.35 227.15,114.35 227.53,114.73 227.53,114.8 227.6,114.8 227.66,114.86 228.34,114.86 228.47,114.73 228.47,114.37 228.29,114.2 228.29,113.81 227.33,112.85 226.11,112.85 226.06,112.8 224.94,112.8 224.68,113.05 224.68,113.23 224.69,113.25 224.72,113.34 224.74,113.43 224.72,113.54 224.68,113.63 224.68,114 224.72,114.09 224.74,114.2 224.72,114.3 224.68,114.39 224.68,114.91 224.75,115.13 224.68,115.36 224.68,117.93 224.79,118.03
+601_VCC on IN2 (solid shape): outline of 140 points within 225.72,112.16 233.98,118.51
+AZA_VDD on BOTTOM (solid shape): 26.35,37.49 26.35,34.94 26.2,34.79 25.62,34.79 25.56,34.78 25.38,34.78 25.24,34.76 25.13,34.68 25.01,34.56 23.21,34.56 23.11,34.55 23.02,34.51 22.79,34.51 22.71,34.59 22.71,35.04 22.9,35.24 24.21,35.24 25.45,36.47 25.45,37.49 25.57,37.61 26.22,37.61
+CRT_AVCC_33 on TOP (solid shape): 33.43,151.26 33.43,150.66 33.57,150.52 33.95,150.52 35.22,149.25 36.11,149.25 36.49,148.87 36.49,148.23 36.37,148.1 35.86,148.1 35.35,148.61 34.97,148.61 34.84,148.74 34.84,148.87 33.7,150.01 33.07,150.01 32.56,150.52 32.56,151.28 32.66,151.38 33.32,151.38
+FB_PLLAVDD on TOP (solid shape): 115.69,194.8 115.69,194.41 115.52,194.24 115.25,194.24 115.18,194.17 115.17,194.16 115.11,194.12 115.06,194.05 115.05,194.04 114.99,193.97 114.99,193.45 114.51,192.98 114.51,192.2 114.21,191.91 113.76,191.91 113.74,191.88 113.67,191.88 113.5,192.08 113.25,192.15 112.93,192.02 112.8,191.69 112.83,191.52 112.93,191.37 112.96,191.34 112.9,191.27 112.9,190.66 112.93,190.63 112.83,190.53 112.26,190.53 112.18,190.61 112.18,192.48 112.84,193.13 113.22,193.13 113.32,193.09 113.44,193.08 113.76,193.21 113.89,193.53 113.9,193.58 113.9,194.58 114.29,194.98 115.52,194.98
+FB_PLLAVDD on IN2 (solid shape): outline of 99 points within 132.5,186.81 138.38,188.38
+SENSOR_POWER on TOP (solid shape): 136.44,214.53 136.44,213.89 136.57,213.76 136.57,213.27 136.55,213.2 136.54,213.13 136.55,213.06 136.57,212.98 136.57,212.61 136.55,212.55 136.54,212.47 136.32,212.24 135.94,212.24 135.81,212.37 135.81,214.4 136.06,214.65 136.32,214.65
+SENSOR_POWER on BOTTOM (solid shape): 157.27,212.87 157.27,211.6 157.14,211.48 156.26,211.48 156,211.22 155.75,211.22 155.62,211.35 155.62,212.37 156.51,213.26 156.89,213.26
+SENSOR_POWER on IN2 (solid shape): outline of 1390 points within 139.49,209.83 158.67,217.47
+SMDDR_VREF_DIMM on TOP (solid shape): 46.74,129.34 46.74,129.19 46.37,128.83 46.37,128.37 46.34,128.35 46.24,128.35 46.04,128.15 46.04,127.98 46.03,127.96 46.03,127.54 45.89,127.4 45.89,123.97 45.26,123.34 44.62,123.34 44.37,123.59 44.37,123.85 44.5,123.97 45,123.97 45.26,124.23 45.26,127.53 45.51,127.78 45.51,127.96 45.55,127.99 45.55,128.82 46.2,129.47 46.6,129.47
+SMDDR_VREF_DQ1_M1 on TOP (solid shape): 55.7,128.87 56.89,128.87 56.94,128.83 56.94,127.79 56.94,127.78 56.94,124.99 57.32,124.61 57.32,124.23 57.2,124.1 56.43,124.1 56.31,124.23 56.31,127.56 55.18,128.68 55.18,128.9 55.32,129.03 55.55,129.03
+TS_PWR on TOP (solid shape): 71.93,192.3 71.93,192.05 72.18,191.79 72.18,191.16 71.93,190.9 71.29,190.9 71.17,191.03 71.17,191.41 70.69,191.89 70.69,192.45 70.77,192.53 71.7,192.53
+TS_PWR on BOTTOM (solid shape): 71.3,193.32 71.3,192.51 71.5,192.51 71.5,193.32 71.52,193.34 71.78,193.34 71.8,193.32 71.8,192.41 71.88,192.34 71.88,191.26 71.52,190.9 70.28,190.9 70.02,191.16 70.02,191.37 70.3,191.64 70.34,191.71 70.36,191.79 70.36,191.85 70.89,192.38 71,192.49 71,193.32 71.03,193.35 71.28,193.35
+USBPWR0 on BOTTOM (solid shape): outline of 113 points within 14.96,88.77 20.37,94.03
+USBPWR1 on TOP (solid shape): 18.46,111.27 18.46,109.5 18.21,109.24 17.44,109.24 16.64,110.05 15.45,110.05 14.97,110.53 14.97,111.21 15.16,111.4 18.33,111.4
+USBPWR1 on TOP (solid shape): 23.67,96.54 23.67,94.18 23.55,94.07 21.24,94.07 20.41,94.89 20.19,94.89 20.06,95.02 20.06,95.73 20.21,95.88 21.8,95.88 22.1,96.18 23.04,96.18 23.46,96.6 23.61,96.6
+USBPWR1 on BOTTOM (solid shape): 23.67,96.03 23.67,94.76 23.54,94.64 22.4,94.64 22.16,94.88 22.15,94.92 22.14,94.95 22.14,95.27 21.76,95.65 20.37,95.65 20.24,95.78 20.24,97.3 20.37,97.43 22.27,97.43
+USBPWR1 on BOTTOM (solid shape): outline of 202 points within 17.06,103.4 28.49,110.39
+USBPWR1 on IN4 (solid shape): outline of 345 points within 22.3,94.64 30.27,104.8
+USBPWRD2 on BOTTOM (solid shape): 221.62,106.73 221.62,105.23 221.5,105.12 221.1,105.12 220.89,104.92 220.89,103.77 220.56,103.44 218.65,103.44 218.36,103.73 218.36,105.26 218.51,105.41 218.51,106.76 218.56,106.81 221.53,106.81
+USBPWRD2 on BOTTOM (solid shape): 229.66,125.12 229.66,124.81 228.4,124.81 228.4,124.61 229.66,124.61 229.66,124.31 228.4,124.31 228.4,124.11 229.66,124.11 229.66,123.81 228.4,123.81 228.4,123.61 229.66,123.61 229.66,123.47 229.54,123.34 229.05,123.34 229.01,123.34 226.87,123.34 226.74,123.47 226.74,124.99 226.99,125.24 229.53,125.24
+USBPWRD2 on BOTTOM (solid shape): 212.94,114.41 212.94,111.63 212.84,111.53 212.84,110.2 212.64,110 211.12,110 210.74,110.39 210.74,112.54 210.8,112.6 210.8,112.88 212.3,112.88 212.3,113.71 212.1,113.71 212.1,112.88 211.8,112.88 211.8,113.71 211.6,113.71 211.6,112.88 211.3,112.88 211.3,113.71 211.1,113.71 211.1,112.88 210.8,112.88 210.8,114.31 211.02,114.53 211.02,114.73 211.12,114.83 212.52,114.83
+USBPWRD2 on IN3 (solid shape): outline of 1812 points within 210.61,103.49 230.73,125.45
+VAC_IN on TOP (solid shape): 14.52,198.93 14.52,196.6 15,196.13 15.49,196.13 15.73,195.89 15.73,193.9 15.34,193.51 13.77,193.51 12.01,195.28 12.01,197.28 11.17,198.12 10.18,198.12 9.72,198.57 9.72,199.64 10.36,200.28 13.18,200.28
+VAC_IN on TOP (solid shape): 57.63,201.8 57.63,200.73 57.83,200.53 61.51,200.53 61.72,200.33 61.72,197.46 61.65,197.34 61.63,197.2 61.63,197.13 61.65,197.05 61.67,197.02 60.17,195.53 57.22,195.53 57,195.75 57,196.06 56.99,196.1 56.99,197.2 56.32,197.88 56.32,198.56 56.46,198.7 56.46,201.95 56.59,202.08 57.35,202.08
+VAC_IN on SVCC (solid shape): 8.63,208.2 11.1,210.67 13.57,208.2 13.57,204.94 13.96,202.99 15.08,201.34 19.13,197.38 20.75,196.32 22.65,195.95 35.7,195.95 38.55,197.13 39.73,199.98 39.73,200.77 53.1,200.77 54.89,201.51 55.63,203.3 55.63,205.72 62.78,205.72 62.78,196.43 62.51,196.15 62.39,196.23 62.25,196.25 61.98,196.14 61.87,195.87 61.9,195.73 61.97,195.61 61.45,195.09 60.47,195.09 60.33,195.31 60.09,195.4 59.85,195.31 59.72,195.09 59.45,195.09 59.31,195.27 59.1,195.33 58.89,195.27 58.75,195.09 52.62,195.09 52.33,195.04 52.08,194.87 48.24,191.03 39.73,191.03 39.43,190.97 39.19,190.8 38.74,190.36 34.8,190.36 34.7,190.46 34.7,190.89 34.69,190.92 34.67,190.94 34.33,191.29 34.31,191.3 34.28,191.31 20.76,191.31 20.74,191.3 20.71,191.29 19.47,190.04 14.43,190.04 14.43,191.7 13.78,193.28 12.2,193.93 10.65,193.93 11.49,195.39 11.23,197.05 11.23,200.85 10.89,203.74 8.05,204.4 7.96,204.44 7.86,204.47 7.77,204.5 8.41,205.68 8.63,207
+VAC_IN on IN4 (solid shape): outline of 1152 points within 9.9,187.86 62.78,201.99
+VCONN_5V_3 on BOTTOM (solid shape): 24.43,45.36 24.43,44.47 24.1,44.14 24.08,44.15 24.05,44.15 23.35,44.15 22.91,44.6 22.91,45.62 23.03,45.74 24.05,45.74
+VCONN_5V_3 on IN2 (solid shape): outline of 212 points within 19.86,44.85 24.3,49.17
+VGPU_CORE on TOP (solid shape): 113.91,215.97 113.94,215.9 113.9,215.82 112.8,214.4 112.4,212.65 113.11,210.34 115,208.83 115,204.74 114.39,204.13 114.37,204.13 114.18,204.04 114.05,203.86 114.03,203.83 112.58,203.83 112.27,203.52 112.27,202.52 112.45,202.34 112.63,202.34 112.87,202.1 112.87,200.99 112.76,200.89 109.22,200.89 107.33,202.78 107.3,202.78 107.25,202.82 107.18,202.83 106.49,202.83 106.07,203.26 106.07,204.13 106.89,204.95 106.89,206.93 104.81,209.01 104.81,210.94 106.89,213.02 106.89,213.31 110.41,216.84 110.72,216.84 111.02,217.14 112.74,217.14
+VGPU_CORE on TOP (solid shape): outline of 2006 points within 124.86,189.25 136.93,209.57
+VGPU_CORE on BOTTOM (solid shape): 112.95,216.79 112.95,214.69 112.94,214.68 112.54,213.7 112.4,212.65 112.54,211.6 112.94,210.62 112.95,210.61 112.95,210.21 113.79,209.37 113.79,206.35 114.16,205.98 114.48,205.98 114.71,205.75 114.71,204.84 113.79,203.92 113.79,201.57 112.92,200.71 109.01,200.71 108.2,201.52 108.2,208.02 106.04,210.18 106.04,210.41 110.35,214.72 110.35,214.85 110.35,214.86 110.35,215.22 110.35,215.23 110.35,216.34 111.16,217.16 112.58,217.16
+VGPU_CORE on BOTTOM (solid shape): outline of 570 points within 130.4,204.36 142.08,217.47
+VGPU_CORE on SVCC (solid shape): 140.76,213.41 140.67,213.28 140.64,213.13 140.67,212.98 140.76,212.85 140.76,209.11 140.7,209 140.68,208.87 140.7,208.75 140.76,208.63 140.76,206.88 136.26,202.39 136.21,202.3 136.19,202.21 136.19,202.13 136.08,202.01 136.04,201.85 136.08,201.69 136.19,201.56 136.19,199.6 136.09,199.48 136.06,199.33 136.09,199.18 136.19,199.05 136.19,192.93 136.09,192.81 136.06,192.65 136.09,192.5 136.19,192.38 136.19,188.85 135.07,187.73 133.68,187.73 133.55,187.91 133.34,187.98 133.13,187.91 133,187.73 126.9,187.73 124.31,190.31 124.22,190.5 124.03,190.6 117.36,197.27 117.38,197.35 117.39,197.44 117.28,197.71 117.01,197.82 116.93,197.81 116.85,197.78 116.3,198.32 116.22,198.38 116.12,198.4 111.4,198.4 104.95,204.85 104.95,211.37 111.04,217.47 140.76,217.47
+VGPU_CORE on IN2 (solid shape): outline of 6729 points within 105.08,188.21 140.64,217.44
+VGPU_CORE on IN3 (solid shape): outline of 2720 points within 125.04,190.11 135.36,206.8
+VGPU_CORE on IN4 (solid shape): outline of 4540 points within 125.72,189.04 144.44,217.47
+VREF06_RT3612 on TOP (solid shape): 164.4,147.41 164.4,143.84 164.24,143.68 163.82,143.68 163.55,143.41 163.55,142.82 163.48,142.76 162.85,142.76 162.84,142.8 162.72,143.05 162.46,143.15 162.19,143.04 162.08,142.77 162.11,142.64 162.18,142.52 161.86,142.2 159.49,142.2 159,142.69 159,143.07 159.02,143.1 161.36,143.1 161.72,143.46 161.72,144.01 161.49,144.24 161.49,144.47 161.74,144.73 161.97,144.73 162.4,144.29 163.49,144.29 163.77,144.57 163.77,147.11 164.13,147.47 164.33,147.47
ADOGND on TOP (solid shape): 19.34,27.9 19.34,27.86 19.13,27.65 19.13,27.01 19.26,26.88 19.26,24.66 19.22,24.58 19.13,24.56 19.01,24.59 18.88,24.6 18.51,24.6 18.46,24.6 18.39,24.63 18.36,24.7 18.36,24.74 18.36,24.76 18.4,24.83 18.41,24.91 18.41,27.24 19.12,27.95 19.29,27.95
ADOGND on TOP (solid shape): outline of 488 points within 1.51,14.81 23.97,30.13
ADOGND on TOP (solid shape): outline of 538 points within 10.94,24.66 24.05,39.01
ADOGND on BOTTOM (solid shape): 5.94,29.84 5.97,29.69 6,29.55 6,28.72 5.18,27.9 5.07,27.88 5.01,27.97 5.01,29.25 5.01,29.62 5.23,29.84
ADOGND on BOTTOM (solid shape): 9.84,30.12 9.87,29.73 10.08,29.39 10.08,28.72 9.95,28.6 8.3,28.6 8.05,28.34 7.67,28.34 7.54,28.47 7.54,28.72 7.65,28.83 7.65,29.13 7.72,29.2 7.72,29.94 7.71,29.95 7.69,30.06 7.78,30.12
ADOGND on BOTTOM (solid shape): 17.71,29.7 17.71,28.81 17.74,28.74 17.81,28.71 18.17,28.71 18.26,28.65 18.24,28.54 17.78,28.08 17.72,28.02 17.72,27.7 17.65,27.7 16.93,26.97 16.93,26.7 16.9,26.63 16.87,26.57 16.87,26.55 15.88,25.57 15.88,25.39 15.35,24.86 15.19,24.86 15.12,24.83 15.09,24.76 15.09,24.66 14.9,24.66 14.65,24.91 14.65,25.68 14.78,25.8 15.92,25.8 16.15,26.03 16.15,26.77 16.31,26.93 16.31,27.74 16.41,27.84 16.41,28.58 16.67,28.84 16.91,29.08 16.91,30 17.4,30
ADOGND on BOTTOM (solid shape): outline of 393 points within 4.62,14.35 24.05,28.71
ADOGND on SGND (solid shape): outline of 142 points within 1.51,14.35 24.05,39.01
ADOGND on IN1 (solid shape): 13.42,39.01 13.51,38.92 13.63,38.88 16.05,38.88 16.15,38.9 16.23,38.96 16.28,39.01 16.96,39.01 17.52,38.45 17.6,38.4 17.7,38.38 18.23,38.38 18.97,37.64 18.97,36.98 19,36.85 19.1,36.76 19.1,35.13 18.92,34.95 18.26,34.95 18.21,35 18.21,35.94 18.2,35.99 18.17,36.03 17.32,36.88 17.32,36.98 17.31,37.03 17.28,37.07 17.18,37.17 17.19,37.23 17.17,37.33 17.12,37.41 16.86,37.67 16.78,37.72 16.68,37.74 14.78,37.74 14.68,37.72 14.6,37.67 14.22,37.29 14.16,37.2 14.14,37.11 14.14,34.31 14.02,34.19 13.51,34.19 13.38,34.31 13.38,36.98 13.36,37.08 13.31,37.16 13.05,37.41 12.97,37.47 12.87,37.49 12.81,37.48 12.75,37.54 12.75,38.83 12.93,39.01
ADOGND on IN1 (solid shape): outline of 142 points within 1.51,14.35 14.17,29.87
ADOGND on SVCC (solid shape): outline of 137 points within 4.08,14.35 24.05,39.01
ADOGND on IN2 (solid shape): outline of 1496 points within 1.51,14.35 24.05,39.01
ADOGND on IN3 (solid shape): outline of 163 points within 17.06,24.34 24.05,30.12
ADOGND on IN3 (solid shape): 5.93,29.87 6,29.56 6.02,29.25 6.02,27.84 6.78,27.08 6.78,27.07 12.11,27.07 13.07,26.11 14.14,24.69 13.67,22.98 13.67,19.54 14.07,18.84 14.17,18.03 13.68,17.55 12.91,17.55 13.15,18.37 12.66,19.08 12.66,23.44 13.12,24.57 12.15,25.32 10.32,25.32 10.27,25.34 10.23,25.38 10.26,25.49 10.27,25.61 10.09,26.05 9.65,26.23 8.89,26.23 8.45,26.05 8.27,25.61 8.28,25.49 8.31,25.38 8.27,25.34 8.22,25.32 6.32,25.32 6.27,25.34 6.23,25.38 6.26,25.49 6.27,25.61 6.09,26.05 5.65,26.23 4.89,26.23 4.45,26.05 4.27,25.61 4.28,25.49 4.31,25.38 4.27,25.34 4.22,25.32 3.32,25.32 3.27,25.34 3.23,25.38 3.26,25.49 3.27,25.61 3.09,26.05 2.65,26.23 1.89,26.23 1.73,26.21 1.58,26.15 1.53,26.19 1.51,26.25 1.51,26.64 4,26.64 4.71,26.94 5.01,27.65 5.01,29.25 4.99,29.44 4.94,29.63 5.18,29.87
ADOGND on SGND1 (solid shape): outline of 142 points within 1.51,14.35 24.05,39.01
ADOGND on IN4 (solid shape): outline of 1314 points within 1.51,14.35 24.05,39.01
ADOGND on SGND2 (solid shape): outline of 142 points within 1.51,14.35 24.05,39.01
BAT-V on TOP (solid shape): outline of 2248 points within 105.24,94.33 138.98,117.01
BAT-V on BOTTOM (solid shape): 139.11,114.93 139.11,113.89 139.97,113.03 139.97,112.4 139.35,112.4 138.81,112.95 137.33,112.95 137.1,113.18 135.81,113.18 135.68,113.31 135.68,114.45 136.33,115.1 136.33,115.55 136.69,115.91 138.13,115.91
BAT-V on BOTTOM (solid shape): 103.09,103.1 103.09,102.08 103.68,101.5 107.85,101.5 108.03,101.32 108.03,98.97 107.76,98.7 100.38,98.7 99.89,99.18 99.89,101.62 100.2,101.62 100.2,101.57 100.21,101.51 100.23,101.46 100.26,101.41 100.29,101.37 100.33,101.33 100.38,101.3 100.43,101.27 100.48,101.25 100.54,101.24 100.59,101.24 100.65,101.25 100.7,101.26 100.75,101.28 100.8,101.31 100.84,101.35 100.88,101.39 100.91,101.44 100.94,101.49 100.95,101.54 100.96,101.59 100.96,101.65 100.95,101.71 100.94,101.76 100.91,101.81 100.88,101.86 100.84,101.9 100.8,101.93 100.75,101.96 100.7,101.98 100.65,102 100.59,102 100.54,102 100.48,101.99 100.43,101.97 100.38,101.95 100.33,101.92 100.29,101.88 100.26,101.83 100.23,101.78 100.21,101.73 100.2,101.68 100.2,101.62 99.89,101.62 99.89,103.65 102.53,103.65
CRT_VCC_R on TOP (solid shape): 18.29,150.05 18.29,149.13 18.2,149.04 17.3,149.04 16.83,148.57 14.14,148.57 14.08,148.64 14.08,149.41 14.89,150.22 18.12,150.22
CRT_VCC_R on TOP (solid shape): 27.39,157.84 27.39,156.52 28.27,155.65 28.67,155.65 29.12,155.2 29.12,153.98 28.3,153.98 28.14,154.13 28.14,154.89 26.82,156.21 26.23,156.21 26.08,156.36 26.08,157.88 27.35,157.88
CRT_VCC_R on BOTTOM (solid shape): 11.35,159.92 11.35,157.5 11.09,157.25 9.95,157.25 8.76,158.44 6.54,158.44 6.36,158.63 6.36,159.23 6.59,159.46 6.66,159.46 6.78,159.43 6.9,159.41 7.02,159.43 7.13,159.46 7.23,159.36 8.86,159.36 9.55,160.04 11.22,160.04
CRT_VCC_R on IN1 (solid shape): 27.35,157.88 27.35,155.98 27.12,155.75 26.54,155.75 26.33,155.95 26.33,158.11 27.13,158.11
CRT_VCC_R on IN1 (solid shape): 16.11,150.11 17.24,150.11 17.59,149.76 17.59,148.92 17.32,148.64 16.12,148.64 16.11,148.63 14.81,148.63 14.63,148.81 14.63,149.08 14.64,149.09 14.64,149.72 15.16,150.24 15.98,150.24
CRT_VCC_R on IN1 (solid shape): 11.35,158.09 11.35,157.41 11.44,157.32 11.47,157.24 11.44,157.17 11.36,157.06 11.33,156.92 11.42,156.68 11.69,156.54 11.7,156.51 11.7,155.71 11.6,155.61 9.66,155.61 9.47,155.8 9.44,155.88 9.49,155.96 9.61,156.09 9.65,156.26 9.55,156.51 9.3,156.62 9.26,156.63 9.24,156.67 9.24,158.14 9.44,158.34 11.09,158.34
FB_CAL_PD_VDDQ on TOP (solid shape): 145.87,182.08 146.06,182.08 146.07,182.07 146.69,182.07 146.85,181.91 146.85,181.58 146.56,181.3 145.92,181.3 145.24,181.98 145.24,182.21 145.35,182.32 145.62,182.32
FBA_VREFC_1 on TOP (solid shape): 159.77,188.57 159.8,188.54 159.8,187.37 159.77,187.34 159.77,187.04 159.93,186.89 160.02,186.8 160.05,186.67 159.98,186.49 159.8,186.42 159.68,186.42 159.27,186.83 159.27,187.45 159.27,187.5 159.29,187.56 159.29,188.33 159.27,188.36 159.27,189.18 159.08,189.36 158.69,189.36 158.48,189.41 158.39,189.61 158.39,190.09 159.04,190.75 159.77,190.75
FBA_VREFC_1 on BOTTOM (solid shape): 159.85,186.87 159.85,186.45 159.91,186.39 159.91,185.92 159.79,185.79 159.69,185.66 159.63,185.5 159.56,185.43 159.56,183.11 159.48,183.04 159.33,183.04 159.21,183.16 159.21,183.76 159.01,183.96 159.01,185.93 159.26,186.18 159.34,186.28 159.4,186.39 159.47,186.45 159.47,186.89 159.53,186.91 159.8,186.91
FBA_VREFC_2 on TOP (solid shape): 159.98,195 160.06,194.82 160.04,194.73 159.98,194.64 159.28,193.94 159.28,192.76 159.42,192.76 159.45,192.78 159.77,192.78 159.77,193.8 160.03,194.05 160.28,193.8 160.28,192.27 159.66,192.27 159.63,192.25 159.28,192.25 159.28,191.54 159.03,191.28 158.78,191.54 158.78,194.16 159.62,195 159.71,195.06 159.8,195.08
G5335-AGND-2 on TOP (solid shape): 170.21,157.13 170.21,155.82 170.16,155.72 170.15,155.61 170.17,155.48 170.23,155.37 170.23,153.6 170.11,153.48 170.11,152.79 168.8,152.79 168.61,152.97 168.61,153.39 168.41,153.59 168.41,153.88 168.52,154 168.77,154 168.84,153.98 168.9,153.98 169.16,154.07 169.3,154.31 169.3,154.33 169.31,154.34 169.31,156.91 169.69,157.29 170.05,157.29 170.05,157.29
G5335-AGND-2 on BOTTOM (solid shape): 169.21,153.46 169.21,152.86 169.13,152.78 168.76,152.78 168.69,152.85 168.69,153.24 168.68,153.29 168.67,153.37 168.64,153.39 168.61,153.43 168.18,153.86 168.14,153.9 168,154.03 167.92,154.03 167.92,154.04 167.13,154.04 167.13,154.29 167.92,154.29 167.92,154.29 168.16,154.29 168.16,154.29 168.38,154.29
G5335-LX-2 on BOTTOM (solid shape): 165,160.64 165,159.6 164.27,158.86 164.27,157.79 163.96,157.48 163.96,157.1 164.24,156.82 164.39,156.82 164.4,156.8 164.4,156.02 164.4,155.81 164.5,155.71 165.13,155.71 165.13,153.16 164.9,152.93 164.9,152.03 164.65,152.03 164.65,152.81 164.4,152.81 164.4,152.03 164.15,152.03 164.15,153.04 164.22,153.11 164.22,154.75 163.94,155.04 163.15,155.04 162.9,155.29 163.92,155.29 163.92,155.54 163.13,155.54 163.13,155.29 162.9,155.29 160.12,158.07 160.12,158.09 159.36,158.85 159.34,158.85 158.78,159.41 158.78,160.65 159.18,161.05 164.6,161.05
G5335-VCC-2 on BOTTOM (solid shape): 167.69,159.92 167.69,159.02 167.67,158.95 167.66,158.87 167.67,158.8 167.69,158.73 167.69,157.88 167.56,157.76 167.18,157.76 167.05,157.88 167.05,159.92 167.18,160.04 167.56,160.04
G5719LX1.5V on BOTTOM (solid shape): 10.64,34.93 10.64,34.05 10.55,33.96 9.91,33.96 9.65,33.71 9.05,33.1 6.85,33.1 6.78,33.17 6.78,33.68 6.9,33.8 8.05,33.8 8.29,34.04 8.29,34.93 8.41,35.05 10.52,35.05
G5719LX2.5V on BOTTOM (solid shape): 76.12,187.6 76.12,185.44 75.86,185.19 73.38,185.19 73.22,185.35 73.22,185.83 73.32,185.92 74.57,185.92 74.59,185.95 74.59,187.35 74.98,187.73 75.99,187.73
HP-L2 on BOTTOM (solid shape): 15.92,23.26 15.92,22.88 16.3,22.5 17.19,22.5 17.44,22.25 17.44,21.49 17.32,21.36 16.05,21.36 15.92,21.49 15.92,21.87 15.79,21.99 15.16,21.99 15.03,22.12 15.03,23.14 15.29,23.39 15.79,23.39
HP-L3 on BOTTOM (solid shape): 15.67,21.61 15.67,19.45 15.54,19.33 14.9,19.33 14.78,19.45 14.78,19.58 14.9,19.71 15.03,19.71 15.16,19.83 15.16,21.61 15.29,21.74 15.54,21.74
HP-R2 on BOTTOM (solid shape): 18.21,23.64 18.21,23.14 18.46,22.88 19.1,22.88 19.22,22.76 19.22,22.5 18.97,22.25 17.95,22.25 17.83,22.37 17.83,22.88 17.19,23.52 16.81,23.52 16.68,23.64 16.68,24.03 16.81,24.15 17.7,24.15
HP-R3 on BOTTOM (solid shape): 10.97,28.22 10.97,28.09 10.71,27.84 9.32,27.84 8.81,27.33 8.48,27.33 8.33,27.48 8.33,27.99 8.68,28.34 10.84,28.34
ISEN2N on BOTTOM (solid shape): 160.57,141.75 160.57,140.61 160.45,140.48 160.19,140.48 160.03,140.64 159.97,140.72 159.89,140.78 159.81,140.87 159.43,140.87 159.3,140.74 159.3,140.58 159.28,140.5 159.28,140.43 159.28,140.4 159.28,140.36 159.28,140.29 159.3,140.21 159.3,140.1 159.18,139.98 158.92,139.98 158.8,140.1 158.8,141.46 158.84,141.5 158.86,141.55 158.86,141.56 159.05,141.75 159.68,141.75 159.81,141.88 160.45,141.88
L_SPK+ on TOP (solid shape): 41.03,94 41.03,92.97 40.81,92.75 40.5,92.75 40.08,93.17 39.19,93.17 39.02,93.35 39.02,93.98 39.16,94.13 40.9,94.13
L_SPK+ on BOTTOM (solid shape): 20.05,37.63 20.05,36.74 20.01,36.7 20.01,35.01 20.01,35.01 19.82,35.01 19.81,35.02 19.81,36.49 19.56,36.74 19.56,37.64 19.67,37.75 19.93,37.75
L_SPK+ on IN4 (solid shape): 40.18,94.13 40.95,94.13 41.08,94 41.08,93.77 41.06,93.75 41.06,93.49 40.94,93.37 38.75,93.37 38.42,93.69 38.42,94.38 38.55,94.51 39.8,94.51
L_SPK+ on IN4 (solid shape): 20.32,40.41 20.32,38.19 20.08,37.95 20.08,36.75 19.93,36.59 19.61,36.59 19.52,36.69 19.52,37.85 18.88,38.48 18.88,38.8 18.92,38.88 19.01,38.89 19.05,38.89 19.1,38.88 19.45,39.24 19.1,39.6 19.05,39.59 19.01,39.59 18.92,39.6 18.88,39.68 18.88,40.06 19.59,40.76 19.96,40.76
L_SPK+_1 on TOP (solid shape): 38.87,92.87 39.82,92.87 40.14,92.55 40.14,91.79 38.3,91.79 37.67,92.42 37.67,93.07 37.75,93.15 38.59,93.15
L_SPK+_1 on TOP (solid shape): 42.92,101.57 42.92,100.89 42.77,100.58 42.92,100.27 42.92,100.15 42.71,99.94 41.91,99.94 41.73,100.13 41.73,101.17 41.73,101.41 41.64,101.49 41.64,101.76 41.82,101.94 42.55,101.94
L_SPK+_1 on BOTTOM (solid shape): 82.52,198.7 82.52,196.41 82.37,196.26 81.5,196.26 81.35,196.41 81.35,198.7 81.55,198.9 82.32,198.9
L_SPK+_1 on IN4 (solid shape): 82.52,197.51 82.52,196.41 82.37,196.26 81.5,196.26 81.35,196.41 81.35,197.63 81.48,197.76 82.27,197.76
L_SPK+_1 on IN4 (solid shape): 42.79,102.16 42.79,101.62 42.72,101.54 41.7,101.54 41.66,101.58 41.66,101.86 41.62,101.91 40.93,102.59 40.93,102.75 41.39,103.21 41.74,103.21
L_SPK+_1_VIKI on TOP (solid shape): 42.08,96.38 42.08,95.94 42.01,95.88 41.93,95.88 41.08,95.03 41.08,94.64 41,94.56 39.08,94.56 39.07,94.57 39.07,95.3 39.38,95.61 40.77,95.61 40.81,95.65 40.94,95.65 41.76,96.47 41.99,96.47
L_SPK+_1_VIKI on BOTTOM (solid shape): 39.99,98.48 39.99,96.62 41.08,95.53 41.08,94.67 40.96,94.56 39.81,94.56 39.12,95.25 39.12,96.52 39.22,96.62 39.22,98.45 39.27,98.5 39.97,98.5
L_SPK- on TOP (solid shape): 43.36,94.05 43.36,93.27 43.27,93.19 41.45,93.19 41.34,93.31 41.34,94.15 41.37,94.18 43.23,94.18
L_SPK- on BOTTOM (solid shape): 21.46,40.12 21.46,38.38 20.8,37.71 20.77,37.69 20.74,37.66 20.67,37.58 20.67,37.49 20.67,37.38 20.67,36.47 20.41,36.21 20.41,35.02 20.41,35.01 20.24,35.01 20.21,35.04 20.21,36 20.21,36.32 20.14,36.39 20.14,36.68 20.16,36.7 20.16,36.78 20.16,36.85 20.16,36.92 20.16,37.44 20.16,37.51 20.16,37.58 20.16,37.89 20.53,38.26 20.53,40.06 20.75,40.28 20.75,40.29 21.29,40.29
L_SPK- on IN4 (solid shape): 22.38,40.69 22.38,39.99 21.01,38.63 20.75,38.63 20.62,38.76 20.62,39.94 21.68,41 22.06,41
L_SPK- on IN4 (solid shape): 43.28,94.07 43.28,93.11 42.51,92.34 42.07,92.34 41.4,93.02 41.4,93.6 41.41,93.61 41.41,94.1 41.45,94.15 43.21,94.15
L_SPK-_1 on TOP (solid shape): 42.9,92.6 42.9,91.9 41.58,90.57 40.16,90.57 40.16,91.32 41.59,92.75 42.76,92.75
L_SPK-_1 on TOP (solid shape): 41.32,101.83 41.32,101.38 41.42,101.29 41.42,99.76 41.32,99.66 40.46,99.66 40.46,99.67 40.4,99.73 40.4,101.01 40.19,101.22 40.19,101.61 40.2,101.66 40.2,101.7 40.2,101.91 40.27,101.97 41.17,101.97
L_SPK-_1 on BOTTOM (solid shape): 84.02,198.75 84.02,196.47 83.87,196.31 83,196.31 82.85,196.47 82.85,198.75 83.05,198.95 83.82,198.95
L_SPK-_1 on IN4 (solid shape): 84.02,197.76 84.02,196.47 83.87,196.31 83,196.31 82.85,196.47 82.85,198.07 82.93,198.14 83.64,198.14
L_SPK-_1 on IN4 (solid shape): 40.55,102.54 40.99,102.1 41.31,101.78 41.31,101.49 41.19,101.37 40.3,101.37 39.08,102.6 39.08,102.63 39.74,103.29 39.8,103.29
L_SPK-_1_VIKI on TOP (solid shape): 43.86,96.29 43.86,95.52 43.38,95.03 43.38,94.62 43.32,94.56 41.32,94.56 41.26,94.63 41.26,94.76 41.27,94.8 41.26,94.84 41.25,94.9 41.85,95.49 42.7,95.49 43.1,95.9 43.1,96.29 43.23,96.42 43.73,96.42
L_SPK-_1_VIKI on BOTTOM (solid shape): 41.25,98.47 41.25,96.61 41.36,96.5 41.55,96.5 42.67,95.38 43.13,95.38 43.38,95.13 43.38,94.68 43.23,94.52 41.41,94.52 41.27,94.67 41.27,95.56 40.47,96.36 40.47,98.48 40.5,98.52 41.2,98.52
MEM_VREF_CTL_QA on TOP (solid shape): 160.62,192.53 160.81,192.72 161,192.53 161,191.62 161.01,191.61 161.01,191.18 160.95,191.13 160.95,190.85 161.12,190.69 161.51,190.69 161.7,190.5 161.51,190.3 160.11,190.3 160.11,191.19 160.32,191.4 160.32,191.41 160.62,191.71
PVADPTR on TOP (solid shape): 43.2,120.88 43.2,118.87 42.18,117.85 42.18,116.09 42.73,115.55 42.73,114.17 42.63,114.07 39.41,114.07 39.29,114.2 39.29,115.47 39.04,115.71 39.04,117.63 39.05,117.64 39.05,120 39.1,120 39.21,120.04 39.25,120.15 39.25,120.53 39.23,120.61 39.18,120.66 39.13,120.74 39.16,120.82 39.49,121.15 42.92,121.15
PVADPTR on TOP (solid shape): outline of 267 points within 55.8,188.62 68.55,200.53
R_SPK+ on TOP (solid shape): 49.29,94.37 49.29,93.52 49.15,93.38 48.31,93.38 48.01,93.09 47.55,93.09 47.19,93.44 47.19,94.24 47.42,94.46 49.2,94.46
R_SPK+ on BOTTOM (solid shape): 21.91,37.72 21.91,36.81 21.21,36.11 21.21,35.02 21.2,35.01 21.04,35.01 21.01,35.04 21.01,36 21.01,36.19 21.41,36.59 21.41,36.75 21.41,36.79 21.41,37.73 21.55,37.86 21.77,37.86
R_SPK+ on IN4 (solid shape): 48.31,93.75 48.31,92.83 48.1,92.62 47.25,92.62 47.06,92.81 47.06,93.78 47.16,93.88 48.18,93.88
R_SPK+ on IN4 (solid shape): 22.78,37.9 22.91,37.89 23.04,37.89 23.14,37.79 23.14,36.83 22.7,36.38 21.58,36.38 21.4,36.56 21.4,37.65 21.68,37.93 22.64,37.93
R_SPK+_1 on TOP (solid shape): 42.57,106.94 42.63,106.8 42.72,106.68 42.98,106.42 42.98,105.83 42.74,105.58 42.74,105.32 42.72,105.3 42.72,105.12 42.71,105.12 42.71,104.6 42.7,104.59 41.77,104.59 41.73,104.63 41.73,106.58 42.12,106.97 42.55,106.97
R_SPK+_1 on TOP (solid shape): 50.71,94.53 50.71,92.72 49.96,91.97 48.65,91.97 48.4,92.22 48.4,92.93 48.52,93.05 49.39,93.05 49.57,93.23 49.57,93.25 49.69,93.37 49.69,94.11 49.69,94.11 49.69,94.65 49.82,94.78 50.47,94.78
R_SPK+_1 on BOTTOM (solid shape): 88.49,198.75 88.49,196.47 88.34,196.31 87.47,196.31 87.32,196.47 87.32,198.75 87.52,198.95 88.29,198.95
R_SPK+_1 on IN3 (solid shape): 42.95,106.69 42.95,106.34 42.74,106.13 41.95,106.13 40.93,107.15 40.93,107.61 41.4,108.08 41.56,108.08
R_SPK+_1 on IN3 (solid shape): 88.51,196.82 88.51,195.42 87.29,194.21 86.91,194.21 86.53,194.59 86.53,195.04 87.29,195.81 87.29,196.75 87.47,196.92 88.41,196.92
R_SPK+_1_VIKI on TOP (solid shape): 49.27,95.83 49.27,94.89 49.22,94.84 47.56,94.84 46.14,96.26 46.14,96.95 46.68,97.49 47.61,97.49
R_SPK+_1_VIKI on BOTTOM (solid shape): 44.67,97.83 47.33,97.83 47.68,97.48 47.68,96.73 47.51,96.56 44.18,96.56 44.12,96.62 43.09,96.62 42.98,96.73 42.98,98.46 43.05,98.53 43.97,98.53
R_SPK- on TOP (solid shape): 45.75,94.14 45.75,93.28 45.7,93.23 44.77,93.23 44.34,92.8 43.84,92.8 43.55,93.09 43.55,93.89 43.82,94.16 45.73,94.16
R_SPK- on BOTTOM (solid shape): 21.28,37.59 21.28,36.63 20.81,36.17 20.81,35.01 20.63,35.01 20.61,35.03 20.61,36 20.61,36.25 20.8,36.44 20.8,37.55 20.92,37.67 21.19,37.67
R_SPK- on IN4 (solid shape): 44.74,94.02 44.74,92.53 44.32,92.11 44,92.11 43.61,92.5 43.61,94.05 43.74,94.18 44.59,94.18
R_SPK- on IN4 (solid shape): 23.04,38.99 23.04,38.18 22.76,38.18 22.55,38.15 22.35,38.06 21.67,38.06 21.56,37.96 21.55,37.95 21.41,37.87 21.32,37.72 21.32,37.71 21.3,37.69 21.3,36.6 21.18,36.47 20.9,36.47 20.76,36.61 20.76,37.91 21.95,39.09 22.94,39.09
R_SPK-_1 on TOP (solid shape): 47.07,91.51 47.07,90.8 45.7,90.8 44.83,91.67 44.83,92.69 44.94,92.8 45.78,92.8
R_SPK-_1 on TOP (solid shape): 43.7,105.56 43.78,105.56 43.95,105.56 44.21,105.29 44.21,103.76 44.09,103.64 43.35,103.64 43.03,103.96 43.03,105.17 43.43,105.58 43.62,105.58
R_SPK-_1 on BOTTOM (solid shape): 87.02,198.75 87.02,196.47 86.86,196.31 86,196.31 85.85,196.47 85.85,198.75 86.05,198.95 86.81,198.95
R_SPK-_1 on IN3 (solid shape): 44.07,105.47 44.07,105.27 43.42,104.62 41.85,104.62 41.79,104.68 41.79,105.56 41.9,105.67 43.87,105.67
R_SPK-_1 on IN3 (solid shape): 86.99,196.82 86.99,195.93 85.97,194.92 84.81,194.92 84.58,195.14 84.58,195.78 84.91,196.11 85.52,196.11 85.82,196.41 85.82,196.85 85.9,196.92 86.89,196.92
R_SPK-_1_VIKI on TOP (solid shape): 44.78,96.4 44.78,96.08 45.41,95.45 46.4,95.45 46.63,95.22 46.63,94.79 46.38,94.54 43.65,94.54 43.59,94.6 43.59,94.98 44.14,95.54 44.14,96.29 44.3,96.46 44.73,96.46
R_SPK-_1_VIKI on BOTTOM (solid shape): 42.49,98.45 42.49,96.64 42.67,96.46 44.05,96.46 44.68,95.83 44.68,94.67 44.56,94.55 43.7,94.55 43.55,94.69 43.55,95.37 43.39,95.54 42.74,95.54 41.72,96.56 41.72,98.47 41.76,98.52 42.43,98.52
RING2 on TOP (solid shape): 21.36,27.91 21.36,25.75 20.82,25.22 20.16,25.22 20.14,25.24 20.14,25.52 20.59,25.98 20.59,27.86 20.75,28.01 21.25,28.01
RING2 on BOTTOM (solid shape): 7.34,29.79 7.34,29.36 7.27,29.29 7.27,28.24 7.41,28.09 7.55,28.09 7.71,27.94 7.71,27.72 7.51,27.52 6.29,27.52 5.08,26.31 4.98,26.31 4.93,26.26 4.89,26.26 4.43,26.07 4.24,25.61 4.24,25.55 4.25,25.48 4.15,25.38 1.9,25.38 1.76,25.52 1.76,26.43 1.82,26.49 4.31,26.49 6.38,28.56 6.38,29.7 6.52,29.83 7.29,29.83
RING2 on IN4 (solid shape): 8.66,27.5 8.66,27.03 8.57,26.94 6.97,26.94 6.58,27.33 6.58,27.99 6.67,28.09 8.08,28.09
RING2 on IN4 (solid shape): 21.46,27.77 21.46,27.1 21.9,26.65 21.9,26.05 21.75,25.91 21.75,25.91 21.06,25.22 20.19,25.22 20.04,25.37 20.04,26.05 20.71,26.72 20.71,27.85 20.79,27.93 21.29,27.93
RT3612_BOOT1 on BOTTOM (solid shape): 157.88,146.07 157.75,145.95 155.75,145.95 155.62,146.07 155.62,146.33 155.75,146.45 156.79,146.45 156.85,146.44 156.92,146.43 156.98,146.44 157.05,146.45 157.14,146.45 157.32,146.63
RT3612_BOOT2 on BOTTOM (solid shape): 160.6,149.96 160.6,148.64 160.74,148.5 160.17,147.93 160.09,148 160.09,149.76 159.53,150.31 159,150.31 158.87,150.19 158.77,150.19 158.49,150.47 158.49,150.62 158.69,150.82 159.74,150.82
RT3612_PHASE1 on BOTTOM (solid shape): 158.48,146.67 158.33,146.52 157.58,147.27 156.66,147.27 156.5,147.11 156.5,146.89 156.33,146.72 156.13,146.72 156.12,146.71 155.75,146.71 155.62,146.83 155.62,147.09 155.74,147.2 155.89,147.2 156.41,147.72 157.42,147.72
RT3612_PHASE1 on BOTTOM (solid shape): 146.39,149.99 146.43,149.89 146.54,149.84 146.92,149.84 147.03,149.89 147.07,149.99 147.07,150.06 149.03,150.06 149.49,149.6 149.49,148.52 148.33,147.37 148.33,146.15 148.15,145.97 144.93,145.97 144.26,146.64 143.45,146.64 143.37,146.72 143.37,149.49 143.94,150.06 146.39,150.06
RT3612_PHASE2 on BOTTOM (solid shape): 159,149.53 159,148.39 159.6,147.79 158.9,148.2 158.57,148.54 158.57,148.94 158.44,149.07 158.44,149.37 157.93,149.88 157.93,150.01 158.16,150.24 158.29,150.24
RT3612_PHASE2 on BOTTOM (solid shape): 149.09,167.31 149.09,165.78 150.72,164.16 151.25,164.16 151.33,164.08 151.33,160.85 150.9,160.42 149.5,160.42 147.07,162.85 147.07,163 147.03,163.11 146.92,163.16 146.54,163.16 146.43,163.11 146.39,163 146.39,162.98 144.81,162.98 144.34,163.45 144.34,165.53 146.1,167.28 148.13,167.28 148.25,167.41 148.99,167.41
RT3612_UG2 on BOTTOM (solid shape): 159.86,149.73 159.86,148.05 159.75,147.94 159.74,147.94 159.16,148.51 159.16,149.62 158.92,149.86 158.92,149.96 159.13,150.16 159.43,150.16
RT6543_BOOT on BOTTOM (solid shape): 162.28,132.2 161.62,132.2 161.41,132 160.04,132 159.84,132.2 159.84,132.64 159.94,132.74 160.35,132.74 160.52,132.56 161.23,132.56 161.89,133.22 162.28,133.22
RT6543_FB on BOTTOM (solid shape): 163.92,133.19 165.35,133.19 165.6,132.94 167.64,132.94 167.75,132.83 167.75,132.43 167.65,132.33 166.47,132.33 166.26,132.13 166.26,131.57 166.11,131.42 164.76,131.42 164.73,131.45 164.73,132.27 164.56,132.43 164.05,132.43 163.9,132.28 163.71,132.28 163.69,132.3 163.69,133.17 163.76,133.24 163.87,133.24
RT6543_PH on TOP (solid shape): 148.25,129.31 148.25,127.02 147.87,126.64 147.37,126.64 147.11,126.9 147.11,128.42 147.24,128.55 147.24,129.31 147.37,129.44 148.13,129.44
RT6543_PH on BOTTOM (solid shape): 152.62,130.45 152.62,129.51 152.83,129.31 154,129.31 154.21,129.09 154.21,126.09 153.79,125.68 142.03,125.68 141.9,125.8 141.9,128.93 142.21,129.23 146.17,129.23 147.7,130.76 152.32,130.76
RT6543_UG on BOTTOM (solid shape): 161.87,133.42 161.16,132.71 160.73,132.71 160.6,132.84 160.6,133.04 160.88,133.32 160.88,133.6 161.87,133.6
RT6543_VCC on BOTTOM (solid shape): 160.73,137.23 160.73,136.52 160.85,136.39 160.92,136.39 160.93,136.36 161.07,136.18 161.29,136.11 161.51,136.18 161.65,136.36 161.66,136.39 162.2,136.39 162.28,136.32 162.28,135.51 162.2,135.43 161.92,135.43 161.87,135.38 161.87,135.1 161.79,135.02 160.98,135.02 160.9,135.1 160.9,135.2 160.65,135.45 158.97,135.45 158.91,135.52 158.91,136.15 159.08,136.32 159.96,136.32 160.14,136.5 160.14,137.21 160.23,137.3 160.66,137.3
SENSEA on BOTTOM (solid shape): 23.26,28.67 23.26,28.32 23.49,28.09 24.05,28.09 24.18,27.96 24.18,27.58 24.05,27.45 23.41,27.45 23.16,27.71 22.91,27.71 22.78,27.84 22.78,28.14 22.91,28.27 22.91,28.65 22.98,28.72 23.21,28.72
SLEEVE on TOP (solid shape): 20.44,27.86 20.44,26.13 19.96,25.65 19.96,25.32 19.86,25.22 19.43,25.22 19.4,25.24 19.4,27.66 19.81,28.06 20.24,28.06
SLEEVE on TOP (solid shape): 4.51,16.85 6.37,14.99 6.37,14.49 6.29,14.4 4.32,14.4 4.21,14.51 4.21,15.6 3.9,15.92 3.57,15.92 2.68,16.8 2.68,17.2 4.51,17.2
SLEEVE on IN3 (solid shape): 20.49,28.09 20.49,25.93 20.24,25.68 19.73,25.68 19.35,26.06 19.35,28.09 19.48,28.22 20.37,28.22
SLEEVE on IN3 (solid shape): 6.56,15.56 6.56,14.58 6.44,14.47 4.98,14.47 4.98,14.46 4.34,14.46 4.26,14.55 4.26,15.56 4.39,15.7 6.42,15.7
SN_VCORE1 on BOTTOM (solid shape): 143.38,146.3 144.17,146.3 144.51,145.96 144.51,145.61 144.23,145.34 142.69,145.34 142.53,145.5 142.53,146.47 142.63,146.57 143.11,146.57
SN_VCORE2 on BOTTOM (solid shape): 151.02,168.04 151.02,166.87 150.57,166.42 149.58,166.42 149.45,166.54 149.45,167.28 149.55,167.38 149.86,167.38 150.59,168.12 150.95,168.12
TYPEC1_USB0 on TOP (solid shape): 36.06,107.58 36.06,104.55 35.91,104.4 35.83,104.4 35.72,104.51 34.99,104.51 34.7,104.8 34.23,104.8 33.94,104.5 33.94,104.36 33.44,103.87 33.44,102.85 33.32,102.72 33.32,101.37 33.49,101.2 34.17,101.2 34.24,101.13 34.24,100.46 34.29,100.36 34.4,100.31 34.96,100.31 35.06,100.36 35.11,100.46 35.11,100.87 35.15,100.96 35.24,100.97 35.31,100.95 35.37,100.95 35.66,101.07 35.78,101.35 35.78,101.4 36.42,101.4 36.54,101.28 36.54,101.15 36.51,101.14 36.34,101.03 36.24,100.86 36.24,100.84 35.92,100.53 35.89,100.49 35.87,100.45 35.72,100.45 35.61,100.4 35.57,100.29 35.57,99.69 35.11,99.23 35.11,98.64 35.01,98.54 35.01,97.66 34.76,97.41 34.31,97.41 34.31,99.46 34.11,99.67 33.41,99.67 32.58,100.5 32.58,101.5 32.3,101.78 32.3,106.45 32.79,106.94 32.87,107 32.95,107.1 34.07,107.1 34.64,107.66 35.97,107.66
TYPEC1_USB0 on BOTTOM (solid shape): 12.24,58.82 12.24,54.89 11.48,54.12 11.48,52.98 11.35,52.85 9.57,52.85 8.94,52.22 7.54,52.22 7.41,52.35 7.41,52.85 7.79,53.24 7.79,53.87 8.94,55.01 9.44,55.01 9.82,55.39 9.82,58.82 9.95,58.95 12.11,58.95
TYPEC1_USB0 on IN1 (solid shape): outline of 1063 points within 19.03,104.67 35.18,113.85
TYPEC1_USB0 on SVCC (solid shape): outline of 467 points within 3.03,48.03 22.65,111.01
TYPEC1_USB0 on IN2 (solid shape): outline of 1125 points within 7.67,57.05 14.14,69.36
TYPEC1_USB0_PD on TOP (solid shape): 42.66,113.25 42.66,108.05 41.35,106.74 41.35,105.41 41.33,105.31 41.32,105.21 41.32,103.44 41.33,103.34 41.35,103.23 41.35,102.97 41.14,102.76 36.84,102.76 36.55,103.06 36.55,107.39 36.75,107.59 37.51,107.59 37.76,107.85 37.76,109.88 37.3,110.34 37.3,113.29 37.47,113.45 42.46,113.45
VA2 on TOP (solid shape): 73.81,200.28 73.81,196.95 73.48,196.62 72.49,196.62 70.34,194.47 69.15,194.47 69.01,194.61 69.01,197.61 69.21,197.81 70.07,197.81 70.38,198.12 70.38,200.28 70.58,200.48 73.6,200.48
VADPBL on TOP (solid shape): 69.74,205.97 69.74,205.46 69.71,205.43 68.97,205.43 68.63,205.08 68.63,201.37 68.3,201.04 67.42,201.04 67.31,201.02 67.22,200.96 67.18,200.91 58.24,200.91 57.93,201.22 57.93,204.44 56.94,205.43 56.94,205.84 57.17,206.07 69.64,206.07
N17061293 on TOP (solid shape): 76.88,205.89 76.88,201.32 76.25,200.68 70.78,200.68 70.12,201.34 70.12,205.97 70.33,206.17 76.6,206.17
N17061319 on TOP (solid shape): 148.69,120.8 148.69,119.81 148.23,119.35 148.23,119.28 148.21,119.24 148.19,119.19 148.19,119.13 148.19,119.07 148.2,119.01 148.21,118.95 148.23,118.91 148.23,118.84 148.36,118.72 148.36,117.74 148.08,117.46 148.08,114.92 145.7,112.54 142.03,112.54 141.97,112.61 139.94,112.61 139.75,112.8 139.75,116.86 139.87,116.99 141.14,116.99 141.27,117.12 141.27,117.62 146.2,117.62 146.2,117.57 146.21,117.51 146.23,117.46 146.26,117.41 146.29,117.36 146.33,117.32 146.38,117.29 146.43,117.26 146.48,117.24 146.53,117.22 146.59,117.22 146.65,117.22 146.7,117.23 146.76,117.25 146.81,117.27 146.85,117.3 146.9,117.34 146.93,117.38 146.96,117.43 146.99,117.48 147,117.54 147.01,117.6 147.01,117.65 147,117.71 146.99,117.76 146.96,117.82 146.93,117.86 146.9,117.91 146.85,117.95 146.81,117.98 146.76,118 146.7,118.02 146.65,118.03 146.59,118.03 146.53,118.03 146.48,118.01 146.43,117.99 146.38,117.96 146.33,117.93 146.29,117.89 146.26,117.84 146.23,117.79 146.21,117.74 146.2,117.68 146.2,117.62 141.27,117.62 141.27,118.89 141.74,119.36 141.74,119.87 142.03,120.16 144.7,120.16 145.42,120.89 148.6,120.89
N17061319 on BOTTOM (solid shape): 145.46,119.91 145.46,118.51 144.44,117.5 144.44,114.96 143.17,113.69 139.87,113.69 139.62,113.94 139.62,117.88 142.03,120.29 145.08,120.29
N17072870 on TOP (solid shape): 167.39,166.48 167.4,166.43 167.42,166.38 166.97,165.93 166.97,162.05 166.61,161.69 166.61,161 166.44,160.82 165.55,160.82 164.07,162.3 164.07,165.98 164.72,166.63 166.67,166.63 166.67,166.65 166.87,166.85 167.39,166.85
N17072870 on BOTTOM (solid shape): 168.04,167.46 168.04,166.39 167.99,166.34 167.87,166.44 167.71,166.47 167.46,166.37 167.33,166.13 167.23,166.13 166.97,165.86 166.97,160.81 166.79,160.63 166.04,160.63 166.04,160.64 163.89,162.79 160.17,162.79 159.99,162.97 159.99,166.33 160.19,166.52 163.79,166.52 164.14,166.87 164.14,167.62 164.26,167.74 167.76,167.74
N17419880 on TOP (solid shape): 34.88,104.25 35.62,104.25 36.3,103.57 36.3,103.01 36.73,102.58 37.28,102.58 37.46,102.4 37.46,101.79 37.4,101.73 37.08,101.73 37,101.65 35.69,101.65 35.63,101.71 35.63,102.3 35.48,102.46 33.95,102.46 33.7,102.7 33.7,103.76 34.19,104.25 34.19,104.4 34.34,104.54 34.59,104.54
N18723876 on TOP (solid shape): 26.34,190.96 26.34,186.41 27.91,184.85 38.95,184.85 39.17,184.62 39.17,183.51 38.81,183.14 26.26,183.14 24.12,185.28 24.12,190.82 24.33,191.03 26.28,191.03
N18723876 on BOTTOM (solid shape): 28.21,192.14 28.21,190.08 28.02,189.89 24.97,189.89 24.53,190.33 24.53,191.52 25.31,192.3 28.06,192.3
N18867651 on BOTTOM (solid shape): 204.31,129.97 204.55,129.97 204.61,129.94 204.67,129.94 204.97,129.94 205.03,129.94 205.1,129.97 206.29,129.97 206.58,129.68 207.89,129.68 208.27,130.05 209.25,130.05 209.39,129.92 209.39,128.39 209.28,128.28 206.68,128.28 206.3,128.65 206.17,128.74 206.02,128.77 206,128.77 205.97,128.81 204.4,128.81 204.27,128.88 204.13,128.9 204,128.88 203.87,128.81 203.63,128.81 202.97,129.47 202.9,129.52 202.82,129.54 202.75,129.54 202.66,129.62 201.86,129.62 201.81,129.68 201.81,129.83 202.49,129.83 202.49,130.02 201.81,130.02 201.81,130.23 201.91,130.33 203.95,130.33
N18867812 on TOP (solid shape): 34.16,162.74 34.18,162.73 34.38,162.73 34.38,161.99 34.58,161.99 34.58,162.73 34.78,162.73 34.78,161.99 34.8,161.99 34.8,161.79 34.8,161.78 34.77,161.73 34.76,161.67 34.76,161.45 34.41,161.1 34.41,160.11 34.08,159.79 34.08,158.14 33.95,158.01 33.19,158.01 33.07,158.14 33.07,161.31 32.94,161.44 32.68,161.44 32.56,161.57 32.56,162.2 32.68,162.33 33.45,162.33 33.86,162.74 34.13,162.74
