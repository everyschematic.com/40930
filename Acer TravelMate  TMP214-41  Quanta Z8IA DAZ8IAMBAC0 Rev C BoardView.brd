# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP8_SSD_C: length 3.4
  BOTTOM w0.114: C795.2 21.94,83.49 22.14,83.29 22.14,82 22.49,81.65 22.49,81.44 22.35,81.31 CN16.49
PCIE_TXP9_LAN: length 155.9
  TOP w0.114: v2(19.65,161.28) 19.6,161.23 19.6,161.01 19.73,160.88 19.94,160.88 20.12,161.07 20.12,161.49 19.98,161.63 19.98,162.2 19.89,162.29 U6521.41
  IN1 w0.089: v1(128.19,141.5) 128.42,141.73 128.42,143.18 127.7,143.9 127.7,149.41 127.03,150.07 125.08,150.07 124.09,151.06 124.09,161.47 123.1,162.47 119.16,162.47 118.79,162.84 118.79,164.11 117.14,165.76 117.14,168.07 115.9,169.31 115.9,170.05 115.51,170.43 115.51,171.6 113.51,173.61 112.62,173.61 112.06,174.16 105.02,174.16 104.95,174.09 103.88,174.09 102.87,173.07 101.98,173.07 100.15,171.24 93.37,171.24 93.27,171.35 91.99,171.35 91.84,171.5 88.34,171.5 88.18,171.35 83.1,171.35 82.24,170.48 68.73,170.48 64.44,174.77 53.28,174.77 51.14,176.92 44,176.92 36.79,169.71 36.79,167.32 34.79,165.33 32.51,165.33 31.11,163.93 29.33,163.93 26.92,161.52 22.45,161.52 21.61,162.35 19.25,162.35 18.97,162.07 18.97,161.06 19.17,160.85 19.98,160.85 20.11,160.98 20.11,161.1 19.93,161.28 v2(19.65,161.28)
  BOTTOM w0.114: v1(128.19,141.5) 128.36,141.33 128.36,141.15 128.18,140.96 C96791.2
PCIE_TXP9_LAN_C: length 10
  IN3 w0.114: v1(121.47,139.18) 121.34,139.18 121.21,139.31 121.21,139.47 121.33,139.6 121.71,139.6 122.11,139.2 128.11,139.2 128.26,139.35 128.26,139.53 v1(127.93,139.85)
  BOTTOM w0.114: U6539.BY7 121.47,138.95 v1(121.47,139.18) ; C96791.1 128.16,140.51 128.32,140.36 128.32,140.23 v1(127.93,139.85)
PCIE_WAKE#: length 428
  TOP w0.114: Q33.1 186.54,112.41 v1(186.99,111.96) ; v1(115.16,111.86) v2(115.16,112.54) 115.36,112.75 R68463.1 ; v2(18.97,81.18) 19.12,81.02 R69099.2 ; R67506.2 25.73,162.72 v1(25.34,162.33)
  IN1 w0.089: v2(224.33,124.25) 224.45,124.13 226.13,124.13 227.12,125.12 231.06,125.12 233.6,122.58 233.6,119.28 233.03,118.7 232.39,118.7 231.69,118.01 229.51,118.01 227.59,116.09 227.59,113.52 224.73,110.66 224.73,108.75 220.64,104.67 220.64,103.78 220.01,103.15 218.99,103.15 218.61,103.53 218.1,103.53 217.34,102.77 v2(213.41,102.77)
  IN3 w0.089: v1(106.29,125.65) 106.37,125.65 106.66,125.94 106.66,127.53 106.79,127.66 107.23,127.66 107.49,127.91
  IN3 w0.102: v1(25.34,162.33) 26.08,161.59 26.08,153.06 25.06,152.04 25.06,149.63 25.7,148.99 25.7,133.63 23.41,131.34 23.41,129.94 23.16,129.69 23.16,122.73 23.92,121.97 23.92,115.21 22.52,113.81 22.52,111.02 22.65,110.89 22.65,106.19 20.62,104.16 20.62,100.61 18.33,98.32 18.33,95.15 18.71,94.76 18.71,86.26 18.33,85.87 18.33,81.81 v2(18.97,81.18) ; 107.49,127.91 108.17,128.6 108.17,131.14 108.76,131.72 108.76,132.61 109.09,132.94 109.09,154.19 108.63,154.65 108.63,157.12 109.14,157.63 109.14,159.66 109.8,160.32 109.8,162.3 109.62,162.48 109.62,164.21 111.07,165.66 111.07,171.83 107.21,175.69 102.38,175.69 101.14,176.93 101.14,177.95 99.49,179.6 96.18,179.6 94.28,177.7 92.76,177.7 92.12,178.33 90.6,178.33 89.83,179.09 88.56,179.09 88.06,178.58 84.48,178.58 82.84,176.95 66,176.95 65.63,177.31 62.35,177.31 62.02,176.98 59.91,176.98 58.11,175.18 56.79,175.18 55.16,173.55 54.45,173.55 52.62,171.73 52.62,169.31 51.23,167.92 46.15,167.92 45.77,167.54 45.77,163.52 v2(43.73,161.49)
  IN4 w0.089: v1(106.29,125.65) 106.66,125.28 106.66,121.7 108,120.37 108,119.94 110.08,117.85 110.08,117.12 110.79,116.4 110.79,115.47 111.27,114.98 111.65,114.98 112.19,114.45 112.19,113.43 112.57,113.05 114.35,113.05 115.16,112.24 v1(115.16,111.86) 115.16,111.78 115.54,111.4 115.87,111.4 117.9,109.37 117.9,109.01 118.69,108.23 125.85,108.23 127.63,106.45 128.37,106.45 131.64,103.18 139.02,103.18 139.31,103.48 147.67,103.48 148.43,102.71 155.32,102.71 156.1,103.5 157.63,103.5 157.91,103.78 157.91,104.06 158.16,104.31 163.01,104.31 163.42,103.91 164,103.91 164.13,104.04 166.67,104.04 167.51,103.2 170.91,103.2 171.5,103.78 173.02,103.78 174.72,102.08 179.59,102.08 182.42,104.91 182.42,107.65 184.01,109.24 184.01,110.32 185.64,111.96 v1(186.99,111.96) 187.37,111.58 188.18,111.58 188.77,112.16 192.32,112.16 193.85,110.64 195.5,110.64 195.65,110.49 196.74,110.49 196.95,110.28 196.95,109.95 197.09,109.81 197.34,109.81 200.45,106.7 200.83,106.7 204.13,103.4 204.13,102 204.74,101.4 210.01,101.4 210.36,101.75 212.39,101.75 v2(213.41,102.77)
  BOTTOM w0.102: v1(106.29,125.65) 106.48,125.65 U6539.DK39
  BOTTOM w0.114: v1(25.34,162.33) 25.95,161.72 33.07,161.72 33.35,162 36.7,162 37.64,161.06 43.3,161.06 v2(43.73,161.49) ; CN49.9 223.83,123.75 v2(224.33,124.25)
PD#: length 16.9
  IN2 w0.102: v2(23.27,36.34) 24.82,36.34 26.84,34.31 29.76,34.31 30.91,33.17 v2(30.91,32.66)
  BOTTOM w0.114: v2(23.27,36.34) 23.1,36.5 R478.1 22.86,36.88 22.74,36.75 22.74,36.64 22.44,36.34 22.27,36.34 21.91,35.99 U20.47 ; D12.2 D13.2 30.91,33.68 30.75,33.83 R479.1 30.4,33.55 30.27,33.42 C595.1 30.64,33.05 30.91,32.79 v2(30.91,32.66)
PEDET: length 3.1
  BOTTOM w0.114: CN16.69 17.35,81.34 17.63,81.62 17.63,82.76 TP13376.1
PEG_RXN1: length 57.8
  TOP w0.114: v2(119.49,198.94) 117.93,198.94 116.47,200.41 116.47,200.65 116.63,200.81 C358.1
  IN4 w0.089: v2(127.66,159.18) 127.66,159.56 127.77,159.67 128.91,159.67 129.54,160.3 129.54,163.14 128.95,163.72 128.19,163.72 124.2,167.71 123.56,167.71 123.03,168.24 123.03,169.17 121.51,170.69 121.51,171.06 119.76,172.82 119.76,176.98 118.96,177.78 118.96,179.94 118.46,180.44 118.46,193.16 119.14,193.85 119.14,196.46 119.55,196.87 119.81,196.87 120.19,197.25 120.19,198.55 119.96,198.78 119.65,198.78 v2(119.49,198.94)
  BOTTOM w0.102: U6539.V2 123.58,157.71 124.74,157.71 124.9,157.86 126.93,157.86 127.57,158.5 127.57,159.09 v2(127.66,159.18)
PEG_RXN1_C: length 13.3
  TOP w0.102: 123.68,200.28 123.92,200.28 123.94,200.3 124.89,200.3 125.09,200.51 125.9,200.51 126.08,200.68 126.34,200.68 126.48,200.54 v1(126.48,200.22)
  TOP w0.114: 123.68,200.28 122.68,200.28 120.22,202.74 116.82,202.74 116.37,202.28 116.37,201.99 116.63,201.72 C358.2
  BOTTOM w0.114: v1(126.48,200.22) U8.AB9
PEG_RXN2: length 68.8
  TOP w0.114: C384.1 128.06,208.65 128.06,208.8 128.06,208.96 127.94,209.09 123.81,209.09 123.73,209.01 v2(123.73,208.66)
  IN4 w0.089: v2(125.78,159.18) 125.75,159.18 125.57,159.36 125.57,159.66 125.7,159.79 126.59,159.79 127.05,160.25 128.67,160.25 128.95,160.52 128.95,161.69 128.19,162.45 128.19,162.71 127.44,163.46 126.8,163.46 126.33,163.93 126.33,164.56 123.95,166.95 123.44,166.95 122.27,168.12 122.27,168.88 121.58,169.57 121.33,169.57 120.34,170.56 120.34,171.32 119.17,172.49 119.17,174.75 118.79,175.13 118.79,175.66 118.92,175.79 118.92,176.8 118.37,177.35 118.37,179.64 117.85,180.16 117.85,193.8 118.31,194.26 118.31,196.52 118.66,196.87 118.66,199.59 119.55,200.48 119.55,201.44 121.46,203.35 121.46,206.02 123.25,207.81 123.25,208.18 v2(123.73,208.66)
  BOTTOM w0.102: U6539.T2 123.59,158.34 124.49,158.34 124.62,158.47 125.32,158.47 125.57,158.71 125.57,158.97 v2(125.78,159.18)
PEG_RXN2_C: length 8.8
  TOP w0.102: 128.09,202.26 128.09,202.24 128.1,202.22 128.1,201.91 128.37,201.64 128.37,201.11 128.29,201.03 128.11,201.03 v1(128.11,201.03)
  TOP w0.114: 128.09,202.26 128.09,204.33 128.47,204.71 128.47,207.41 128.34,207.54 128.06,207.54 127.93,207.67 C384.2
  BOTTOM w0.114: v1(128.11,201.03) 128.17,200.97 128.17,200.74 128.01,200.58 127.77,200.58 U8.AC10
PEG_RXN3: length 69.8
  TOP w0.114: C6554.1 129.51,210.63 129.51,210.94 129.24,211.22 126.76,211.22 125.56,210.03 124.25,210.03 v2(123.73,210.55)
  IN4 w0.089: v2(123.73,210.55) 123.73,209.81 123.49,209.57 122.98,209.57 118.84,205.43 118.84,200.61 118.03,199.8 118.03,197.13 117.7,196.8 117.7,194.89 117.27,194.46 117.27,175.66 118.59,174.34 118.59,172.06 119.37,171.27 119.37,170.64 120.63,169.38 120.63,168.84 125.7,163.78 125.7,163.29 127.6,161.39 127.6,160.92 v1(127.71,160.82)
  BOTTOM w0.102: U6539.R2 123.61,158.97 124.36,158.97 124.97,159.58 126.88,159.58 127.37,160.08 127.39,160.08
  BOTTOM w0.114: 127.39,160.08 127.55,160.24 127.55,160.66 v1(127.71,160.82)
PEG_RXN3_C: length 9.9
  TOP w0.102: v1(128.96,201.06) 129.4,201.76 129.4,202.02 129.55,202.17
  TOP w0.114: C6554.2 129.71,209.19 129.46,208.94 129.46,203.93 129.62,203.76 129.62,202.24 129.55,202.17
  BOTTOM w0.114: U8.AC11 v1(128.96,201.06)
PEG_RXN4: length 74.1
  TOP w0.114: C6557.1 130.52,208.74 130.52,210.87 129.61,211.78 v2(129.61,212.57)
  IN4 w0.089: v1(125.88,160.82) 125.88,162.1 125.01,162.96 125.01,163.65 119.92,168.74 119.92,169.2 118,171.11 118,174.04 116.68,175.36 116.68,186.79 115.69,187.78 115.69,193.77 116.89,194.97 116.89,196.62 116.53,196.97 116.53,197.53 117.39,198.4 117.39,200.05 118.16,200.81 118.16,205.77 121.84,209.45 121.84,210.97 122.22,211.35 129.2,211.35 129.61,211.75 v2(129.61,212.57)
  BOTTOM w0.102: v1(125.88,160.82) 125.73,160.67 125.73,160.34 125.48,160.09 124.72,160.09 124.27,159.64 124.04,159.64 124,159.6 123.64,159.6 U6539.N2
PEG_RXN4_C: length 8.9
  TOP w0.102: v1(129.79,200.24) 129.8,200.25 130.24,201.09 130.24,201.34 130.48,201.58 130.48,202.22 130.49,202.24 130.49,202.26
  TOP w0.114: C6557.2 130.73,207.44 130.27,206.98 130.27,204.31 130.49,204.09 130.49,202.26
  BOTTOM w0.114: U8.AB12 v1(129.79,200.24)
PEG_RXP1: length 57.8
  TOP w0.114: v2(119.49,198.18) 119.22,198.18 119.1,198.31 119.1,198.59 118.97,198.71 117.84,198.71 116.24,200.31 116.24,200.54 115.87,200.91 C370.1
  IN4 w0.089: v1(127.02,159.18) 127.69,159.85 128.84,159.85 129.36,160.37 129.36,163.07 128.88,163.55 128.11,163.55 124.12,167.54 123.49,167.54 122.85,168.17 122.85,169.09 121.33,170.62 121.33,170.99 119.58,172.74 119.58,176.91 118.78,177.71 118.78,179.87 118.28,180.37 118.28,193.24 118.97,193.92 118.97,196.54 119.48,197.05 119.73,197.05 120.01,197.33 120.01,198.47 119.88,198.6 119.7,198.6 119.49,198.39 v2(119.49,198.18)
  BOTTOM w0.102: v1(127.02,159.18) 127.36,158.84 127.36,158.58 126.84,158.06 124.81,158.06 124.66,157.91 124.02,157.91 U6539.V1
PEG_RXP1_C: length 13.4
  TOP w0.102: 123.91,200.51 123.99,200.51 124,200.5 124.8,200.5 125.01,200.71 125.82,200.71 125.99,200.89 126.33,200.89 v1(126.48,201.04)
  TOP w0.114: 123.91,200.51 122.77,200.51 120.31,202.97 116.73,202.97 116.14,202.38 116.14,201.96 115.87,201.7 C370.2
  BOTTOM w0.114: U8.AC9 126.87,200.65 v1(126.48,201.04)
PEG_RXP2: length 68.7
  TOP w0.114: C382.1 128.61,208.53 128.29,208.84 128.29,208.88 128.29,209.05 128.03,209.32 123.72,209.32 v2(123.04,208.65)
  IN4 w0.089: v1(125.14,159.18) 125.19,159.18 125.39,159.38 125.39,159.73 125.63,159.97 126.52,159.97 126.97,160.42 128.6,160.42 128.77,160.6 128.77,161.62 128.01,162.38 128.01,162.64 127.36,163.28 126.73,163.28 126.16,163.85 126.16,164.49 123.87,166.77 123.36,166.77 122.09,168.05 122.09,168.81 121.51,169.39 121.26,169.39 120.16,170.48 120.16,171.24 118.99,172.41 118.99,174.67 118.61,175.05 118.61,175.74 118.74,175.86 118.74,176.73 118.19,177.28 118.19,179.57 117.67,180.09 117.67,193.87 118.13,194.33 118.13,196.59 118.49,196.95 118.49,199.66 119.38,200.55 119.38,201.52 121.28,203.42 121.28,206.09 123.04,207.86 v2(123.04,208.65)
  BOTTOM w0.102: v1(125.14,159.18) 125.17,159.18 125.37,158.98 125.37,158.8 125.24,158.67 124.53,158.67 124.4,158.54 124.04,158.54 U6539.T1
PEG_RXP2_C: length 8.9
  TOP w0.102: v1(128.12,200.2) 128.57,200.65 128.57,201.73 128.3,202 128.3,202.22 128.32,202.24 128.32,202.26
  TOP w0.114: C382.2 128.7,204.62 128.32,204.24 128.32,202.26
  BOTTOM w0.114: v1(128.12,200.2) 128.09,200.2 U8.AB10
PEG_RXP3: length 69.8
  TOP w0.114: C6556.1 129.05,210.43 129.29,210.67 129.29,210.85 129.14,210.99 126.85,210.99 125.66,209.8 124.15,209.8 123.89,210.06 123.46,210.06 v2(122.97,210.55)
  IN4 w0.089: v1(127.1,160.82) 127.42,161.14 127.42,161.32 125.52,163.22 125.52,163.7 120.46,168.77 120.46,169.3 119.2,170.56 119.2,171.2 118.41,171.98 118.41,174.27 117.09,175.59 117.09,194.53 117.52,194.96 117.52,196.87 117.85,197.2 117.85,199.87 118.66,200.68 118.66,205.51 122.91,209.75 123.42,209.75 123.55,209.89 123.55,210.15 123.15,210.55 v2(122.97,210.55)
  BOTTOM w0.102: 127.29,160.3 127.29,160.29 126.79,159.79 124.89,159.79 124.27,159.17 124.06,159.17 U6539.R1 ; v1(127.1,160.82) 127.33,160.59
  BOTTOM w0.114: 127.29,160.3 127.33,160.34 127.33,160.59
PEG_RXP3_C: length 9.8
  TOP w0.102: v1(128.93,201.85) 129.08,201.85 129.2,201.98 129.2,202.13 129.34,202.26
  TOP w0.114: C6556.2 128.95,209.7 129.08,209.57 129.36,209.57 129.48,209.45 129.48,209.29 129.23,209.03 129.23,203.83 129.39,203.67 129.39,202.32 129.34,202.26
  BOTTOM w0.114: v1(128.93,201.85) 129.03,201.75 129.03,201.57 128.89,201.44 128.55,201.44 U8.AD11
PEG_RXP4: length 74.1
  TOP w0.114: C6555.1 130.06,208.53 130.29,208.75 130.29,210.77 129.38,211.68 129.38,212.15 128.95,212.57 v2(128.83,212.57)
  IN4 w0.089: v2(128.83,212.57) 129.04,212.37 129.25,212.37 129.43,212.18 129.43,211.83 129.13,211.53 122.14,211.53 121.66,211.05 121.66,209.53 117.98,205.84 117.98,200.88 117.22,200.12 117.22,198.47 116.35,197.61 116.35,196.9 116.71,196.54 116.71,195.04 115.51,193.85 115.51,187.7 116.5,186.71 116.5,175.28 117.83,173.96 117.83,171.04 119.74,169.12 119.74,168.67 124.84,163.57 124.84,162.89 125.7,162.02 125.7,161.17 125.35,160.82 v1(125.27,160.82)
  BOTTOM w0.102: U6539.N1 124.04,159.85 124.18,159.85 124.63,160.3 125.39,160.3 125.52,160.43 125.52,160.68 125.38,160.82 v1(125.27,160.82)
PEG_RXP4_C: length 8.8
  TOP w0.102: v1(129.79,201.04) 129.94,201.04 130.04,201.14 130.04,201.43 130.28,201.66 130.28,202.22 130.27,202.24
  TOP w0.114: 130.27,202.24 130.27,204 130.04,204.22 130.04,207.08 130.5,207.53 130.5,207.64 130.37,207.77 130.09,207.77 129.97,207.9 C6555.2
  BOTTOM w0.114: U8.AC12 129.41,200.62 129.7,200.62 129.85,200.77 129.85,200.97 v1(129.79,201.04)
PEG_TXN1: length 63.5
  TOP w0.114: C96708.2 129.56,156.23 129.82,156.23 v2(129.95,156.11)
  IN4 w0.089: v1(124.6,205.86) 124.33,205.86 123.67,206.52 123.11,206.52 122.04,205.45 122.04,203.3 120.59,201.85 120.59,196.26 119.83,195.5 119.83,193.72 119.04,192.93 119.04,189.8 119.43,189.42 119.43,186.71 118.86,186.15 118.86,180.8 119.35,180.31 119.35,178.03 120.19,177.19 120.19,172.95 122.04,171.09 122.04,170.74 126.26,166.52 127.3,166.52 130.03,163.79 130.03,159.86 129.28,159.11 129.28,156.39 129.47,156.19 129.86,156.19 v2(129.95,156.11)
  BOTTOM w0.114: v1(124.6,205.86) 124.83,205.64 125.01,205.64 125.27,205.38 125.27,204.7 125.22,204.65 U8.AG7
PEG_TXN1_C: length 8.5
  TOP w0.089: v1(121.57,156.57) 121.73,156.41 121.73,156.23 121.93,156.03 122.55,156.03 122.73,155.85 123.06,155.85 123.09,155.83 123.11,155.83
  TOP w0.114: 123.11,155.83 123.66,155.83 124,156.16 128.67,156.16 C96708.1
  BOTTOM w0.102: U6539.Y7 121.57,156.7 v1(121.57,156.57)
PEG_TXN2: length 56.5
  TOP w0.114: C96704.2 131.08,157.09 131.24,157.25 131.59,157.25 v2(131.85,156.99)
  IN4 w0.089: v2(131.85,156.99) 131.87,156.99 132.13,157.25 132.89,157.25 133.57,157.94 133.57,163.29 132.25,164.61 132.25,165.38 130.85,166.77 130.85,168.68 126.93,172.6 124.52,172.6 122.78,174.34 122.78,178.03 122.22,178.58 122.22,181.12 121.92,181.43 121.92,186.41 122.65,187.15 122.65,201.14 124.42,202.92 124.55,202.92 v1(124.83,202.64)
  BOTTOM w0.114: U8.AE7 125.22,202.25 v1(124.83,202.64)
PEG_TXN2_C: length 10.4
  TOP w0.089: 123.49,156.92 123.47,156.92 123.44,156.94 122.73,156.94 121.88,156.94 121.71,157.11 121.71,157.34 v1(121.57,157.48)
  TOP w0.114: C96704.1 130.36,157.26 129.8,157.26 129.69,157.15 125.72,157.15 125.33,156.76 123.98,156.76 123.82,156.92 123.49,156.92
  BOTTOM w0.102: U6539.V7 121.57,157.62 v1(121.57,157.48)
PEG_TXN3: length 57.3
  TOP w0.114: C96707.2 131.72,158.72 131.84,158.84 132.31,158.84 v2(132.51,158.65)
  IN4 w0.089: v1(126.48,203.47) 125.78,203.47 125.14,204.11 124.56,204.11 121.86,201.42 121.86,191.56 120.7,190.39 120.7,188.75 121.28,188.16 121.28,187.3 120.95,186.97 120.95,178.21 121.92,177.24 121.92,173.68 126.29,169.31 126.92,169.31 131.36,164.87 131.36,164.36 132.38,163.34 132.38,160.64 131.62,159.88 131.62,159.08 131.85,158.85 132.3,158.85 v2(132.51,158.65)
  BOTTOM w0.114: v1(126.48,203.47) 126.9,203.06 U8.AF9
PEG_TXN3_C: length 11.4
  TOP w0.089: 123.49,157.93 123.47,157.93 123.44,157.96 123.18,157.96 123.08,157.86 121.88,157.86 121.71,158.02 121.71,158.27 v1(121.58,158.4)
  TOP w0.114: 123.49,157.93 123.75,157.93 124.03,157.65 124.53,157.65 124.72,157.84 129.41,157.84 130.42,158.85 131.14,158.85 131.27,158.72 C96707.1
  BOTTOM w0.102: v1(121.58,158.4) 121.24,158.74 U6539.T7
PEG_TXN4: length 57
  TOP w0.114: C96703.2 131.08,161.03 130.96,161.16 130.96,161.42 131.08,161.55 131.63,161.55 v2(131.87,161.31)
  IN4 w0.089: v2(131.87,161.31) 131.69,161.49 131.32,161.49 130.68,162.13 130.68,164.28 127.68,167.28 126.66,167.28 123.25,170.7 123.25,171.08 120.82,173.51 120.82,177.44 120.37,177.9 120.37,180.18 119.87,180.68 119.87,182.35 120.06,182.54 120.06,191.16 121.23,192.33 121.23,201.59 124.43,204.8 124.94,204.8 125.24,205.1 125.87,205.1 v1(125.98,205.2)
  BOTTOM w0.114: U8.AG10 127.4,204.15 127.4,204.39 126.79,205 126.18,205 v1(125.98,205.2)
PEG_TXN4_C: length 11.8
  TOP w0.089: v1(121.56,159.31) 121.69,159.19 121.69,158.96 121.87,158.77 123.44,158.77 123.47,158.75 123.49,158.75
  TOP w0.114: C96703.1 131.07,160.42 131.07,160.05 130.81,159.79 130.45,159.79 129.14,158.49 124.47,158.49 124.21,158.75 123.49,158.75
  BOTTOM w0.102: U6539.P7 121.56,159.46 v1(121.56,159.31)
PEG_TXP1: length 63.5
  TOP w0.114: C96706.2 129.3,156.6 129.47,156.44 129.72,156.44 129.95,156.66 v2(129.95,156.77)
  IN4 w0.089: v1(124.6,205.23) 124.48,205.23 124.25,205.46 124.25,205.68 123.59,206.34 123.18,206.34 122.22,205.38 122.22,203.22 120.77,201.77 120.77,196.19 120.01,195.43 120.01,193.65 119.22,192.86 119.22,189.87 119.6,189.49 119.6,186.64 119.04,186.07 119.04,180.87 119.53,180.39 119.53,178.1 120.37,177.26 120.37,173.02 122.22,171.17 122.22,170.81 126.33,166.7 127.37,166.7 130.21,163.86 130.21,159.79 129.46,159.04 129.46,156.46 129.55,156.37 129.65,156.37 129.95,156.67 v2(129.95,156.77)
  BOTTOM w0.114: v1(124.6,205.23) 124.79,205.41 124.91,205.41 125.04,205.28 125.04,204.79 124.99,204.75 124.99,204.42 U8.AG6
PEG_TXP1_C: length 8.5
  TOP w0.089: v1(122.22,156.57) 122.04,156.57 121.9,156.44 121.9,156.3 122,156.21 122.62,156.21 122.8,156.03 123.06,156.03 123.09,156.05 123.11,156.05
  TOP w0.114: C96706.1 128.5,156.39 123.9,156.39 123.57,156.05 123.11,156.05
  BOTTOM w0.102: v1(122.22,156.57) 122.22,156.7 U6539.Y5
PEG_TXP2: length 56.6
  TOP w0.114: v2(131.85,157.76) 131.57,157.48 131.26,157.48 131.08,157.66 C96702.2
  IN4 w0.089: v1(124.83,203.44) 124.5,203.12 124.38,203.12 122.47,201.22 122.47,187.22 121.74,186.48 121.74,181.35 122.04,181.05 122.04,178.51 122.6,177.95 122.6,174.27 124.44,172.42 126.86,172.42 130.68,168.61 130.68,166.7 132.08,165.3 132.08,164.54 133.4,163.22 133.4,158.01 132.81,157.43 132.2,157.43 131.87,157.76 v2(131.85,157.76)
  BOTTOM w0.114: U8.AF7 v1(124.83,203.44)
PEG_TXP2_C: length 10.3
  TOP w0.089: 123.49,157.15 123.47,157.15 123.44,157.12 122.65,157.12 122.65,157.12 121.95,157.12 121.89,157.18 121.89,157.32 122.06,157.48 v1(122.22,157.48)
  TOP w0.114: 123.49,157.15 123.92,157.15 124.07,156.99 125.24,156.99 125.63,157.38 129.6,157.38 129.7,157.49 130.46,157.49 130.63,157.66 C96702.1
  BOTTOM w0.102: U6539.V5 122.22,157.61 v1(122.22,157.48)
PEG_TXP3: length 57.3
  TOP w0.114: v2(132.48,159.31) 132.25,159.07 131.95,159.07 131.72,159.31 C96705.2
  IN4 w0.089: v1(126.48,202.66) 126.48,202.91 126.1,203.3 125.7,203.3 125.07,203.93 124.63,203.93 122.04,201.34 122.04,191.49 120.87,190.32 120.87,188.82 121.46,188.24 121.46,187.22 121.13,186.89 121.13,178.28 122.09,177.31 122.09,173.76 126.36,169.49 127,169.49 131.54,164.94 131.54,164.43 132.56,163.42 132.56,160.57 131.8,159.81 131.8,159.15 131.92,159.03 132.35,159.03 132.48,159.15 v2(132.48,159.31)
  BOTTOM w0.114: v1(126.48,202.66) U8.AE9
PEG_TXP3_C: length 11.4
  TOP w0.089: 123.49,158.16 123.47,158.16 123.44,158.14 123.11,158.14 123.01,158.04 121.95,158.04 121.89,158.1 121.89,158.2 122.09,158.4 v1(122.22,158.4)
  TOP w0.114: 123.49,158.16 123.85,158.16 124.12,157.88 124.44,157.88 124.62,158.07 129.32,158.07 130.33,159.08 131.08,159.08 131.27,159.26 C96705.1
  BOTTOM w0.102: U6539.T5 121.89,158.73 v1(122.22,158.4)
PEG_TXP4: length 57
  TOP w0.114: v2(131.87,161.97) 131.87,161.95 131.7,161.78 130.99,161.78 130.73,161.52 130.73,161.28 130.47,161.03 C96701.2
  IN4 w0.089: v1(125.98,204.47) 125.98,204.67 125.73,204.92 125.31,204.92 125.01,204.62 124.5,204.62 121.41,201.52 121.41,192.25 120.24,191.08 120.24,182.46 120.05,182.27 120.05,180.75 120.54,180.26 120.54,177.97 121,177.51 121,173.58 123.43,171.16 123.43,170.77 126.74,167.46 127.75,167.46 130.86,164.36 130.86,162.2 131.39,161.67 131.67,161.67 131.87,161.87 v2(131.87,161.97)
  BOTTOM w0.114: v1(125.98,204.47) 125.98,204.65 126.08,204.75 126.08,204.75 126.1,204.77 126.7,204.77 127.17,204.3 127.17,204.12 U8.AG9
PEG_TXP4_C: length 11.7
  TOP w0.089: 123.49,158.98 123.47,158.98 123.44,158.95 121.95,158.95 121.86,159.03 121.86,159.12 122.06,159.31 v1(122.17,159.31)
  TOP w0.114: 123.49,158.98 124.3,158.98 124.56,158.71 129.05,158.71 130.35,160.02 130.72,160.02 130.85,160.14 130.85,160.42 130.68,160.58 C96701.1
  BOTTOM w0.102: v1(122.17,159.31) 122.17,159.32 122.17,159.5 U6539.P5
PEGX_RST#: length 43.7
  TOP w0.114: v1(111.55,185.49) 111.6,185.49 112.11,186 113.28,186 v2(113.84,185.44) 114.98,185.44 115.18,185.24 115.79,185.24 116.66,186.1 119.4,186.1 119.46,186.16 v1(122.34,186.16)
  IN3 w0.102: v2(122.85,205) 122.25,204.4 122.25,194.68 122.67,194.26 122.67,187.41 122.34,187.09 v1(122.34,186.16)
  BOTTOM w0.114: R296.2 120.58,207.28 v2(122.85,205) ; R306.2 111.22,186.33 111.22,185.82 v1(111.55,185.49) 111.21,185.15 R305.2 110.76,184.58 110.89,184.45 110.89,182.88 109.77,181.76 108.5,181.76 108.39,181.64 R384.1
PEGX_RST#_C: length 2
  BOTTOM w0.114: U9.4 109.89,185.84 v2(109.9,185.82) 110.15,185.82 110.27,185.93 R305.1
PEX_CLKREQ#: length 24.2
  BOTTOM w0.114: Q9.1 113.26,188.98 113.39,188.85 R25487.2 ; R25487.2 115,188.85 115.26,188.59 R297.1 ; R25487.2 114.6,189.63 114.47,189.76 114.47,190.22 114.88,190.62 114.88,192.74 114.42,193.2 v2(114.42,195.4) 114.42,196.58 115.24,197.39 115.24,198.52 115.36,198.65 117.27,198.65 118.54,199.92 119.43,199.92 119.96,199.39 123.79,199.39 123.98,199.58 123.98,200 124.42,200.44 U8.AC6
PEX_TERMP: length 5.1
  BOTTOM w0.102: U8.AF25 140.48,203.41 140.48,204.08 141.37,204.97
  BOTTOM w0.114: R312.2 142.67,206.71 142.67,206.7 142.67,206.27 141.37,204.97
PEX_TSTCLK: length 6
  BOTTOM w0.127: U8.AF22 138.19,203.62 138.19,203.8 139.92,205.53 140.46,205.53 141.08,206.15 141.08,206.94 141.02,207 R307.2
PEX_TSTCLK#: length 6.9
  BOTTOM w0.127: R307.1 141.47,207.05 141.32,206.91 141.32,206.05 140.56,205.29 140.02,205.29 138.43,203.7 138.43,203.52 138.09,203.18 138.09,202.72 U8.AE22
PGANG: length 1.9
  TOP w0.114: R68560.2 76.93,113.79 76.95,113.79 76.98,113.81 v2(77.57,113.81) 77.63,113.81 77.77,113.67 U6544.23
PINSET_TSEN: length 2.3
  TOP w0.114: PR7021.2 157.71,142.82 157.35,142.47 v2(157.04,142.47)
  TOP w0.178: PR7023.1 157.12,143.63 157.68,143.63 PR7028.1 PR7021.2
PLTRST#: length 568
  TOP w0.114: R601.1 88.18,102 88.26,102.08 91.54,102.08 v1(91.99,101.62) ; v2(209.72,93.37) 206.8,93.37 206.29,92.86 204.77,92.86 204.4,93.23 CN66.2 ; v1(104.87,128.47) 104.79,128.55 R68483.1 ; R68932.1 13.37,162.84 11.86,162.84 v1(11.73,162.96) 11.48,163.22 Q6620.3 ; v1(23.31,84.48) 21.92,83.08 19.48,83.08 16.43,80.03 v2(16.43,78.76) 15.41,77.75 v2(15.41,76.98) 15.41,76.86 16.33,75.94 16.33,75.54 16.67,75.19 18.45,75.19 18.71,75.46 21.13,75.46 22.14,76.48 22.73,76.48 22.91,76.3 R69097.1 23.11,75.94 23.29,76.12 23.82,76.12 24.25,76.55 24.76,76.55 24.99,76.78 24.99,77.57 25.29,77.87 26.46,77.87 26.73,78.14 U6565.1 ; v1(80.64,119.15) 81.15,118.64 82.27,118.64 82.34,118.72 84.04,118.72 84.41,118.35 D13110.1
  IN1 w0.089: v2(200.45,104.8) 203.5,104.8 205.31,106.61 207.02,106.61 209.34,104.29 215.18,104.29 217.34,106.45 221.79,106.45 224.33,108.99 224.33,112.42 227.2,115.29 227.2,116.3 229.41,118.51 231.57,118.51 232.2,119.15 232.84,119.15 233.17,119.48 233.17,122.25 231.19,124.23 229.41,124.23 228.39,123.21 226.74,123.21 226.23,123.72 224.1,123.72 v2(223.57,124.25) ; v1(80.64,119.15) 80.64,121.66 82.32,123.34 85.26,123.34 86.74,124.81 96.64,124.81 97.58,125.75 99.49,125.75 101.01,127.28 101.39,127.28 102.15,128.04 104.44,128.04 v1(104.87,128.47)
  IN3 w0.102: v2(104.57,174.75) 104.85,175.03 107.21,175.03 110.66,171.57 110.66,165.92 108.88,164.14 108.88,162.1 108.86,162.07 108.86,160.14 108.71,159.99 108.71,157.83 108.22,157.35 108.22,155.95 108.12,155.85 108.12,134.26 107.74,133.88 107.74,130.96 107.92,130.78 107.92,129.1 107.67,128.85 105.25,128.85 v1(104.87,128.47) ; v1(115.87,97.51) 117.32,98.96 119.3,98.96 119.5,98.75 123.03,98.75 124.12,99.84 131.52,99.84 133.42,101.75 137,101.75 137.79,102.54 141.74,102.54 142.47,101.81 143.12,101.81 144.06,100.86 146.17,100.86 147.14,101.83 149.29,101.83 150.13,102.66 156.1,102.66 156.38,102.94 158.91,102.94 160.79,104.82 163.98,104.82 164.59,104.21 167.99,104.21 168.45,104.67 171.52,104.67 176.51,109.66 179.2,109.66 184.44,104.42 187.62,104.42 188.89,105.69 190.55,105.69 192.85,103.39 199.04,103.39 v2(200.45,104.8) ; v1(23.31,84.48) 23.79,84.96 23.79,86 24.56,86.76 24.56,93.87 28.29,97.61 37.46,97.61 37.76,97.3 45.89,97.3 46.43,96.77 59.33,96.77 60.17,97.61 68.98,97.61 70.28,98.9 70.28,99.11 71.6,100.43 72.26,100.43 73.2,101.37 77.52,101.37 77.77,101.62 79.8,101.62 80.56,102.38 80.94,102.38 v1(81.58,101.75)
  IN4 w0.089: v2(104.57,174.75) 104.57,175.41 105.07,175.92 105.07,184.33 v2(105.42,184.68) ; v1(11.73,162.96) 11.86,162.84 15.92,162.84 16.56,162.2 16.56,147.85 20.78,143.63 20.78,138.28 16.4,133.9 16.4,130.05 15.83,129.48 15.83,118.32 17.32,116.83 17.32,114.45 17.95,113.81 17.95,112.16 16.94,111.15 16.94,104.92 17.44,104.42 17.44,103.15 17.19,102.89 17.19,99.97 17.06,99.84 17.06,92.35 17.57,91.84 17.57,89.07 16.82,88.33 16.82,87.03 17.22,86.63 17.22,86.06 17.06,85.9 17.06,79.4 v2(16.43,78.76) ; v1(115.87,97.51) 115.29,96.92 111.3,96.92 110.66,97.56 104.41,97.56 101.11,100.86 99.36,100.86 97.84,102.38 95.68,102.38 94.9,101.61 92.01,101.61 v1(91.99,101.62) 91.99,101.6 91.64,101.24 82.09,101.24 v1(81.58,101.75)
  BOTTOM w0.102: v1(104.87,128.47) 105.33,128.47 105.64,128.16 U6539.DD41
  BOTTOM w0.114: v2(105.42,184.68) 105.61,184.68 106.12,185.19 U9.2 ; v1(80.64,119.15) 80.82,118.97 80.82,110.11 79.99,109.28 79.99,108.8 80.35,108.44 80.73,108.44 81.02,108.15 81.02,107.67 80.69,107.34 80.69,106.32 79.67,105.31 79.67,104.8 81,103.47 81,102.58 81.58,102 v1(81.58,101.75) ; v2(209.72,93.37) 211.25,94.89 211.25,98.96 212.77,100.48 212.77,104.04 212.39,104.42 208.45,104.42 207.84,103.81 206.14,103.81 205.53,104.42 200.83,104.42 v2(200.45,104.8) 200.96,105.31 200.96,106.32 199.82,107.46 199.05,107.46 197.61,108.91 196.41,108.91 195.83,109.5 R2665.2 ; v1(91.99,101.62) 92.02,101.62 92.84,102.45 93.96,102.45 94.41,102.89 94.41,107.46 94.99,108.05 94.99,108.58 95.12,108.71 R68683.2 96.03,108.71 96.09,108.76 U6554.1 ; CN49.8 v2(223.57,124.25)
PLTRST#_LAN: length 10.2
  TOP w0.114: U6521.36 17.06,163.81 16.94,163.68 v2(16.94,163.09) ; R68932.2 R68929.1 13.29,164.14 13,164.42 13,165 v2(12.87,165.12) 12.35,164.6 Q6620.1 12.35,163.46 v2(12.24,163.34)
  IN1 w0.089: v2(12.24,163.34) 13,163.34 13.25,163.09 v2(16.94,163.09)
PM_EXTTS#0: length 11.4
  TOP w0.114: v2(46.43,138.23) 46.4,138.2 R224.1 ; v2(50.97,137.61) 50.97,137.94 52.44,139.41 Q6639.1
  IN1 w0.089: v2(46.43,138.23) 50.81,138.23 50.97,138.07 v2(50.97,137.61)
  BOTTOM w0.114: v2(46.43,138.23) 46.34,138.32 JDIM1.134
PM_EXTTS#1: length 5.8
  TOP w0.114: R69024.1 55.85,137.85 Q124.1 55.83,138.27 55.71,138.4 55.11,138.4 v2(54.62,138.89)
  BOTTOM w0.114: v2(54.62,138.89) 55.19,138.32 JDIM02.134
PM_THRMTRIP#: length 246.2
  TOP w0.114: v2(51.86,137.61) 51.86,138.2 53.02,139.36 Q6639.3 53.39,138.2 53.83,137.75 Q124.3 ; v1(103.55,95.22) 103.42,95.35 103.42,97.18 103.91,97.66 v2(103.91,99.34) 103.91,101.52 104.46,102.07 Q86.1 105.54,103.31 105.94,102.92 R822.1
  IN3 w0.102: v1(93.29,177.03) 93.26,177.06 92.37,177.06 91.87,177.57 89.45,177.57 88.44,176.55 87.42,176.55 87.04,176.93 83.41,176.93 83.02,176.54 65.62,176.54 65.27,176.88 62.83,176.88 62.5,176.55 60.19,176.55 58.39,174.75 56.94,174.75 55.34,173.15 54.68,173.15 53.13,171.6 53.13,154.58 52.75,154.2 52.75,138.5 v2(51.86,137.61) ; v1(124.89,155.71) 124.89,155.47 125.39,154.96 126.16,154.96 126.66,154.45 130.86,154.45 131.87,153.44 136.19,153.44 136.9,152.73 136.9,150.19 137.51,149.58 137.51,147.16 138.02,146.66 138.02,141.42 137.71,141.12 137.08,141.12 136.72,140.76 136.72,131.44 137.46,130.71 137.46,128.04 138.22,127.28 138.22,124.23 137.38,123.39 137.38,122.04 136.82,121.48 136.82,117.83 135.05,116.05 135.05,112.24 130.73,107.92 130.73,105.81 128.21,103.3 120.98,103.3 118.05,100.38 116.3,100.38 114.55,98.62 111.78,98.62 110.13,96.97 109.57,96.97 107.01,94.41 104.36,94.41 v1(103.55,95.22)
  IN4 w0.089: v1(124.89,155.71) 123.62,156.98 123.62,159.28 123.11,159.79 122.66,159.79 v1(122.22,160.23) 122.67,160.68 122.98,160.68 123.49,161.19 123.49,164.11 119.04,168.55 119.04,168.81 117.65,170.2 113.71,170.2 113.33,170.58 112.31,170.58 111.68,171.22 95.8,171.22 92.37,174.65 92.37,176.68 92.76,177.06 93.26,177.06 v1(93.29,177.03)
  BOTTOM w0.102: U6539.M5 121.89,160.56 v1(122.22,160.23)
  BOTTOM w0.114: Q6640.3 91.79,177.75 92.5,177.03 v1(93.29,177.03)
PMON: length 34.9
  TOP w0.203: v2(167.81,124.48) 166.91,123.58 v2(166.17,123.58) 165.15,122.55 165.15,120.25 164.76,119.87 v2(164.14,119.87)
  IN4 w0.089: v2(166.92,143.15) 166.29,143.79 165.27,143.79 165.02,143.53 165.02,141.63 164.51,141.12 164.51,138.86 165.91,137.46 165.91,137 167.15,135.76 167.15,127.17 167.81,126.51 v2(167.81,124.48)
  BOTTOM w0.114: PR7051.1 167.43,143.66 v2(166.92,143.15)
  BOTTOM w0.203: PR25.2 163.47,119.48 163.59,119.35 164.36,119.35 164.54,119.18 PC18.2 PR23.1 164.49,120.19 164.16,119.87 v2(164.14,119.87)
PP: length 1.4
  TOP w0.114: R600.2 92.15,97.82 U33.4
PRE_SEL: length 3
  TOP w0.114: U6537.27 24.3,122.3 24.12,122.12 23.08,122.12 v2(22.65,121.69) R68215.1
PRIVACY_EN: length 190.7
  TOP w0.114: v1(171.75,116.86) 171.19,116.3 171.19,115.87 171.7,115.36 R68883.2
  IN1 w0.089: v2(140.15,129.69) 140.13,129.69 140,129.56 140,125.5 142.03,123.47 147.11,123.47 148.25,124.61 156.26,124.61 158.41,122.45 160.19,122.45 161.84,120.8 164.64,120.8 165.27,120.16 165.27,119.55 166.75,118.08 166.75,116.15 167.03,115.87 169.06,115.87 169.79,116.61 171.5,116.61 v1(171.75,116.86)
  IN3 w0.102: v2(140.15,129.69) 139.36,130.48 139.36,140.36 140.05,141.04 140.05,143.74 139.36,144.42 139.36,147.22 139.14,147.44 139.14,155.57 138.43,156.28 133.73,156.28 133.52,156.49 133.52,162.89 131.29,165.12 130.73,165.12 127.93,167.92 127.93,168.93 127.38,169.49 125.34,169.49 124,170.84 124,171.14 121.79,173.35 118.87,173.35 116.3,175.92 116.3,176.27 116.01,176.56 115.65,176.56 113,179.22 113,183.11 112.44,183.66 111.3,183.66 110.76,184.2 106.57,184.2 105.63,185.14 104.9,185.14 104.69,184.93 99.99,184.93 98.39,183.33 94.04,183.33 92.95,184.43 92.95,186.27 92.76,186.46 92.76,187.22 92.37,187.6 86.91,187.6 85.54,188.97 79.27,188.97 78.1,187.8 75.99,187.8 75.31,188.49 74.98,188.49 74.34,189.13 74.34,189.38 73.96,189.76 71.66,189.76 71.29,189.39 71.29,189.25 70.91,188.87 69.51,188.87 69.01,188.36 64.31,188.36 63.8,188.87 63.04,188.87 62.91,189 v2(62.91,189.38)
  BOTTOM w0.114: CN29.14 63.15,191.27 62.66,190.78 62.66,189.63 v2(62.91,189.38) ; R68881.1 132.25,127.03 132.25,128.8 134.28,130.83 138.86,130.83 140,129.69 v2(140.15,129.69)
PROCHOT#_CPU: length 8.5
  BOTTOM w0.114: U6539.E2 123.27,163.76 123.71,164.19 124.08,164.19 125.01,165.12 125.01,167.71 126.54,169.24 126.54,169.69 126.16,170.08 R68260.2
PROCHOT_EC: length 12.9
  TOP w0.114: U37.17 150.66,103.14 150.59,103.07 150.11,103.07 149.88,103.3 C6610.2 149.37,103.3 149.27,103.4 149.27,103.53 149.06,103.74 148.64,103.74 148.25,103.35 148.25,102.59 147.75,102.08 147.75,101.88 146.1,100.23 145.84,100.23 v2(145.21,99.59) 144.44,98.83 R25298.2 143.97,97.53 143.75,97.75 Q6509.2
PROCPWRGD: length 1.3
  TOP w0.114: v1(120.27,142.84) 120.45,143.02 R68480.2
  BOTTOM w0.102: v1(120.27,142.84) 119.94,142.52 U6539.BM9
PS_FB_CLAMP: length 7.6
  BOTTOM w0.114: U8.F3 121.45,186.08 118.54,186.08 117.17,187.45 117.17,187.68 116.61,188.24 v2(116.4,188.24) 116.3,188.13 R313.1
PSELF: length 3.4
  TOP w0.114: R68556.1 76.37,114.96 76.39,114.98 R69003.2 77.46,114.98 77.54,115.06 v2(77.9,115.06) 77.92,115.03 77.92,114.37 78.1,114.2 78.1,114.17 U6544.22
PULSAR_38P4M_REFCLK: length 2.9
  BOTTOM w0.114: CN17.64 192.9,107.9 193.21,107.59 193.21,106.83 TP13354.1
PVADPTR: length 272.9
  TOP w0.254: PQ8007.3 67.42,200.76 68.46,200.76 PC5.1 PC1.1
  TOP w0.381: 41.47,120.65 41.61,120.51 ; PD8001.1 83.3,189.18 83.54,188.95 PR9278.2 84.02,188.54 84.22,188.34 v2(84.22,188.08)
  TOP w0.508: v2(162.35,124.99) 162.48,124.99 163.6,123.86 PR31.1 163.04,122.92 162.32,123.64 159.3,123.64 159.13,123.47 157.48,123.47 PD9002.2
  TOP w3.048: 56.18,190.14 54.22,190.14 51.74,187.66 50.02,187.66 46.69,184.34 46.69,178.18 41.07,172.56 41.07,157.88 41.61,157.34 41.61,120.51
  IN1 w0.508: v2(139.17,174.2) 139.17,172.98 143.1,169.06 151.56,169.06 152.34,168.28 v2(157.14,168.28) ; v2(67.17,193.89) 67.17,193.51 67.48,193.19 76.11,193.19 77.13,192.17 77.13,191.21 78.68,189.66 78.68,188.59 79.65,187.63 82.95,187.63 83.23,187.35 83.87,187.35 84.22,187.7 v2(84.22,188.08)
  IN2 w0.508: v2(139.17,174.2) 138.32,173.35 130.63,173.35 128.82,175.16 128.82,178.15 128.52,178.46 123.87,178.46 122.6,177.19 120.8,177.19 119.1,178.89 119.1,179.85 118.54,180.41 114.42,180.41 112.67,178.66 110.41,178.66 109.96,179.1 108.46,179.1 107.61,179.95 107.61,184.95 106.57,185.99 106.57,186.71 105.63,187.66 103.5,187.66 102.55,186.71 101.65,186.71 100.24,185.3 98.36,185.3 96.93,186.73 94.76,186.73 94.08,187.41 94.08,188.44 92.46,190.06 88.48,190.06 88.03,189.61 87.17,189.61 86.56,189 84.63,189 84.22,188.59 v2(84.22,188.08)
  IN4 w0.508: v2(157.14,168.28) 157.14,167.03 156,165.88 156,160.68 159.56,157.12 159.56,153.82 158.44,152.7 158.44,151.26 159.3,150.39 159.94,150.39 160.83,149.5 160.83,147.72 161.84,146.71 161.84,145.18 161.08,144.42 161.08,143.02 160,141.94 158.86,141.94 156.76,139.85 156.76,137.56 152.01,132.81 152.01,126.82 153.21,125.63 161.72,125.63 v2(162.35,124.99)
  vias: v2(42.34,115.59)
PWM-VID: length 38.5
  TOP w0.114: PR9015.1 97.18,197.41 v1(97.07,197.51)
  IN4 w0.089: v1(114.68,179.8) 112.16,179.8 111.78,180.18 111.78,180.69 112.8,181.71 112.8,184.98 111.12,186.66 108.15,186.66 107.67,186.18 103.65,186.18 103.02,185.54 101.67,185.54 101.26,185.95 101.26,187.17 95.68,192.76 95.68,196.59 96.59,197.51 v1(97.07,197.51)
  BOTTOM w0.114: R370.2 115.14,179 v2(115.1,179) 114.94,179 114.68,179.27 v1(114.68,179.8)
PWRLED#: length 121.7
  TOP w0.114: v2(153.32,100.81) 153.32,100.72 152.94,100.34 U37.24 150.76,100.34 150.14,99.72 149.54,99.72 149.51,99.68 149.48,99.68 149.23,99.43 R67484.1
  IN3 w0.102: v2(153.32,100.81) 152.45,99.94 152.45,99.08 153.21,98.32 154.22,98.32 156.89,95.65 166.29,95.65 166.92,96.29 167.56,96.29 168.27,95.58 171.32,95.58 172.44,96.69 182.29,96.69 183.07,97.47 193.22,97.47 193.44,97.69 196.01,97.69 196.39,97.3 198.04,97.3 199.05,98.32 201.85,98.32 202.74,99.21 v2(203.25,99.21) 203.25,101.24 203.78,101.78 203.78,102.75 205.28,104.24 205.28,106.7 206.24,107.67 206.37,107.67 v2(206.67,107.97)
  IN4 w0.089: v2(225.22,119.66) 225.22,119.15 226.49,117.88 226.49,117.37 227.5,116.35 227.5,113.43 228.39,112.54 228.39,112.16 228.14,111.91 222.93,111.91 219.22,108.2 215.7,108.2 214.66,109.24 210.48,109.24 209.6,108.35 207.06,108.35 v2(206.67,107.97)
  BOTTOM w0.114: v2(225.22,119.66) 225.72,120.16 228.01,120.16 228.31,120.46 CN55.10 ; CN52.12 205.35,100.15 205.79,99.72 205.79,98.7 205.66,98.57 203.63,98.57 203.25,98.96 v2(203.25,99.21) ; v2(206.67,107.97) 206.67,109.5 204.39,111.78 203.83,111.78 202.95,112.67 CN48.20
R_SPK+: length 72.8
  IN4 w1.016: 47.56,92.9 44.67,90.01 37.96,90.01 34.81,86.86 34.81,80.12 33.45,78.76 33.45,64.26 32.86,63.67 32.86,42.26 29.23,38.63 28.2,38.63 26.93,37.36 22.76,37.36
  vias: v2(21.66,37.61) v2(21.66,36.95) v2(47.39,93.62) v2(47.72,94.21) v2(48.05,93.62)
R_SPK+_1: length 150.3
  TOP w1.016: 42.21,105.21 42.21,103.5 45.33,100.38 47.77,100.38 50.2,97.95 50.2,94.21
  IN3 w1.016: 87.17,194.84 86.43,194.1 76.14,194.1 75.03,192.99 72.38,192.99 70.32,195.05 66.32,195.05 60.78,189.51 60.78,181.47 55.02,175.71 46.25,175.71 42.12,171.59 42.12,158.14 41.91,157.92 41.91,119.67 41.4,119.17 41.4,107.53 41.54,107.39
  BOTTOM w1.016: CN63.1 94.8,200.95 94.15,200.3 88.82,200.3 87.93,199.41 87.93,198.27
  vias: v2(41.94,106.45) v2(42.6,106.45) v2(50.13,92.68) v2(87.56,196.65) v2(88.23,196.65)
R_SPK+_1_VIKI:
  vias: v2(46.75,97.21) v2(47.41,97.21) v2(47.54,96.29)
R_SPK-: length 69.2
  IN4 w1.016: 44.17,92.85 44.17,92.11 43.4,91.34 37.26,91.34 33.49,87.57 33.49,80.93 32.13,79.57 32.13,64.82 31.54,64.23 31.54,42.83 28.74,40.03 27.73,40.03 26.4,38.7 22.91,38.7
  vias: v2(21.02,37.44) v2(21.03,36.73) v2(43.78,93.62) v2(44.11,93.04) v2(44.44,93.62)
R_SPK-_1: length 162.2
  TOP w1.016: 43.61,104.16 43.61,103.99 45.88,101.72 48.47,101.72 51.53,98.65 51.53,92.09 50.6,91.16 46.71,91.16 46.27,91.59
  IN3 w1.016: 42.06,105.13 41.8,105.13 40.08,106.84 40.08,119.81 40.58,120.32 40.58,159.06 40.8,159.28 40.8,172.15 45.72,177.06 54.49,177.06 59.46,182.03 59.46,190.06 65.77,196.37 70.88,196.37 72.94,194.31 74.47,194.31 75.59,195.42 85.1,195.42
  BOTTOM w1.016: CN63.2 94.17,202.2 93.59,201.62 88.23,201.62 86.41,199.79 86.41,198.52
  vias: v2(43.25,105) v2(43.83,105.32) v2(46.02,91.08) v2(86.09,196.65) v2(86.75,196.65)
R_SPK-_1_VIKI:
  vias: v2(43.8,94.8) v2(44.46,94.8) v2(46.4,95.02)
REGN6V: length 5.2
  TOP w0.203: PR39.1 156.45,119.39 v2(155.98,118.92) 155.82,118.77 155.4,118.77 155.04,118.41 v2(154.54,118.41)
  BOTTOM w0.152: v2(154.54,118.41) 154.82,118.7 PC9.1 155.67,118.7 155.92,118.95 PU1.24
REQ_WLAN#: length 5.2
  TOP w0.114: v2(183.05,110.31) 183.05,110 183.41,109.65 R652.1 183.94,109.12 v2(184.13,108.92) 184.38,108.68 Q63.3
  BOTTOM w0.114: v2(183.05,110.31) 183.08,110.33 183.08,110.38 183.35,110.65 CN17.53
RESET#_USB: length 5.4
  TOP w0.114: v2(86.11,116.65) D13110.2 84.41,116.65 84.28,116.51 R68551.1 R68558.2 C96779.1 82.12,116.51 81.96,116.35 81.96,116.23 81.83,116.09 U6544.17
RF_EN: length 55.7
  TOP w0.114: R25318.2 169.59,95.02 169.82,94.79 172.84,94.79 v1(173.65,95.6)
  IN3 w0.102: v2(204.92,102.03) 204.92,101.5 205.91,100.51 205.91,98.7 205.79,98.57 204.39,98.57 202.61,96.8 201.21,96.8 200.53,96.11 195.56,96.11 194.9,95.45 180.72,95.45 180.54,95.63 173.68,95.63 v1(173.65,95.6)
  BOTTOM w0.114: v2(204.92,102.03) 203.55,103.4 202.48,103.4 201.59,102.51 200.2,102.51 199.41,103.3 199.41,106.04 199.26,106.19 198.67,106.19 197.63,107.24 196.41,107.24 196.29,107.11 R68691.2
RF_OFF#: length 5.6
  BOTTOM w0.114: R68691.1 R68693.1 R672.1 194.16,107.56 v2(193.63,108.09) 192.96,108.76 192.96,109.75 192.81,109.9 CN17.56
RING2: length 16.5
  IN4 w1.016: 21.44,26.32 20.84,25.72 15.88,25.72 15.41,26.18 15.41,27.2 14.78,27.84 13.89,27.84 13.51,27.45 8.49,27.45
  BOTTOM w0.203: U20.17 20.71,27.97 v2(20.94,27.75)
  vias: v2(5.94,27.71) v2(6.78,27.84) v2(7.44,27.84) v2(20.92,27.08)
ROM_CS: length 10.2
  TOP w0.102: v1(128.99,184.46) 127.84,183.31 127.84,182.65
  TOP w0.114: TP67.1 131.62,177.44 130.75,178.3 130.75,178.69 129.33,180.11 129.33,180.26 127.84,181.75 127.84,182.65
  BOTTOM w0.102: U8.D12 v1(128.99,184.46)
ROM_SCLK: length 7.7
  TOP w0.114: v1(128.66,182.1) 128.65,182.1 128.47,182.1 128.22,182.35 128.22,182.89 v1(128.96,183.63)
  BOTTOM w0.102: v1(128.66,182.1) 128.66,182.05 128.82,181.89 128.82,180.7 128.96,180.55 ; U8.C12 129.36,184.05 128.96,183.65 v1(128.96,183.63)
  BOTTOM w0.114: R342.1 129.71,178.4 R352.2 129.66,178.96 v2(129.99,179.3) 129.71,179.57 129.71,179.8 128.96,180.55
ROM_SI: length 7
  BOTTOM w0.102: 129.39,180.55 129.04,180.9 129.04,182.9 U8.B12
  BOTTOM w0.114: 129.39,180.55 130.24,179.7 130.34,179.7 130.84,179.19 R350.2 131.08,179.19 v2(131.08,178.38) 131.44,178.02 R341.1
ROM_SO: length 8.3
  BOTTOM w0.102: 133.68,180.08 133.55,180.21 131.08,180.21 129.38,181.91 U8.A12
  BOTTOM w0.114: 133.68,180.08 133.8,179.96 v2(133.8,179.24) 133.14,179.24 R351.2 133.11,178.94 132.89,178.71 132.79,178.71 132.66,178.58 R343.1
RREF: length 2
  BOTTOM w0.254: U40.1 27.89,63.34 v2(27.4,63.83) 26.79,64.44 R752.2
RREF_U2_HUB: length 2.6
  TOP w0.114: U6544.8 84.25,111.17 84.37,111.04 v2(84.37,109.75) 84.37,109.47 R68561.2
RSET: length 5.8
  TOP w0.203: U6521.12 24.09,168.21 24.23,168.34 24.23,169.62 24.51,169.9 24.51,170.91 24.75,171.15 v2(25.13,171.15) 25.45,171.47 R4009.1 R67477.2
RSMRST#: length 130.9
  TOP w0.114: v1(85.36,119.25) 85.42,119.3 R68954.1 ; v2(145.88,96.45) 145.88,96 146.22,95.65 146.73,95.65 146.98,95.4 146.98,94.76 147.24,94.51 150.67,94.51 152.19,96.03 152.19,96.29 152.45,96.54 153.21,96.54 153.84,97.18 153.84,97.3 155.16,98.62 155.16,99.89 155.8,100.53 155.8,102.09 157.11,103.4 159.05,103.4 159.43,103.78 159.43,108.99 159.86,109.42 U37.112
  IN1 w0.089: v2(145.88,96.45) 145.31,97.02 137.87,97.02 137.08,97.81 135.48,97.81 134.95,97.28 120.29,97.28 119.93,96.92 118.59,96.92 116.48,94.81 96.39,94.81 95.8,95.4 92.37,95.4 91.87,94.89 82.98,94.89 81.58,96.29 80.44,96.29 78.66,98.07 78.66,99.08 79.17,99.59 v1(79.17,100.48)
  IN4 w0.089: v1(84.96,102.89) 84.58,102.51 84.12,102.51 83.94,102.69 83.94,103.2 83.74,103.4 79.93,103.4 79.04,102.51 79.04,100.61 v1(79.17,100.48)
  BOTTOM w0.114: v1(84.96,102.89) 84.96,103.17 82.53,105.6 82.53,107.08 82.65,107.2 82.65,109.25 82.53,109.37 82.53,110.07 81.99,110.61 81.99,114.6 85.36,117.98 v1(85.36,119.25)
RSMRST#_R: length 28.5
  TOP w0.114: v1(86.74,120.44) 86.28,119.99 R68954.2 85.93,119.75 85.77,119.91 R68476.2 R68470.2
  IN3 w0.089: v1(109.02,124.99) 108.66,124.63 108.66,123.49 108.63,123.47
  IN3 w0.102: 108.63,123.47 107.54,122.37 98.9,122.37 98.72,122.2 97.2,122.2 96.82,122.58 92.88,122.58 92.5,122.2 89.45,122.2 88.46,121.21 86.94,121.21 86.74,121 v1(86.74,120.44)
  BOTTOM w0.102: v1(109.02,124.99) 109.01,124.99 109.01,125 108.83,125 U6539.DM35
RSVD_TP_2: length 18.8
  TOP w0.089: 122.6,151.66 122.57,151.63 119.17,151.63 v1(118.53,152.26)
  TOP w0.114: 122.6,151.66 123.36,151.66 124.11,150.91 128.94,150.91 129.18,150.67 133.19,150.67 TP13276.1
  BOTTOM w0.102: U6539.AL10 118.8,152 v1(118.53,152.26)
RSVD_TP_3: length 17.4
  TOP w0.089: v1(118.54,151.66) 118.74,151.45 122.48,151.45 122.65,151.28 123.11,151.28
  TOP w0.114: TP13277.1 133.82,150.4 129.07,150.4 128.83,150.64 123.75,150.64 123.11,151.28
  BOTTOM w0.102: U6539.AM12 118.66,151.54 v1(118.54,151.66)
RSVD_TP_4: length 16
  TOP w0.089: 122.6,152.68 122.46,152.53 119.48,152.53 v1(118.54,153.47)
  TOP w0.114: TP13279.1 131.83,152 128.78,152 128.23,151.45 124.59,151.45 123.36,152.68 122.6,152.68
  BOTTOM w0.102: U6539.AH12 118.64,153.37 v1(118.54,153.47)
RSVD_TP_5: length 17.2
  TOP w0.089: 122.6,152.31 122.56,152.36 119.06,152.36 v1(118.57,152.85)
  TOP w0.114: TP13281.1 133.4,151.3 133.03,150.94 129.29,150.94 129.05,151.18 124.47,151.18 123.34,152.31 122.6,152.31
  BOTTOM w0.102: v1(118.57,152.85) 118.62,152.91 U6539.AJ10
RSVD_TP_6: length 3.3
  BOTTOM w0.102: U6539.AR1 124.26,150.38 124.55,150.09 126.59,150.09 126.64,150.14 TP13282.1
RSVD_TP_7: length 8.6
  BOTTOM w0.102: U6539.A51 101.14,165.54 100.83,165.22 100.51,165.22 100.3,165.44 99.67,165.44
  BOTTOM w0.114: TP13258.1 96.57,166.27 97.58,165.25 99.49,165.25 99.67,165.44
RSVD_TP_8: length 8.6
  BOTTOM w0.102: 99.92,164.72 100.53,164.72 100.67,164.58 100.95,164.58 101.28,164.91 U6539.B51
  BOTTOM w0.114: TP13256.1 93.64,165.25 95.93,165.25 96.46,164.72 99.92,164.72
RSVD_TP_9: length 5.7
  BOTTOM w0.102: U6539.C1 124.63,165.24 124.63,166.65
  BOTTOM w0.114: TP13253.1 124.63,167.92 124.63,166.65
RSVD_TP_10: length 5.6
  BOTTOM w0.102: TP13254.1 124.76,168.55 124.25,168.04 124.25,165.33 123.27,164.35 U6539.D2
RSVD_TP_11: length 1.6
  TOP w0.102: 106.98,131.98 107.05,131.98 v1(107.19,131.83)
  TOP w0.114: 106.98,131.98 TP13259.1
  BOTTOM w0.102: v1(107.19,131.83) 107.13,131.83 106.74,132.23 U6539.CP39
RSVD_TP_12: length 2.1
  TOP w0.114: TP13261.1 106.47,130.71 v1(106.9,130.27)
  BOTTOM w0.102: v1(106.9,130.27) 106.88,130.3 106.84,130.3 ; 106.72,130.3 106.27,130.75 U6539.CU40
  BOTTOM w0.114: 106.84,130.3 106.73,130.3 106.72,130.3
RSVD_TP_13: length 5.9
  BOTTOM w0.102: U6539.DV4 123.1,121.45 123.1,121.16 123.51,120.75 123.51,120.53 124.25,119.78
  BOTTOM w0.114: TP13263.1 125.39,117.37 125.39,117.5 125.14,117.75 125.14,118.84 124.25,119.73 124.25,119.78
RSVD_TP_14: length 6.5
  BOTTOM w0.102: U6539.DW3 122.78,121.19 123.29,120.68 123.29,120.37 123.71,119.95
  BOTTOM w0.114: 123.71,119.95 124.86,118.79 124.86,117.65 125.01,117.5 125.01,116.48 TP13264.1
RSVD_TP_15: length 5.5
  BOTTOM w0.102: U6539.DU1 124.16,122.42 124.51,122.07 124.99,122.07 125.85,121.21 125.85,121.18
  BOTTOM w0.114: TP13267.1 127.86,121 126.03,121 125.85,121.18
RSVD_TP_16: length 7.8
  BOTTOM w0.102: U6539.DT2 123.43,122.75 124.21,122.75 124.63,122.32 125.04,122.32 126.13,121.23 128.14,121.23 128.44,120.93
  BOTTOM w0.114: 128.44,120.93 128.57,120.8 129.08,120.8 TP13269.1
RSVD_TP_17: length 7.1
  BOTTOM w0.102: U6539.DW2 123.74,120.99 123.74,120.65 124.2,120.19 124.53,120.19
  BOTTOM w0.114: TP13270.1 126.16,116.74 126.16,118.16 125.19,119.12 125.19,119.99 124.99,120.19 124.53,120.19
RSVD_TP_18: length 6.5
  BOTTOM w0.102: 124.76,120.42 124.3,120.42 124,120.72 124,121.21 123.28,121.93 U6539.DV2
  BOTTOM w0.114: 124.76,120.42 125.14,120.42 125.45,120.11 125.45,119.28 126.44,118.28 126.44,117.73 TP13271.1
RSVD_TP_19: length 8.4
  BOTTOM w0.102: 124.88,164.61 124.15,163.87 U6539.E1
  BOTTOM w0.114: 124.88,164.61 125.27,165 125.27,167.61 126.82,169.16 126.82,169.97 127.3,170.46 TP13272.1
RSVD_TP_20: length 8.2
  BOTTOM w0.102: U6539.F1 124.88,164.18 ; 125.52,166.77 126.03,167.28 127.05,167.28
  BOTTOM w0.114: 125.52,166.77 125.52,164.82 124.88,164.18 ; TP13273.1 127.39,169.22 127.39,167.62 127.05,167.28
RSVD_TP_21: length 8.4
  BOTTOM w0.102: 128.44,121.31 128.32,121.43 126.23,121.43 125.14,122.53 124.84,122.53 124.41,122.96 124.02,122.96 U6539.DR1
  BOTTOM w0.114: TP13274.1 130.98,120.67 129.59,120.67 129.15,121.1 128.65,121.1 128.44,121.31
RSVD_TP_22: length 7.3
  BOTTOM w0.102: 128.44,121.64 126.36,121.64 125.22,122.78 124.97,122.78 124.59,123.17 124.3,123.17 124.07,123.39 123.4,123.39 U6539.DR2
  BOTTOM w0.114: 128.44,121.64 128.75,121.64 129,121.38 129.64,121.38 TP13275.1
RSVD_TP_23: length 9.4
  BOTTOM w0.102: U6539.DR53 100.03,123.03 99.21,122.2 99.21,121.66 98.72,121.18 98.47,120.93 95.85,120.93 95.37,120.44 ; 93.21,119.61 TP13278.1
  BOTTOM w0.114: 93.21,119.61 94.05,120.44 95.37,120.44
RSVD_TP_24: length 4.9
  BOTTOM w0.102: U6539.DW5 122.22,121.22 122.22,121.05 122.47,120.8 122.52,120.8 122.85,120.47 122.85,120.11 123.02,119.95
  BOTTOM w0.114: TP13280.1 124.25,117.47 124.25,118.72 123.02,119.95
RSVD_TP_26: length 11.1
  TOP w0.114: TP13426.1 123.67,130.43 123.67,131.29 123.11,131.85 122.22,131.85 121.77,132.3 120.01,132.3 118.92,131.21 116.58,131.21 v1(116.38,131.01)
  BOTTOM w0.102: U6539.CY15 116.48,131.01 v1(116.38,131.01)
RSVD_TP_39: length 23.1
  TOP w0.114: v1(123.49,118.59) 123.49,118.77 123.11,119.15 TP13425.1
  IN4 w0.089: v1(112.11,130.31) 112.05,130.31 111.73,129.99 111.73,128.11 111.98,127.86 114.93,127.86 115.11,128.04 115.62,128.04 115.87,127.78 115.87,122.58 116.38,122.07 117.52,122.07 118.28,121.31 120.39,121.31 121.18,120.52 121.18,120.19 121.92,119.45 122.63,119.45 v1(123.49,118.59)
  BOTTOM w0.102: U6539.CY28 v1(112.11,130.31)
RT3612_ALERT#: length 2.6
  BOTTOM w0.152: PU7000.3 161.96,148.71 PR7049.2
RT3612_BOOT2:
  vias: v2(160.24,149.96)
RT3612_COMP: length 5
  BOTTOM w0.178: PU7000.15 161.41,143.01 161.41,142.62 161.97,142.06 161.97,141.74 162.16,141.55 162.65,141.55 163.15,141.05 PC7040.2 PR7054.1
RT3612_FB: length 8.3
  BOTTOM w0.178: PU7000.16 161.08,142.77 161.08,142.47 161.64,141.91 161.64,141.58 162.17,141.04 PC7040.1 PR7054.2 162.37,139.72 162.74,139.35 v2(163.87,139.35) 164.1,139.57 PR7055.1 PC7041.2
RT3612_IMON: length 2.6
  BOTTOM w0.178: PR7061.2 163.24,144.12 v4(163.14,144.22) 162.94,144.42 162.26,144.42 162.25,144.43 PU7000.11
RT3612_ISEN1N: length 2.1
  BOTTOM w0.178: PR7039.2 158.52,142.36 158.61,142.46 158.61,143.49 158.62,143.49 158.62,143.67 PU7000.19
RT3612_ISEN1P: length 5.7
  BOTTOM w0.178: PU7000.20 158.19,143.81 v4(158.19,142.93) 157.84,142.58 156.96,142.58 156.48,142.09 PC7034.2 PR7038.1 156.1,140.75 PR7036.1
RT3612_ISEN2N: length 1.9
  BOTTOM w0.178: PR7048.2 159.24,142.33 158.95,142.62 158.95,143.35 158.95,143.36 158.95,143.44 PU7000.18
RT3612_ISEN2P: length 5.2
  BOTTOM w0.178: PR7044.1 161.36,140.44 PR7047.1 PC7036.2 161.14,141.82 160.84,142.12 160.59,142.12 v2(160.24,142.47) 159.71,142.47 159.3,142.87 159.3,143.23 PU7000.17
RT3612_LG1: length 11.8
  IN4 w0.508: v2(149.3,147.42) 150.01,148.13 155.6,148.13 v2(155.75,147.98)
  BOTTOM w0.178: PU7000.28 157.47,148.08 157.22,148.08 157.17,148.13
  BOTTOM w0.508: PQ7000.8 149.14,147.27 v2(149.3,147.42) ; v2(155.75,147.98) v2(156.26,148.49) 156.61,148.13 157.17,148.13
RT3612_LG2: length 23.3
  IN2 w0.508: v2(157.38,149.71) 156.93,150.16 156.93,150.17 153.72,153.39 153.72,160.4 150.34,163.78 v2(150.34,165.86)
  BOTTOM w0.178: PU7000.30 158.14,148.55 158.14,148.69
  BOTTOM w0.508: v2(150.34,165.86) 150.34,165.78 151.13,165 PQ7001.8 ; 158.14,148.69 157.93,148.9 157.93,149.16 v2(157.38,149.71)
RT3612_PHASE1: length 16.3
  IN4 w0.508: v2(156.46,147.42) 151.68,142.64 148.89,142.64 148.38,143.15 148.38,148.1 v2(149.14,148.87)
  vias: v2(157.14,147.47)
RT3612_PHASE2: length 24.1
  IN2 w0.508: v2(148.22,166) 149.14,166.93 150.97,166.93 151.48,166.42 151.48,164.18 154.9,160.77 154.9,153.27 158.72,149.45 v2(158.72,149.2)
  vias: v2(146.86,166.52)
RT3612_PSYS: length 5.6
  BOTTOM w0.178: 163.53,145.69 162.61,145.69 PU7000.9
  BOTTOM w0.203: PR7051.2 167.08,144.77 167.04,144.81 PR7053.1 166.04,144.81 166.01,144.77 PC7042.2 164.44,144.77 v2(164.09,145.12) 163.53,145.69
