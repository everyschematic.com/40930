# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ34: length 53.5
  IN3 w0.089: v1(99.31,167.41) 99.31,166.47 99.11,166.27 97.34,166.27 97.33,166.26 88.83,166.26 88.78,166.3 74.12,166.3 71.29,163.47 70.81,163.47 70.68,163.34 70.68,162.86 70.2,162.38 68.83,162.38 68.63,162.58 68.63,163.39 68.5,163.52 68.16,163.52 68.07,163.43 68.07,162.54 67.98,162.46 67.71,162.46 67.62,162.54 67.62,163.43 67.53,163.52 66.36,163.52 66.27,163.43 66.27,162.54 66.18,162.46 65.91,162.46 65.82,162.54 65.82,163.43 65.74,163.52 62.96,163.52 62.83,163.39 v2(62.83,162.67)
  BOTTOM w0.079: 102.8,166 103.02,165.78 103.02,165.32 103.37,164.97 U6539.B46
  BOTTOM w0.102: 101.01,166.65 101.65,166.65 102.23,166.06 102.74,166.06 102.8,166
  BOTTOM w0.114: 101.01,166.65 99.87,166.65 99.31,167.2 v1(99.31,167.41) ; JDIM02.37 64.44,162.57 63.86,163.16 63.32,163.16 v2(62.83,162.67)
M_B_DQ35: length 52.8
  IN3 w0.089: v1(99.92,167.41) 99.92,166.57 99.35,166 86.27,166 86.23,165.96 74.27,165.96 70.34,162.04 65.36,162.04 65.27,162.12 65.27,163.09 65.18,163.18 64.92,163.18 64.83,163.09 64.83,162.12 64.74,162.04 61.17,162.04 60.62,162.58 59.57,162.58 v2(59.07,162.08)
  BOTTOM w0.079: 102.81,166.25 103.35,165.7 U6539.A46
  BOTTOM w0.102: 99.92,167.14 99.92,167.1 100.12,166.9 101.77,166.9 102.41,166.27 102.79,166.27 102.81,166.25
  BOTTOM w0.114: v2(59.07,162.08) 58.31,161.32 JDIM02.42 ; v1(99.92,167.41) 99.92,167.14
M_B_DQ36: length 55.6
  IN3 w0.089: v1(104.19,168.93) 104.06,168.81 92.63,168.81 92.48,168.65 86.81,168.65 86.03,169.44 84.75,169.44 84.37,169.06 73.05,169.06 70.75,166.76 59.63,166.76 v2(58.63,165.76)
  BOTTOM w0.079: 105.12,166.51 105.12,166 105.23,165.9 105.23,165.18 105.16,165.11 105.16,164.66 105.06,164.56 105.06,164.03 U6539.E44
  BOTTOM w0.102: v1(104.19,168.93) 104.97,168.14 104.97,166.75 105.12,166.6 105.12,166.51
  BOTTOM w0.114: JDIM02.28 57.98,164.82 58.47,165.31 58.47,165.59 v2(58.63,165.76)
M_B_DQ37: length 55.2
  IN3 w0.089: v2(59.95,165.76) 60.6,166.41 63.19,166.41 63.58,166.01 63.85,166.01 63.94,166.1 63.94,166.32 64.03,166.41 64.3,166.41 64.38,166.32 64.38,166.1 64.47,166.01 64.74,166.01 64.83,166.1 64.83,166.32 64.92,166.41 70.93,166.41 73.2,168.68 84.12,168.68 84.4,168.4 89.99,168.4 90.34,168.04 92.12,168.04 92.5,168.42 103.91,168.42 v1(104.06,168.27)
  BOTTOM w0.079: 104.92,166.42 104.92,165.92 105.06,165.78 105.06,165.25 104.98,165.17 104.98,164.75 104.77,164.54 U6539.D43
  BOTTOM w0.102: 104.92,166.42 104.77,166.57 104.77,167.84 104.34,168.27 v1(104.06,168.27)
  BOTTOM w0.114: JDIM02.24 57.97,165.82 58.18,166.04 58.18,166.22 58.56,166.6 59.12,166.6 v2(59.95,165.76)
M_B_DQ38: length 54.2
  IN3 w0.089: v1(104.39,167.41) 104.01,167.79 103.93,167.79 103.6,168.12 92.58,168.12 92.25,167.79 90.22,167.79 89.86,168.14 84.15,168.14 83.99,168.3 73.32,168.3 70.66,165.63 70.4,165.63 70.28,165.76 70.28,165.88 70.15,166.01 69.9,166.01 69.77,165.88 69.77,165.68 69.68,165.59 69.42,165.59 69.33,165.68 69.33,165.92 69.24,166.01 68.97,166.01 68.88,165.92 68.88,165.68 68.79,165.59 68.53,165.59 68.44,165.68 68.44,165.92 68.35,166.01 68.08,166.01 67.99,165.92 67.99,165.68 67.9,165.59 67.64,165.59 67.55,165.68 67.55,165.92 67.46,166.01 67.19,166.01 67.1,165.92 67.1,165.68 67.01,165.59 66.75,165.59 66.66,165.68 66.66,165.92 66.57,166.01 66.3,166.01 66.21,165.92 66.21,165.68 66.13,165.59 65.86,165.59 65.77,165.68 65.77,165.92 65.68,166.01 65.34,166.01 65.25,165.92 65.25,165.68 65.16,165.59 62.76,165.59 v2(62.6,165.76)
  BOTTOM w0.079: U6539.B43 104.69,165.12 104.89,165.32 104.89,165.72 104.75,165.87 104.75,166.33 104.39,166.7 104.39,166.8
  BOTTOM w0.102: v1(104.39,167.41) 104.39,166.8
  BOTTOM w0.114: JDIM02.29 64.14,164.57 63.8,164.23 63.16,164.23 62.6,164.8 v2(62.6,165.76)
M_B_DQ39: length 53.7
  IN3 w0.089: v2(61.28,165.76) 61.79,165.25 70.78,165.25 73.43,167.89 89.73,167.89 90.09,167.54 92.43,167.54 92.71,167.81 101.27,167.81 101.36,167.73 101.36,166.48 101.45,166.39 101.71,166.39 101.8,166.48 101.8,167.73 101.89,167.81 103.37,167.81 v1(103.78,167.41)
  BOTTOM w0.079: U6539.A43 104.56,165.61 104.56,166.14 104.06,166.65 104.06,166.8
  BOTTOM w0.102: v1(103.78,167.41) 104.06,167.13 104.06,166.8
  BOTTOM w0.114: v2(61.28,165.76) 61.28,165.77 61.77,166.27 63.04,166.27 63.73,165.57 JDIM02.25
M_B_DQ40: length 60.9
  IN3 w0.089: v2(62.78,168.42) 62.4,168.81 62.4,169.06 62.66,169.31 63.91,169.31 64,169.22 64,168.15 64.09,168.06 64.36,168.06 64.45,168.15 64.45,169.22 64.53,169.31 64.8,169.31 64.89,169.22 64.89,168.15 64.98,168.06 65.25,168.06 65.33,168.15 65.33,169.22 65.42,169.31 65.69,169.31 65.78,169.22 65.78,168.15 65.87,168.06 66.13,168.06 66.22,168.15 66.22,169.22 66.31,169.31 66.58,169.31 66.67,169.22 66.67,168.51 66.76,168.42 69.26,168.42 71.18,170.34 83.65,170.34 83.87,170.56 87.17,170.56 87.52,170.2 88.95,170.2 89.35,170.61 89.81,170.61 90.22,170.2 105.2,170.2 105.74,169.67 105.74,167.76 v1(106.34,167.15)
  BOTTOM w0.079: 106.24,166.8 106.24,166.54 106.09,166.39 106.09,165.56 U6539.A40
  BOTTOM w0.102: v1(106.34,167.15) 106.24,167.05 106.24,166.8
  BOTTOM w0.114: JDIM02.17 63.64,167.57 v2(62.78,168.42)
M_B_DQ41: length 61.8
  IN3 w0.089: v2(59.74,168.4) 59.74,167.84 59.87,167.71 60.28,167.71 60.37,167.8 60.37,168.97 60.46,169.06 60.72,169.06 60.81,168.97 60.81,167.8 60.9,167.71 67.21,167.71 67.29,167.8 67.29,167.99 67.38,168.08 67.65,168.08 67.74,167.99 67.74,167.8 67.83,167.71 68.09,167.71 68.18,167.8 68.18,167.99 68.27,168.08 68.54,168.08 68.63,167.99 68.63,167.8 68.72,167.71 69.06,167.71 70.24,168.89 70.36,168.89 70.55,168.7 70.68,168.7 70.87,168.89 70.87,169.01 70.68,169.2 70.68,169.33 70.86,169.52 70.99,169.52 71.5,169.01 71.62,169.01 71.81,169.2 71.81,169.32 71.45,169.69 71.45,169.87 71.57,170 84.07,170 84.27,170.2 86.91,170.2 87.35,169.77 104.69,169.77 104.82,169.64 104.82,168.86 105.05,168.63 v1(105.35,168.63)
  BOTTOM w0.079: 105.91,166.8 105.91,165.78 105.83,165.69 105.83,165.29 106.07,165.05 U6539.B40
  BOTTOM w0.102: v1(105.35,168.63) 105.94,168.04 105.94,166.82 105.91,166.8
  BOTTOM w0.114: v2(59.74,168.4) 59.74,167.68 58.97,166.9 58.34,166.9 58.26,166.82 JDIM02.20
M_B_DQ42: length 62.4
  IN3 w0.089: v2(58.41,168.4) 58.38,168.42 58.08,168.42 57.96,168.3 57.96,166.52 58.08,166.39 58.34,166.39 58.47,166.52 58.47,167.66 58.59,167.79 58.97,167.79 59.4,167.36 69.21,167.36 69.39,167.54 69.64,167.54 69.82,167.36 70.12,167.36 70.25,167.49 70.25,167.69 69.99,167.95 69.99,168.13 70.15,168.3 70.4,168.3 70.83,167.87 71.01,167.87 71.14,168 71.14,168.13 70.93,168.34 70.93,168.46 71.12,168.65 71.25,168.65 71.46,168.44 71.58,168.44 72.25,169.11 72.25,169.53 72.38,169.66 84.34,169.66 84.5,169.82 86.8,169.82 86.89,169.73 86.89,169.21 87.04,169.06 88.56,169.06 89,169.49 104.45,169.49 104.58,169.36 104.58,168.74 105.33,167.99 v1(105.35,167.99)
  BOTTOM w0.079: 105.71,166.8 105.71,165.79 105.64,165.73 105.64,165.25 105.78,165.11 105.78,164.59 U6539.D40
  BOTTOM w0.102: 105.71,166.8 105.71,167 105.74,167.03 105.74,167.84 105.58,167.99 v1(105.35,167.99)
  BOTTOM w0.114: v2(58.41,168.4) 58.51,168.29 58.51,167.95 58.39,167.82 JDIM02.16
M_B_DQ43: length 63.7
  IN3 w0.089: v2(59.89,171.75) 60.27,171.37 69.03,171.37 69.26,171.6 69.26,172.49 69.43,172.65 90.69,172.65 90.98,172.36 92.37,172.36 92.5,172.49 92.5,173 92.79,173.29 94.62,173.29 95.78,172.13 106.83,172.13 108.25,170.71 108.25,169.69 108,169.44 108,169.24 107.61,168.86 v1(107.56,168.86)
  BOTTOM w0.079: 107.18,166.49 107.18,166.37 107.2,166.35 107.2,165.82 107.08,165.7 107.08,164.54 107.02,164.47 107.02,163.8 106.83,163.62 106.59,163.62 106.59,163.62 U6539.E41
  BOTTOM w0.102: 107.22,168.51 107.18,168.47 107.18,166.49
  BOTTOM w0.114: v2(59.89,171.75) 59.89,171.63 58.08,169.82 JDIM02.8 ; v1(107.56,168.86) 107.22,168.51
M_B_DQ44: length 61.3
  IN3 w0.089: v1(107.59,167.61) 107.57,167.64 106.24,167.64 105.94,167.94 105.94,169.85 105.23,170.56 90.47,170.56 90.08,170.95 89.19,170.95 88.82,170.58 87.75,170.58 87.42,170.91 83.36,170.91 83.15,170.71 70.79,170.71 69.32,169.24 69.32,168.97 69.23,168.88 68.97,168.88 68.88,168.97 68.88,169.61 68.79,169.69 68.52,169.69 68.43,169.61 68.43,168.97 68.34,168.88 68.08,168.88 67.99,168.97 67.99,169.61 67.9,169.69 67.63,169.69 67.54,169.61 67.54,169.27 67.46,169.19 67.19,169.19 67.1,169.27 67.1,169.44 66.85,169.69 62.15,169.69 61.28,168.82 v2(61.28,168.43)
  BOTTOM w0.079: 107.46,166.84 107.46,166.75 107.36,166.65 107.36,165.59 U6539.A38
  BOTTOM w0.102: 107.46,166.84 107.46,167.48 107.59,167.61 v1(107.59,167.61)
  BOTTOM w0.114: v2(61.28,168.43) 61.28,167.39 61.48,167.19 62.8,167.19 63.41,166.57 JDIM02.21
M_B_DQ45: length 62.1
  IN3 w0.089: v2(58.62,171.74) 59.33,171.02 69.32,171.02 69.64,171.35 69.64,172.11 69.85,172.31 90.52,172.31 91.04,171.79 93.49,171.79 93.58,171.88 93.58,172.58 93.71,172.71 93.9,172.71 94.03,172.58 94.03,171.92 94.16,171.79 94.38,171.79 94.47,171.88 94.47,172.26 94.56,172.35 94.82,172.35 94.92,172.25 94.92,171.88 95.01,171.79 106.54,171.79 108,170.33 108,169.82 107.64,169.46 v1(107.59,169.46)
  BOTTOM w0.079: 107.67,166.7 107.53,166.56 107.53,165.39 107.3,165.16 U6539.B38
  BOTTOM w0.102: 108,167.77 108,167.28 107.67,166.95 107.67,166.7
  BOTTOM w0.114: 108,167.77 108,169.06 v1(107.59,169.46) ; JDIM02.4 58.07,170.82 58.62,171.37 v2(58.62,171.74)
M_B_DQ46: length 62.8
  IN3 w0.089: v2(63.98,172.23) 63.98,173.07 64.28,173.38 65.23,173.38 65.32,173.29 65.32,172.45 65.41,172.36 65.68,172.36 65.76,172.45 65.76,173.29 65.85,173.38 66.12,173.38 66.21,173.29 66.21,172.45 66.3,172.36 66.56,172.36 66.65,172.45 66.65,173.29 66.74,173.38 67.01,173.38 67.1,173.29 67.1,172.45 67.19,172.36 67.45,172.36 67.54,172.45 67.54,173.29 67.63,173.38 87.55,173.38 88.28,174.11 94.82,174.11 96.06,172.87 107.11,172.87 108.95,171.03 108.95,169.38 v1(108.63,169.06)
  BOTTOM w0.079: 107.87,166.65 107.69,166.47 107.69,165.31 107.53,165.15 107.53,164.46 U6539.D38
  BOTTOM w0.102: 108.24,167.15 107.87,166.77 107.87,166.65
  BOTTOM w0.114: v2(63.98,172.23) 64.17,172.04 64.17,171.22 64.33,171.07 JDIM02.3 ; v1(108.63,169.06) 108.24,168.67 108.24,167.15
M_B_DQ47: length 63.8
  IN3 w0.089: v1(108.63,167.79) 108.24,168.18 108.24,169.31 108.63,169.69 108.63,170.84 106.99,172.48 95.94,172.48 94.79,173.63 92.5,173.63 91.61,172.74 91.1,172.74 90.4,173.45 90.22,173.45 89.89,173.12 89.71,173.12 89.07,173.76 88.44,173.76 87.68,173 68.96,173 68.87,172.91 68.87,171.81 68.78,171.73 68.51,171.73 68.42,171.81 68.42,172.91 68.33,173 68.12,173 67.99,172.87 67.99,171.88 67.86,171.75 62.88,171.75 v2(62.65,171.98)
  BOTTOM w0.079: U6539.E38 107.3,163.82 107.7,164.22 107.7,165.1 107.85,165.24 107.85,166.37 108.12,166.65
  BOTTOM w0.102: 108.62,167.15 108.12,166.65
  BOTTOM w0.114: 108.62,167.15 108.63,167.15 v1(108.63,167.79) ; v2(62.65,171.98) 63.01,171.63 63.01,171.3 64.23,170.07 JDIM02.7
M_B_DQ48: length 55.9
  IN3 w0.089: v2(60.47,151.01) 60.47,151.66 60.6,151.79 64.43,151.79 64.66,152.01 64.78,152.01 65.04,151.75 65.16,151.75 65.35,151.94 65.35,152.07 65.1,152.32 65.1,152.45 66.47,153.82 67.55,153.82 76.45,162.72 86.63,162.72 87.76,163.85 99.69,163.85 99.82,163.73 99.82,163.47 99.69,163.34 99.23,163.34 99.03,163.14 99.03,162.93 99.76,162.2 102.28,162.2 102.35,162.27 102.96,162.27 v1(102.96,162.27)
  BOTTOM w0.102: v1(102.96,162.27) 103.21,162.02 U6539.J47
  BOTTOM w0.114: JDIM02.80 59.85,151.82 60.47,151.2 v2(60.47,151.01)
M_B_DQ49: length 55.1
  IN3 w0.089: v2(63.28,154.26) 63.85,153.69 64.31,153.69 66.44,155.82 66.62,155.82 67.1,155.34 67.23,155.34 67.47,155.59 67.47,155.71 66.96,156.22 66.96,156.35 67.15,156.54 67.28,156.54 67.79,156.03 67.91,156.03 68.1,156.21 68.1,156.34 67.59,156.85 67.59,156.98 67.78,157.16 67.91,157.16 68.42,156.65 68.54,156.65 68.73,156.84 68.73,156.97 68.22,157.48 68.22,157.6 68.41,157.79 68.53,157.79 69.04,157.28 69.17,157.28 69.41,157.53 69.41,157.65 69.09,157.97 69.09,158.1 69.28,158.29 69.41,158.29 69.73,157.97 69.85,157.97 75.83,163.94 86.62,163.94 87.3,164.61 102.28,164.61 102.41,164.49 102.41,163.78 102.92,163.26 v1(102.92,163.25)
  BOTTOM w0.102: U6539.G47 103.21,162.96 102.93,163.25 v1(102.92,163.25)
  BOTTOM w0.114: JDIM02.71 64.34,154.07 63.82,153.56 63.37,153.56 63.28,153.65 v2(63.28,154.26)
M_B_DQ50: length 56.6
  IN3 w0.089: v2(63.35,151.19) 63.81,150.73 64.65,150.73 65.91,151.99 65.91,152.12 65.72,152.31 65.72,152.44 65.91,152.63 66.03,152.63 66.23,152.43 66.65,152.43 67.17,152.95 67.29,152.95 67.41,152.84 67.54,152.84 67.73,153.02 67.73,153.15 67.61,153.27 67.61,153.39 67.8,153.58 67.92,153.58 68.04,153.46 68.17,153.46 68.36,153.65 68.36,153.78 68.24,153.9 68.24,154.02 68.43,154.21 68.55,154.21 68.67,154.09 68.8,154.09 68.98,154.28 68.98,154.41 68.87,154.53 68.87,154.65 69.05,154.84 69.18,154.84 69.3,154.72 69.42,154.72 69.61,154.91 69.61,155.04 69.49,155.15 69.49,155.28 69.68,155.47 69.81,155.47 69.93,155.35 70.05,155.35 70.24,155.54 70.24,155.66 70.12,155.78 70.12,155.91 70.31,156.1 70.44,156.1 70.56,155.98 70.68,155.98 70.87,156.17 70.87,156.29 70.75,156.41 70.75,156.54 70.94,156.73 71.07,156.73 71.19,156.61 71.31,156.61 71.5,156.8 71.5,156.92 71.38,157.04 71.38,157.17 71.57,157.36 71.7,157.36 71.81,157.24 71.94,157.24 72.13,157.43 72.13,157.55 72.01,157.67 72.01,157.8 72.2,157.98 72.32,157.98 72.44,157.87 72.57,157.87 72.76,158.05 72.76,158.18 72.64,158.3 72.64,158.42 72.83,158.61 72.95,158.61 73.07,158.49 73.2,158.49 73.39,158.68 73.39,158.81 73.27,158.93 73.27,159.05 73.46,159.24 73.58,159.24 73.7,159.12 73.83,159.12 74.01,159.31 74.01,159.44 73.9,159.56 73.9,159.68 74.09,159.87 74.21,159.87 74.33,159.75 74.45,159.75 74.64,159.94 74.64,160.07 74.53,160.18 74.53,160.31 74.71,160.5 74.84,160.5 74.96,160.38 75.08,160.38 75.27,160.57 75.27,160.7 75.15,160.81 75.15,160.94 76.59,162.38 86.65,162.38 87.87,163.6 98.04,163.6 99.75,161.89 103.17,161.89 103.54,162.27 v1(103.62,162.27)
  BOTTOM w0.102: v1(103.62,162.27) 103.86,162.03 U6539.J45
  BOTTOM w0.114: v2(63.35,151.19) 63.35,150.98 63.69,150.64 64.07,150.64 64.5,151.07 JDIM02.83
M_B_DQ51: length 55.9
  IN3 w0.089: v1(103.6,163.25) 103.6,163.93 102.66,164.87 87.04,164.87 86.46,164.28 75.53,164.28 70.48,159.23 70.35,159.23 69.91,159.67 69.78,159.67 69.59,159.48 69.59,159.36 70.01,158.94 70.01,158.76 69.86,158.61 69.68,158.61 69.29,159 69.11,159 64.84,154.73 63.14,154.73 62.82,154.4 62.82,153.73 62.69,153.6 60.99,153.6 60.65,153.95 60.15,153.95 60.02,154.07 v2(60.02,154.5)
  BOTTOM w0.102: v1(103.6,163.25) 103.86,162.99 U6539.G45
  BOTTOM w0.114: v2(60.02,154.5) 59.2,155.32 JDIM02.66
M_B_DQ52: length 57.2
  IN3 w0.089: v1(105.58,162.28) 105.1,161.79 103.4,161.79 103.31,161.7 99.6,161.7 97.96,163.34 87.97,163.34 86.66,162.04 77.22,162.04 76.98,161.79 76.85,161.79 76.74,161.91 76.61,161.91 76.42,161.72 76.42,161.6 76.54,161.48 76.54,161.35 76.35,161.16 76.23,161.16 76.11,161.28 75.98,161.28 75.79,161.09 75.79,160.97 75.91,160.85 75.91,160.72 67.1,151.91 66.47,151.91 64.94,150.39 61.51,150.39 61.39,150.52 61.39,151.06 61.51,151.18 v2(62.03,151.18)
  BOTTOM w0.102: v1(105.58,162.28) 105.53,162.28 105.16,161.91 U6539.J42
  BOTTOM w0.114: v2(62.03,151.18) 62.03,151.46 62.65,152.07 JDIM02.79
M_B_DQ53: length 58.5
  IN3 w0.089: v1(106.22,162.28) 106.6,161.9 106.6,161.19 106.35,160.93 100.03,160.93 97.87,163.09 88.08,163.09 86.68,161.69 77.39,161.69 67.23,151.53 66.72,151.53 65.2,150.01 60.21,150.01 v2(59.09,151.13)
  BOTTOM w0.102: U6539.J41 106.22,162.25 v1(106.22,162.28)
  BOTTOM w0.114: v2(59.09,151.13) 58.55,150.59 58.29,150.59 58.06,150.82 JDIM02.84
M_B_DQ54: length 57.7
  IN3 w0.089: v1(105.56,163.27) 105.84,163.55 105.84,164.23 104.69,165.38 86.66,165.38 86.25,164.97 74.95,164.97 70.4,160.42 69.39,160.42 66.29,157.32 66.16,157.32 65.91,157.58 65.78,157.58 65.59,157.39 65.59,157.27 65.85,157.01 65.85,156.88 65.66,156.7 65.54,156.7 65.28,156.95 65.15,156.95 64.98,156.78 64.98,156.6 65.12,156.46 65.12,156.28 64.61,155.77 61.56,155.77 61.3,155.51 v2(61.3,154.42)
  BOTTOM w0.102: U6539.G41 105.56,163.01 v1(105.56,163.27)
  BOTTOM w0.114: JDIM02.67 61.95,155.07 v2(61.3,154.42)
M_B_DQ55: length 57
  IN3 w0.089: v2(58.65,154.49) 58.65,155.53 59.1,155.98 60.37,155.98 60.68,155.67 60.68,154.4 61.13,153.95 62.32,153.95 62.47,154.09 62.47,154.56 63.02,155.11 64.58,155.11 69.49,160.02 70.63,160.02 75.24,164.63 86.29,164.63 86.79,165.12 103.11,165.12 v1(104.97,163.26)
  BOTTOM w0.102: v1(104.97,163.26) 105.16,163.07 U6539.G42
  BOTTOM w0.114: JDIM02.70 58.49,154.32 v2(58.65,154.49)
M_B_DQ56: length 58.7
  IN1 w0.089: v1(107.57,160.47) 107.57,160.25 107.21,159.89 106.37,159.89 106.27,159.99 103.42,159.99 103.17,159.74 103.17,159.41 102.92,159.15 102.53,159.15 102.15,159.53 101.26,159.53 100.08,158.35 93.35,158.35 93.01,158.01 77.29,158.01 77.2,158.1 77.2,158.43 77.11,158.52 76.85,158.52 76.76,158.43 76.76,158.1 76.67,158.01 76.4,158.01 76.31,158.1 76.31,158.43 76.23,158.52 75.96,158.52 75.87,158.43 75.87,158.1 75.78,158.01 75.51,158.01 75.43,158.1 75.43,158.43 75.34,158.52 75.07,158.52 74.98,158.43 74.98,158.1 74.89,158.01 74.63,158.01 74.54,158.1 74.54,158.43 74.45,158.52 74.18,158.52 74.09,158.43 74.09,158.1 74,158.01 73.74,158.01 73.65,158.1 73.65,158.43 73.56,158.52 73.29,158.52 73.2,158.43 73.2,158.1 73.11,158.01 68.12,158.01 66.14,156.03 61.3,156.03 v2(60.41,156.93)
  BOTTOM w0.102: U6539.N38 107.43,160.47 v1(107.57,160.47)
  BOTTOM w0.114: JDIM02.58 58.19,157.32 58.3,157.44 58.76,157.44 59.07,157.76 59.88,157.76 60.41,157.22 v2(60.41,156.93)
M_B_DQ57: length 58
  IN1 w0.089: v2(63.36,156.49) 63.36,156.5 63.85,156.99 66.59,156.99 68.63,159.03 77.83,159.03 77.92,158.94 77.92,158.48 78.01,158.39 78.27,158.39 78.36,158.48 78.36,158.94 78.45,159.03 78.72,159.03 78.81,158.94 78.81,158.48 78.9,158.39 79.16,158.39 79.25,158.48 79.25,158.94 79.34,159.03 79.68,159.03 79.77,158.94 79.77,158.48 79.86,158.39 80.13,158.39 80.22,158.48 80.22,158.94 80.31,159.03 80.57,159.03 80.66,158.94 80.66,158.48 80.75,158.39 81.02,158.39 81.11,158.48 81.11,158.94 81.2,159.03 81.46,159.03 81.55,158.94 81.55,158.48 81.64,158.39 81.91,158.39 82,158.48 82,158.94 82.08,159.03 82.43,159.03 82.52,158.94 82.52,158.48 82.61,158.39 82.87,158.39 82.96,158.48 82.96,158.94 83.05,159.03 83.32,159.03 83.41,158.94 83.41,158.48 83.49,158.39 83.76,158.39 83.85,158.48 83.85,158.94 83.94,159.03 84.21,159.03 84.29,158.94 84.29,158.48 84.38,158.39 92.37,158.39 93.14,159.15 94.28,159.15 94.53,158.9 99.99,158.9 101.65,160.55 102.15,160.55 102.52,160.18 106.47,160.18 106.53,160.12 106.92,160.12 107.12,160.32 107.12,160.68 v1(107.57,161.12)
  BOTTOM w0.102: v1(107.57,161.12) 107.44,161.12 U6539.L38
  BOTTOM w0.114: v2(63.36,156.49) 63.36,156.52 63.91,157.07 JDIM02.59
M_B_DQ58: length 58.5
  IN1 w0.089: v2(60.41,159.78) 62.19,161.57 63.8,161.57 65.83,163.6 67.36,163.6 67.74,163.22 86.15,163.22 86.53,163.6 100.38,163.6 100.76,163.98 101.72,163.98 102.53,164.78 106.05,164.78 106.22,164.61 108.25,164.61 109.1,163.77 109.1,162.46 108.8,162.17 108.8,161.47 108.46,161.12 v1(108.45,161.12)
  BOTTOM w0.102: U6539.L36 108.32,161.12 v1(108.45,161.12)
  BOTTOM w0.114: v2(60.41,159.78) 59.95,159.32 JDIM02.50
M_B_DQ59: length 59.4
  IN1 w0.089: v1(108.45,160.51) 108.85,160.91 108.85,161.25 109,161.39 109,162.09 109.34,162.44 109.34,163.9 108.35,164.89 106.32,164.89 106.14,165.07 102.36,165.07 101.62,164.33 100.48,164.33 100.25,164.11 65.83,164.11 63.67,161.95 61.18,161.95 v2(59.09,159.85)
  BOTTOM w0.102: v1(108.45,160.51) 108.36,160.51 U6539.N36
  BOTTOM w0.114: JDIM02.46 58.62,160.32 v2(59.09,159.85)
M_B_DQ60: length 56.1
  IN1 w0.089: v1(107.49,162.43) 107.11,162.05 107.11,161.18 106.85,160.93 101.52,160.93 99.87,159.28 94.79,159.28 94.53,159.53 90.34,159.53 89.83,159.03 88.13,159.03 87.62,159.53 87.28,159.53 87.19,159.45 87.19,159.11 87.1,159.03 86.83,159.03 86.75,159.11 86.75,159.45 86.66,159.53 86.39,159.53 86.3,159.45 86.3,159.11 86.21,159.03 85.94,159.03 85.86,159.11 85.86,159.45 85.77,159.53 85.5,159.53 85.41,159.45 85.41,159.11 85.32,159.03 85.06,159.03 84.97,159.11 84.97,159.45 84.88,159.53 68.63,159.53 66.47,157.38 63.74,157.38 63.35,156.98 62.19,156.98 v2(61.76,156.55)
  BOTTOM w0.102: U6539.H38 107.45,162.43 v1(107.49,162.43)
  BOTTOM w0.114: v2(61.76,156.55) 61.76,156.42 62.1,156.07 JDIM02.63
M_B_DQ61: length 57.5
  IN1 w0.089: v1(108.45,162.42) 108.6,162.42 108.86,162.68 108.86,163.63 108.15,164.33 106,164.33 105.83,164.5 102.67,164.5 102.41,164.23 102.41,163.57 102.18,163.34 101.65,163.34 101.39,163.6 100.88,163.6 100.5,163.22 88.13,163.22 87.37,162.46 87.1,162.46 87.01,162.54 87.01,162.87 86.92,162.96 86.66,162.96 86.57,162.87 86.57,162.54 86.48,162.46 67.86,162.46 67.1,163.22 66.09,163.22 64.05,161.19 62.72,161.19 v2(61.64,160.1)
  BOTTOM w0.102: v1(108.45,162.42) 108.32,162.42 U6539.H36
  BOTTOM w0.114: JDIM02.49 64.38,159.57 64.27,159.47 62.28,159.47 v2(61.64,160.1)
M_B_DQ62: length 56.2
  IN1 w0.089: v2(62.96,160.11) 63.41,160.55 64.94,160.55 66.34,161.95 88.11,161.95 88.2,162.04 88.2,162.49 88.29,162.58 88.55,162.58 88.64,162.49 88.64,162.04 88.73,161.95 89,161.95 89.09,162.04 89.09,162.49 89.17,162.58 89.44,162.58 89.53,162.49 89.53,162.04 89.62,161.95 89.89,161.95 89.97,162.04 89.97,162.49 90.06,162.58 90.33,162.58 90.42,162.49 90.42,162.04 90.51,161.95 90.77,161.95 90.86,162.04 90.86,162.49 90.95,162.58 91.22,162.58 91.31,162.49 91.31,162.04 91.4,161.95 91.74,161.95 91.87,162.07 91.87,162.33 92.37,162.84 98.22,162.84 98.78,162.28 100.45,162.28 100.76,162.58 101.14,162.58 101.52,162.96 102.11,162.96 102.79,163.65 103.22,163.65 103.8,164.23 105.59,164.23 105.76,164.06 108.05,164.06 108.6,163.5 108.6,163.22 v1(108.45,163.07)
  BOTTOM w0.102: U6539.G36 108.32,163.07 v1(108.45,163.07)
  BOTTOM w0.114: JDIM02.45 63.43,160.57 v2(62.96,160.11)
M_B_DQ63: length 55.5
  IN1 w0.089: v1(107.49,163.07) 106.98,162.56 106.98,162.33 106.4,161.74 102.66,161.74 102.23,161.31 101.39,161.31 100.71,160.63 95.3,160.63 94.71,160.04 89.99,160.04 89.48,159.53 89.22,159.53 89.13,159.62 89.13,159.95 89.04,160.04 88.77,160.04 88.68,159.95 88.68,159.62 88.59,159.53 88.33,159.53 88.24,159.62 88.24,159.95 88.15,160.04 68.63,160.04 66.34,157.76 63.62,157.76 63.2,157.34 61.05,157.34 60.88,157.5 59.67,157.5 v2(59.09,156.92)
  BOTTOM w0.102: U6539.G38 107.16,162.75 v1(107.49,163.07)
  BOTTOM w0.114: JDIM02.62 58.64,156.32 59.09,156.77 v2(59.09,156.92)
M_B_DQSN0: length 66.6
  IN1 w0.089: v2(59.24,120.2) 59.45,120.2 59.74,119.91 59.74,119.55 60.14,119.15 64.82,119.15 68.17,122.5 70.74,122.5 80.39,132.15 80.39,132.87 79.8,133.46 79.8,133.88 80.11,134.18 80.35,134.18 80.73,133.8 81.12,133.8 81.46,134.15 81.46,134.66 81.1,135.03 81.1,135.18 84.82,138.9 84.82,142.42 90.09,147.69 90.09,147.98 91.77,149.65 95.48,149.65 95.75,149.92 95.75,150.37 v1(95.9,150.52)
  BOTTOM w0.079: U6539.AN50 101.62,151.19 101.55,151.12 101.55,150.99 101.34,150.78 99.88,150.78 99.71,150.61 99.19,150.61 99.15,150.58 99.13,150.58
  BOTTOM w0.102: v2(59.24,120.2) 59.49,120.2 59.57,120.12 59.57,119.81 59.52,119.76 58.36,119.76 58.15,119.97 58.15,120.16 57.99,120.32 JDIM02.198 ; v1(95.9,150.52) 95.72,150.71 95.72,150.83 95.85,150.96 96.65,150.96 97.03,150.58 99.13,150.58
M_B_DQSN1: length 63.2
  IN1 w0.089: v2(61.79,125.03) 61.09,125.03 60.91,125.21 60.91,125.53 61.15,125.76 64.61,125.76 66.5,127.66 68.63,127.66 70.78,129.82 70.78,135.02 88.62,152.85 95.3,152.85 95.55,153.1 95.55,153.27 v1(95.8,153.52)
  BOTTOM w0.079: 99.13,153.61 99.15,153.61 99.19,153.64 99.38,153.64 99.67,153.35 101.34,153.35 101.56,153.56 101.56,153.7 101.61,153.75 U6539.AG50
  BOTTOM w0.102: JDIM02.177 64.13,125.57 63.98,125.43 63.73,125.43 62.66,124.36 61.48,124.36 61.35,124.48 61.35,124.72 61.67,125.03 v2(61.79,125.03) ; 99.13,153.61 97.09,153.61 96.76,153.94 95.91,153.94 95.74,153.78 95.74,153.58 v1(95.8,153.52)
M_B_DQSN2: length 77.8
  IN3 w0.089: v2(60.35,109.24) 60.11,109.24 59.71,108.84 59.71,108.23 59.96,107.97 60.81,107.97 61.44,108.61 66.37,108.61 66.72,108.96 66.72,109.24 67.08,109.6 67.47,109.6 67.81,109.94 67.81,110.98 70.81,113.97 70.81,116.45 72.87,118.51 73.45,118.51 75.23,120.29 76.37,120.29 85.54,129.46 85.54,133.85 88.34,136.65 96.6,136.65 100.02,140.07 100.02,143.25 100.45,143.68 100.45,148.37 101.36,149.28 102.09,149.28 102.3,149.49 102.3,149.75 102.56,150.01 103.92,150.01 v1(104.29,150.39)
  BOTTOM w0.102: v1(104.29,150.39) 104.3,150.39 104.51,150.17 U6539.AR44 ; v2(60.35,109.24) 59.8,109.79 59.8,110.01 59.45,110.36 58.75,110.36 58.22,109.82 JDIM02.240
M_B_DQSN3: length 69.5
  IN3 w0.089: v2(62.02,114.13) 62.18,113.97 62.18,113.59 62.44,113.33 64.28,113.33 66.34,115.4 66.34,118.7 68.6,120.96 68.6,122.3 80.44,134.13 80.44,136.93 88.82,145.31 89.77,145.31 90.02,145.06 95.87,145.06 98.22,147.41 98.22,149.5 101.57,152.85 102.2,152.85 102.4,152.65 103.17,152.65 103.18,152.64 103.9,152.64 v1(104.26,152.28)
  BOTTOM w0.102: U6539.AL44 104.51,152.03 v1(104.26,152.28) ; v2(62.02,114.13) 62.14,114.13 62.81,114.8 64.07,114.8 64.34,115.07 JDIM02.219
M_B_DQSN4: length 54.5
  IN3 w0.089: v1(97.38,167.41) 96.68,166.71 89.77,166.71 89.33,167.15 73.71,167.15 71.07,164.51 62.12,164.51 60.97,163.37 59.95,163.37 59.67,163.64 59.67,163.92 59.49,164.1 v2(59.15,164.1)
  BOTTOM w0.079: U6539.D45 104.04,164.02 103.63,164.44 103.63,165.79 103.24,166.17 103.03,166.39 102.98,166.39 102.96,166.4
  BOTTOM w0.102: JDIM02.32 57.96,163.82 58.18,163.6 58.51,163.6 58.73,163.37 59.44,163.37 59.62,163.56 59.62,163.99 59.51,164.1 v2(59.15,164.1) ; v1(97.38,167.41) 97.38,167.8 97.78,168.2 101.17,168.2 101.77,167.59 101.77,167.21 102.49,166.49 102.87,166.49 102.96,166.4
M_B_DQSN5: length 62.9
  IN3 w0.089: v1(106.34,169.46) 106.55,169.26 106.73,169.26 106.85,169.39 106.85,170.33 106.12,171.07 90.68,171.07 90.3,171.45 82.99,171.45 82.76,171.22 70.6,171.22 69.67,170.29 60.46,170.29 60.25,170.08 60.25,169.92 60.47,169.7 v2(61.15,169.7)
  BOTTOM w0.079: U6539.C39 106.71,164.45 106.66,164.41 106.57,164.41 106.48,164.5 106.48,166.21 106.92,166.65 106.92,166.74 106.97,166.79 106.97,166.8
  BOTTOM w0.102: JDIM02.11 64.32,169.07 64.16,168.91 63.89,168.91 63.36,169.44 61.55,169.44 61.27,169.16 60.37,169.16 60.24,169.29 60.24,169.45 60.49,169.7 v2(61.15,169.7) ; 106.97,166.8 106.97,168.84 v1(106.34,169.46)
M_B_DQSN6: length 56.6
  IN3 w0.089: v2(60.36,152.43) 59.73,152.43 59.48,152.68 59.48,152.93 59.61,153.06 60.51,153.06 60.69,152.88 61.75,152.88 61.95,152.68 64.56,152.68 66.47,154.58 67.61,154.58 76.25,163.22 86.66,163.22 87.57,164.13 100.76,164.13 101.93,162.96 102.28,162.96 102.6,162.64 104.36,162.64 104.48,162.52 104.48,162.38 104.37,162.27 v1(104.27,162.27)
  BOTTOM w0.102: v1(104.27,162.27) 104.32,162.27 104.51,162.08 U6539.J44 ; v2(60.36,152.43) 60,152.43 59.9,152.53 59.9,152.89 59.57,153.22 58.33,153.22 58.23,153.32 JDIM02.74
M_B_DQSN7: length 57.5
  IN1 w0.089: v2(61.87,158.14) 61.69,158.14 61.36,158.46 61.36,158.65 61.62,158.9 62.6,158.9 62.91,158.59 66.15,158.59 68.68,161.11 93.7,161.11 94.15,161.57 100.76,161.57 101.01,161.82 101.96,161.82 102.8,162.66 106.5,162.66 107.31,163.47 107.71,163.47 107.87,163.31 107.87,162.18 107.97,162.08 107.97,161.9 107.85,161.77 v1(107.57,161.77)
  BOTTOM w0.102: U6539.K38 107.44,161.77 v1(107.57,161.77) ; v2(61.87,158.14) 61.65,157.91 61.46,157.91 61.34,157.79 61.34,157.65 61.49,157.5 62.97,157.5 63.77,158.3 64.09,158.3 64.36,158.57 JDIM02.53
M_B_DQSN8: length 3.7
  TOP w0.114: R25611.2 67.89,147.72 v2(67.88,147.72)
  BOTTOM w0.114: v2(67.88,147.72) 67.86,147.72 67.29,148.28 66.41,148.28 66.2,148.07 JDIM02.95
M_B_DQSP0: length 66.6
  IN1 w0.089: v2(60.51,120.2) 60.15,120.2 59.94,119.99 59.94,119.64 60.22,119.35 64.73,119.35 68.08,122.7 70.66,122.7 80.18,132.23 80.18,132.79 79.6,133.37 79.6,133.97 80.02,134.39 80.44,134.39 80.82,134.01 81.04,134.01 81.26,134.23 81.26,134.58 80.9,134.94 80.9,135.27 84.62,138.98 84.62,142.5 89.89,147.77 89.89,148.06 91.68,149.86 95.4,149.86 95.55,150.01 95.55,150.25 v1(95.28,150.52)
  BOTTOM w0.079: 99.13,150.81 99.15,150.81 99.19,150.77 99.64,150.77 99.82,150.94 101.28,150.94 101.39,151.06 101.39,151.12 101.32,151.19 U6539.AN51
  BOTTOM w0.102: v1(95.28,150.52) 95.49,150.74 95.49,150.92 95.76,151.19 96.74,151.19 97.12,150.81 99.13,150.81 ; JDIM02.200 57.98,119.82 58.27,119.53 59.61,119.53 59.83,119.75 59.83,119.99 60.05,120.2 v2(60.51,120.2)
M_B_DQSP1: length 63.2
  IN1 w0.089: v2(60.52,125.03) 60.71,125.23 60.71,125.61 61.06,125.97 64.52,125.97 66.42,127.86 68.54,127.86 70.58,129.9 70.58,135.11 88.53,153.06 95.22,153.06 95.35,153.18 95.35,153.34 v1(95.17,153.52)
  BOTTOM w0.079: 99.13,153.84 99.15,153.84 99.19,153.8 99.44,153.8 99.74,153.51 101.28,153.51 101.4,153.63 101.4,153.7 101.35,153.75 U6539.AG51
  BOTTOM w0.102: v1(95.17,153.52) 95.81,154.17 96.85,154.17 97.18,153.84 99.13,153.84 ; v2(60.52,125.03) 60.72,125.03 61.12,124.64 61.12,124.39 61.38,124.13 62.75,124.13 63.83,125.2 64.1,125.2 64.23,125.07 JDIM02.179
M_B_DQSP2: length 77.7
  IN3 w0.089: v1(104.29,149.48) 103.99,149.78 102.66,149.78 102.53,149.66 102.53,149.39 102.19,149.05 101.46,149.05 100.68,148.27 100.68,143.58 100.25,143.15 100.25,139.98 96.69,136.42 88.44,136.42 85.77,133.75 85.77,129.37 76.47,120.06 75.32,120.06 73.55,118.28 72.97,118.28 71.04,116.35 71.04,113.88 68.04,110.88 68.04,109.84 67.57,109.37 67.17,109.37 66.95,109.15 66.95,108.87 66.46,108.38 61.54,108.38 60.9,107.74 59.87,107.74 59.48,108.13 59.48,108.99 59.23,109.24 v2(59.08,109.24)
  BOTTOM w0.102: JDIM02.242 58.04,109.32 58.85,110.13 59.35,110.13 59.58,109.91 59.58,109.73 v2(59.08,109.24) ; v1(104.29,149.48) 104.51,149.27 U6539.AV44
M_B_DQSP3: length 69.4
  IN3 w0.089: v2(63.29,114.13) 62.66,114.13 62.41,113.88 62.41,113.69 62.53,113.56 64.18,113.56 66.11,115.49 66.11,118.79 68.37,121.05 68.37,122.39 80.21,134.23 80.21,137.02 88.72,145.54 89.86,145.54 90.11,145.28 95.77,145.28 97.99,147.5 97.99,149.6 101.47,153.08 102.29,153.08 102.49,152.88 103.26,152.88 103.28,152.87 104.02,152.87 v1(104.29,153.14)
  BOTTOM w0.102: JDIM02.221 62.91,114.57 62.75,114.41 62.75,114.26 62.88,114.13 v2(63.29,114.13) ; v1(104.29,153.14) 104.51,152.93 U6539.AJ44
M_B_DQSP4: length 54.5
  IN3 w0.089: v2(60.47,164.1) 60.13,164.1 59.9,163.87 59.9,163.74 60.04,163.6 60.88,163.6 62.02,164.74 70.98,164.74 73.62,167.38 89.42,167.38 89.86,166.94 96.54,166.94 96.67,167.07 v1(96.67,167.41)
  BOTTOM w0.079: 103.12,166.57 103.14,166.55 103.14,166.5 103.4,166.24 103.78,165.86 103.78,164.5 103.88,164.41 103.96,164.41 104.04,164.5 U6539.C45
  BOTTOM w0.102: v1(96.67,167.41) 97.68,168.42 101.26,168.42 102,167.69 102,167.31 102.59,166.72 102.97,166.72 103.12,166.57 ; v2(60.47,164.1) 60.15,164.1 59.85,163.81 59.85,163.46 59.53,163.14 58.64,163.14 58.41,163.37 58.14,163.37 58.09,163.32 JDIM02.34
M_B_DQSP5: length 62.9
  IN3 w0.089: v2(59.88,169.7) 60.02,169.84 60.02,170.18 60.37,170.52 69.58,170.52 70.51,171.45 82.67,171.45 82.89,171.68 90.39,171.68 90.77,171.29 106.21,171.29 107.08,170.42 107.08,169.29 106.82,169.03 106.53,169.03 v1(106.33,168.82)
  BOTTOM w0.079: 106.74,166.8 106.74,166.78 106.76,166.75 106.76,166.71 106.33,166.28 106.33,164.43 106.71,164.05 U6539.D39
  BOTTOM w0.102: v1(106.33,168.82) 106.44,168.93 106.55,168.93 106.74,168.74 106.74,166.8 ; v2(59.88,169.7) 60.02,169.56 60.02,169.19 60.28,168.93 61.36,168.93 61.64,169.21 63.26,169.21 63.8,168.68 64.05,168.68 64.16,168.57 JDIM02.13
M_B_DQSP6: length 56.5
  IN3 w0.089: v2(59.09,152.43) 59.25,152.6 59.25,153.02 59.51,153.28 60.61,153.28 60.78,153.11 61.84,153.11 62.05,152.9 64.47,152.9 66.37,154.81 67.51,154.81 76.15,163.45 86.57,163.45 87.48,164.36 100.85,164.36 102.02,163.19 102.38,163.19 102.7,162.87 104.45,162.87 104.71,162.61 104.71,162.48 v1(104.92,162.27)
  BOTTOM w0.102: v1(104.92,162.27) 104.92,162.35 U6539.G44 ; v2(59.09,152.43) 59.6,152.43 59.67,152.51 59.67,152.8 59.48,152.99 58.3,152.99 58.13,152.82 JDIM02.76
M_B_DQSP7: length 57.5
  IN1 w0.089: v1(108.43,161.8) 108.18,162.05 108.18,162.16 108.07,162.27 108.07,163.4 107.79,163.67 107.23,163.67 106.41,162.86 102.71,162.86 101.87,162.02 100.93,162.02 100.67,161.77 94.07,161.77 93.61,161.31 68.59,161.31 66.07,158.79 63,158.79 62.68,159.1 61.53,159.1 61.16,158.73 61.16,158.38 61.16,158.19 v2(61.11,158.14)
  BOTTOM w0.102: U6539.K36 108.08,161.45 v1(108.43,161.8) ; v2(61.11,158.14) 61.11,157.56 61.39,157.27 63.06,157.27 63.86,158.07 JDIM02.55
M_B_DQSP8: length 2
  TOP w0.114: R25607.2 66.6,147.72 v2(66.61,147.72)
  BOTTOM w0.114: JDIM02.97 66.46,147.57 v2(66.61,147.72)
M_B_PARITY: length 62.2
  IN3 w0.102: v2(61.03,135.3) 61.26,135.53 68.12,135.53 69.01,136.42 69.01,138.56 86.17,155.72 90.85,155.72 91.87,156.74 97.07,156.74 97.84,157.5 97.84,158.52 98.22,158.9 101.26,158.9 101.77,158.39 103.4,158.39 v1(103.62,158.61)
  BOTTOM w0.102: U6539.U45 103.86,158.37 v1(103.62,158.61)
  BOTTOM w0.152: JDIM02.143 66.16,136.07 66.31,135.91 66.31,135.39 65.96,135.04 64.22,135.04 63.95,135.3 v2(61.03,135.3)
M_B_RAS#: length 62.3
  IN3 w0.102: v1(102.99,156.8) 100.76,156.8 100.44,156.49 98.72,156.49 97.58,155.34 92.63,155.34 91.99,154.71 88.95,154.71 87.04,152.8 86.15,152.8 71.04,137.69 71.04,135.91 68.64,133.51 64.32,133.51 63.93,133.12 62.4,133.12 62.02,132.74 60.75,132.74 60.62,132.86 60.62,133.12 60.75,133.25 61.64,133.25 v2(62.28,133.89)
  BOTTOM w0.102: U6539.AA47 103.21,156.59 103.07,156.73 102.99,156.8 v1(102.99,156.8)
  BOTTOM w0.152: v2(62.28,133.89) 62.28,133.81 60.38,131.9 58.32,131.9 58.24,131.82 JDIM02.152
M_B_WE#: length 61.3
  IN3 w0.102: v1(103.64,156.8) 103.54,156.8 103.12,156.39 100.66,156.39 100.46,156.18 98.93,156.18 97.71,154.96 92.88,154.96 92.25,154.33 89.31,154.33 86.93,151.95 86.75,151.95 86.5,152.21 86.32,152.21 86.03,151.92 86.03,151.77 86.32,151.48 86.32,151.34 86.18,151.19 86.04,151.19 85.74,151.49 85.6,151.49 85.45,151.34 85.45,151.2 85.75,150.91 85.75,150.76 85.6,150.62 85.46,150.62 85.17,150.91 85.02,150.91 84.88,150.77 84.88,150.62 85.17,150.33 85.17,150.19 85.03,150.04 84.89,150.04 84.59,150.34 84.45,150.34 84.3,150.19 84.3,150.05 84.6,149.76 84.6,149.61 84.45,149.47 84.31,149.47 84.02,149.76 83.87,149.76 83.73,149.62 83.73,149.47 84.02,149.18 84.02,149.04 83.88,148.89 83.74,148.89 83.44,149.19 83.3,149.19 83.15,149.04 83.15,148.9 83.45,148.61 83.45,148.46 83.3,148.32 83.16,148.32 82.87,148.61 82.72,148.61 82.58,148.47 82.58,148.33 82.87,148.03 82.87,147.89 82.73,147.74 82.59,147.74 82.29,148.04 82.15,148.04 71.55,137.44 71.55,135.66 68.99,133.1 64.67,133.1 64.04,132.47 v2(63.35,132.47)
  BOTTOM w0.102: v1(103.64,156.8) 103.86,156.59 U6539.AA45
  BOTTOM w0.152: v2(63.35,132.47) 63.63,132.2 64.22,132.2 64.34,132.07 JDIM02.151
MAIND: length 83.3
  TOP w0.114: v2(35.86,127.15) 35.98,127.03 PQ9.2 ; PR59.2 58.98,180.78 58.77,180.57 v2(58.77,180.18) 58.77,179.98 59.17,179.58 PC51.1 58.8,178.76 58.8,178.51 58.42,178.13 57.8,178.13 57.34,177.66 PQ6.3 56.13,177.1 55.53,177.7 54.22,177.7 53.97,177.95 v1(53.94,177.95) ; PQ9087.2 29.95,143.97 30.14,144.17 32.18,144.17 32.56,143.79 v2(32.56,142.64)
  IN4 w0.089: v2(35.86,127.15) 35.48,127.53 35.48,131.72 34.08,133.12 34.08,135.66 33.45,136.29 33.45,140.61 32.56,141.5 v2(32.56,142.64) 32.56,143.53 33.7,144.68 35.07,144.68 36.33,145.93 36.33,156.59 38.48,158.73 38.48,168.32 39.1,168.95 39.1,172.68 44.36,177.94 53.86,177.94 53.87,177.95 v1(53.94,177.95)
MAINON: length 784.1
  TOP w0.114: v2(150.29,96.29) 150.03,96.03 R890.1 149.5,96.17 150.17,96.85 150.41,96.85 150.58,97.02 150.58,97.47 150.82,97.71 150.82,97.79 150.97,97.94 U37.30 ; v2(34.97,169.44) 34.72,169.19 PR6028.1 ; PQ16.2 54.84,177.2 PR120.1 55.58,176.58 56.59,176.58 56.99,176.17 v2(57.5,176.17) ; v1(169.72,135.79) 169.28,136.22 R68841.2 ; R68852.1 173.63,149.53 v2(173.27,149.88) ; R68950.2 205.15,106.7 204.34,105.89 v1(203.88,105.89) ; v2(197.53,131.45) 197.53,131.21 197.78,130.96 PR6016.1
  TOP w0.203: v2(90.93,169.06) 90.98,169.11 PR5006.1
  IN1 w0.089: v1(104.03,182.44) 104.54,182.95 105.15,182.95 105.66,182.44 110.66,182.44 111.5,183.28 112.31,183.28 112.75,182.84 113.7,182.84 114.27,183.41 114.47,183.41 114.73,183.67 118.98,183.67 119.02,183.71 121.03,183.71 123.26,181.48 123.26,181.1 125.65,178.71 129.54,178.71 130.22,178.03 134.54,178.03 136.32,176.25 139.16,176.25 140.51,174.9 140.51,173.12 143.56,170.08 154.48,170.08 155.27,169.29 159.2,169.29 160.24,168.25 166.34,168.25 167.05,167.54 167.05,160.8 168.5,159.36 168.5,156.56 169.59,155.47 169.59,155.09 170.48,154.2 170.48,152.68 171.56,151.6 171.94,151.6 173.27,150.26 v2(173.27,149.88) ; v2(15.07,117.73) 15.76,118.43 28.71,118.43 v2(28.87,118.26) ; v2(166.44,137.82) 166.8,137.46 166.8,137.31 167.43,136.67 168.83,136.67 v1(169.72,135.79) 170.1,135.4 v2(172.13,135.4) ; v1(203.88,105.89) 205.07,107.08 207.18,107.08 209.47,104.8 214.8,104.8 217.85,107.85 219.25,107.85 222.8,111.4 222.8,116.65 223.27,117.12 227.38,117.12 229.41,119.15 230.91,119.15 231.67,119.91 231.67,121.21 v2(231.19,121.69)
  IN2 w0.102: v2(62.59,181.93) 63.05,182.39 64.87,182.39 v2(66.72,184.25)
  IN3 w0.102: v2(66.72,184.25) 66.72,184.3 65.96,185.06 65.96,185.57 66.59,186.2 69.9,186.2 71.04,187.35 74.72,187.35 75.31,186.76 84.58,186.76 86.15,185.19 89.45,185.19 90.2,184.44 90.25,184.44 90.85,183.84 90.85,182.39 91.26,181.99 92.96,181.99 93.37,181.58 94.71,181.58 95.12,181.17 100.17,181.17 100.73,181.73 103.8,181.73 104.03,181.96 v1(104.03,182.44) ; v2(231.19,121.69) 231.31,121.82 231.31,125.24 230.55,126.01 228.01,126.01 225.98,128.04 223.95,128.04 221.66,125.75 213.79,125.75 211.88,127.66 211.5,127.66 209.34,129.82 205.02,129.82 204.52,130.32 199.94,130.32 198.81,131.45 v2(197.53,131.45) 195.62,129.55 191.8,129.55 188.44,126.19 179.96,126.19 178.98,127.17 177.59,127.17 177.46,127.3 177.46,131.59 173.65,135.4 v2(172.13,135.4) ; v1(173.15,120.27) 173.15,120.11 174.62,118.64 176.45,118.64 177.77,117.32 189.58,117.32 190.04,116.86 190.04,115.72 190.67,115.08 191.52,115.08 194.44,112.16 197.66,112.16 198.8,111.02 202.23,111.02 204.82,108.43 206.85,108.43 207.18,108.1 207.18,105.82 204.01,102.65 204.01,101.5 203.75,101.24 203.75,99.08 203.37,98.7 202.74,98.7 202.1,98.07 199.18,98.07 198.17,97.05 196.13,97.05 195.75,97.43 193.51,97.43 192.21,96.14 181.25,96.14 180.92,96.47 172.56,96.47 171.45,95.35 156.81,95.35 154.1,98.07 152.19,98.07 150.41,96.29 v2(150.29,96.29) 150.29,97.69 148.76,99.21 143.94,99.21 143.17,99.97 140.44,99.97 138.66,98.19 135.83,98.19 134.79,97.15 125.22,97.15 124.96,97.41 119.27,97.41 118.79,96.92 117.24,96.92 116.45,96.14 115.82,96.14 v2(115.34,95.65)
  IN4 w0.089: v2(115.34,95.65) 113.93,94.25 97.23,94.25 95.7,95.77 93.38,95.77 92.76,95.15 84.63,95.15 83.61,96.16 79.67,96.16 76.25,92.73 76.25,92.33 75.99,92.07 75.05,92.07 74.24,91.26 50.82,91.26 49.78,92.3 49.78,93.88 48.46,95.2 45.54,95.2 44.9,95.83 38.76,95.83 36.64,97.95 35.72,97.95 33.45,100.23 33.45,103.53 31.71,105.27 31.71,114.67 30.59,115.78 30.59,116.54 v2(28.87,118.26) 28.11,119.02 28.11,129.44 26.68,130.87 26.68,132.45 28.04,133.8 28.04,148.94 27.73,149.25 27.73,150.36 28.11,150.74 28.11,154.08 26.33,155.86 26.33,161.47 31.26,166.39 33.56,166.39 34.21,167.04 34.21,168.68 v2(34.97,169.44) ; v2(66.72,184.25) 66.8,184.17 68.37,184.17 70.34,182.2 70.34,181.18 72.31,179.22 72.31,177.7 73.07,176.93 81.33,176.93 82.85,175.41 85.14,175.41 86.02,174.52 86.02,174.27 87.55,172.74 89.45,172.74 90.93,171.27 v2(90.93,169.06) ; v2(173.27,149.88) 173.27,149.37 172.77,148.87 171.88,148.87 168.83,145.82 168.83,140.2 v2(166.44,137.82) 166.8,137.46 166.8,137.31 171.14,132.97 171.14,128.7 170.99,128.55 170.99,126.01 171.62,125.37 171.62,123.09 173.15,121.56 v1(173.15,120.27) ; v2(4.59,41.53) 6.39,43.33 9.57,43.33 10.33,44.09 10.33,46.5 10.97,47.14 11.73,47.14 18.33,53.74 18.33,55.62 16.81,57.15 16.81,59.46 16.3,59.97 16.3,67.08 15.54,67.84 15.54,72.03 14.02,73.56 13.25,73.56 12.49,74.32 12.49,76.51 16.58,80.61 16.58,86.56 16.43,86.71 16.43,91.43 16.58,91.59 16.58,99.97 16.73,100.12 16.73,102.97 16.43,103.27 16.43,113.05 16.68,113.31 16.68,114.19 15.07,115.81 v2(15.07,117.73)
  BOTTOM w0.114: v2(57.5,176.17) 60.78,176.17 62.59,177.98 v2(62.59,181.93) 62.45,181.93 61.99,182.39 61.01,182.39 60.88,182.52 PR9270.1 ; v2(4.59,41.53) 4.52,41.45 PR6417.1 ; v1(169.72,135.79) PR9268.1
  BOTTOM w0.203: PR7082.1 166.21,138.28 166.44,138.05 v2(166.44,137.82)
MAINON_ON_G: length 221.4
  TOP w0.114: PQ9088.2 26.14,143.73 25.32,144.55 18.08,144.55 17.68,144.95 PQ19.2 19.4,147.45 v2(19.4,148.19) ; PR118.1 PR116.2 57.1,181.76 57.35,181.51 v2(57.35,180.36) 58.29,179.43 PQ6.2 58.29,179.02 57.23,177.96 54.59,177.96 53.98,178.58 v1(53.93,178.58) 53.88,178.58 PQ16.3 ; PQ9050.2 35.01,121.48 v2(34.97,121.43) 34.97,120.42 35.35,120.04 35.35,118.83 33.51,116.99 33.02,116.99 32.68,116.66 32.68,115.97 32.81,115.85 32.81,114.83 32.54,114.56 30.32,114.56 v2(30.17,114.71) ; v2(95.55,94.59) 97.53,94.59 97.98,95.03 PQ12.2
  IN4 w0.089: v1(53.93,178.58) 53.55,178.2 44.24,178.2 38.91,172.87 38.91,169.03 38.29,168.4 38.29,158.81 36.14,156.67 36.14,155.75 v2(34.84,154.45) 35.99,153.31 35.99,146.83 34.21,145.06 33.57,145.06 32.05,143.53 32.05,141.5 32.94,140.61 32.94,133.12 34.84,131.21 34.84,121.69 34.97,121.56 v2(34.97,121.43) ; v2(30.17,114.71) 31.13,113.74 31.13,109.34 29.74,107.95 29.74,106.19 32.68,103.25 32.68,99.95 37.41,95.22 44.67,95.22 45.31,94.59 48.23,94.59 49.07,93.75 49.07,91.97 50.39,90.65 77.21,90.65 77.52,90.95 77.52,92.17 79.73,94.38 93.14,94.38 93.9,95.15 94.99,95.15 v2(95.55,94.59)
  BOTTOM w0.114: v2(19.4,148.19) 19.4,149.55 25.21,155.36 28.03,155.36 28.33,155.06 34.03,155.06 34.64,154.45 v2(34.84,154.45)
MB_GSENSOR_INT: length 8.3
  TOP w0.114: U6516.D5 156,215.53 v2(156,215.67) 156,216.56 155.9,216.66 R68994.2
  BOTTOM w0.114: R25641.2 v2(151.58,214.92) 153.35,214.92 153.46,215.03 154.22,215.03 154.35,215.16 155.24,215.16 155.75,215.67 v2(156,215.67)
MBCLK: length 296.2
  TOP w0.114: v1(170.86,124.33) 170.1,123.57 170.1,120.88 165.86,116.63 v2(165.86,116.42) 165.86,115.16 165.1,114.4 163.19,114.4 162.4,113.61 162.4,113.13 162.23,112.95 R361.1 161.79,112.95 161.67,112.83 161.67,112.49 161.33,112.15 160.84,112.15 160.66,111.97 U37.110 ; v2(205.15,99.34) 205.15,100.1 204.39,100.86 204.39,102.18 205.61,103.4 207.79,103.4 213.84,109.45 213.84,111.29 212.85,112.28 212.85,118.06 211.75,119.15 v2(211.75,121.43) 211.25,121.94 v2(211.25,122.25)
  IN1 w0.089: v2(205.15,99.34) 204.74,98.93 204.16,98.93 203.37,99.72 203.12,99.72 202.74,99.34 198.17,99.34 197.28,100.23 193.8,100.23 193.59,100.02 174.25,100.02 173.76,100.5 168.93,100.5 168.7,100.73 163.37,100.73 162.99,101.11 162.73,101.11 161.97,101.88 161.97,102.64 161.72,102.89 160.07,102.89 159.18,102 147.82,102 146.72,103.1 144.79,103.1 144.72,103.17 139.52,103.17 139.19,102.84 132.89,102.84 132.38,103.35 129.76,103.35 129.61,103.5 117.39,103.5 117.26,103.37 115.59,103.37 115.16,102.94 109.85,102.94 108.71,104.09 v1(107.82,104.09)
  IN3 w0.102: v1(170.86,124.33) 170.61,124.58 170.61,125.75 169.21,127.15 169.21,134.52 168.32,135.4 168.32,139.98 168.63,140.28 168.63,144.85 168.85,145.08 168.85,146.02 169.72,146.88 169.72,149.37 169.87,149.53 169.87,151.25 169.72,151.41 169.72,153.49 170.1,153.87 170.1,155.98 169.46,156.61 169.46,157.3 169.11,157.65 169.11,158.98 167.25,160.83 167.25,167.08 165.24,169.09 159.86,169.09 158.62,170.33 155.75,170.33 155.62,170.46 143.68,170.46 141.14,173 141.14,174.9 139.62,176.43 134.41,176.43 134.28,176.3 134.28,174.9 134.47,174.72 v2(135.26,174.72)
  IN4 w0.089: v2(165.86,116.42) 166.37,116.42 167.86,117.9 171.9,117.9 173.05,119.05 176.73,119.05 177.72,120.04 177.72,121.31 180.64,124.23 187.1,124.23 arc(187.12,124.23) 187.13,124.22 188.39,122.96 190.29,122.96 192.45,125.12 199.82,125.12 200.2,125.5 204.01,125.5 206.29,123.21 209.34,123.21 210.31,122.25 v2(211.25,122.25)
  BOTTOM w0.114: v2(165.86,116.42) 165.83,116.42 165.83,116.42 165.16,116.42 164.77,116.81 163.8,116.81 163.64,116.97 PR17.2 ; v1(107.82,104.09) 108.23,104.5 PC11.1 108.23,105.45 108.08,105.6 PD4.1 108.72,106.17 PR12.2 ; v2(135.26,174.72) 135.47,174.92 Q13.3
MBCLK_THM: length 162.3
  IN1 w0.089: v1(192.37,124.1) 192.37,122.68 190.77,121.08 188.41,121.08 187.52,120.19 184.93,120.19 183.56,121.56 182.16,121.56 181.99,121.38 179.75,121.38 179.12,122.02 177.69,122.02 177.36,122.35 170.2,122.35 168.6,123.95 168.6,124.84 166.54,126.9 164.46,126.9 163.06,128.29 159.76,128.29 158.16,129.89 158.16,131.29 156.1,133.35 155.57,133.35 151.86,137.06 144.19,137.06 141.96,139.29 141.96,144.9 140.1,146.76 140.1,164.72 139.1,165.72 137.01,165.72 133.41,169.31 125.27,169.31 123.59,170.99 123.59,173.28 123.06,173.81 123.06,175.36 118.82,179.6 118.54,179.6 117.5,180.64 114.24,180.64 113.53,179.93 112.06,179.93 111.77,180.22 107.65,180.22 107.51,180.08 105.23,180.08 104.59,180.72 102.71,180.72 101.67,181.76 101.32,181.76 100.17,182.9 92.4,182.9 v1(91.89,182.39)
  BOTTOM w0.114: U2.8 88.53,187.51 88.95,187.09 88.95,186.05 90.36,184.64 91.43,184.64 91.77,184.3 v2(92.2,184.3) 92.45,184.55 R67858.2 93.17,184.07 93.12,184.03 Q6564.4 92.29,183.45 91.89,183.05 v1(91.89,182.39) ; v1(192.37,124.1) 192.35,124.13 192.35,124.89 193.3,125.84 U6517.8
MBDATA: length 299.5
  TOP w0.114: v2(211.25,122.96) 210.74,122.45 210.74,121.82 211.13,121.42 211.13,119.14 212.48,117.79 212.48,112.12 213.41,111.2 213.41,109.56 207.63,103.78 205.4,103.78 204.01,102.38 204.01,100.44 204.47,99.98 v2(204.47,99.34) ; U37.111 160.26,112.1 160.57,112.42 161.08,112.42 161.26,112.59 R369.1 161.06,112.95 160.91,113.11 160.91,113.67 161.64,114.4 162.68,114.4 162.99,114.7 164.89,114.7 165.39,115.2 v2(165.39,116.88) 165.55,116.88 169.72,121.05 169.72,123.21 v2(169.34,123.59) 170.12,124.38 v1(170.25,124.38)
  IN1 w0.089: v1(110.21,104.09) 109.8,103.68 109.8,103.5 110.02,103.29 114.99,103.29 115.44,103.73 117.13,103.73 117.26,103.86 129.76,103.86 129.92,103.7 132.74,103.7 133.14,103.3 139.01,103.3 139.24,103.53 144.88,103.53 144.96,103.44 146.89,103.44 147.98,102.36 159.02,102.36 159.94,103.27 161.84,103.27 162.33,102.79 162.33,102.03 162.86,101.5 163.11,101.5 163.5,101.11 168.96,101.11 169.21,100.86 173.91,100.86 174.41,100.36 193.19,100.36 193.44,100.61 197.44,100.61 198.32,99.72 202.61,99.72 202.99,100.1 203.7,100.1 v2(204.47,99.34)
  IN3 w0.102: v2(133.52,177.15) 133.78,176.9 133.78,174.39 133.92,174.25 135.42,174.25 135.74,174.56 135.74,175.85 135.93,176.04 139.37,176.04 140.76,174.65 140.76,172.74 143.43,170.08 155.24,170.08 155.37,169.95 158.48,169.95 159.69,168.73 165.03,168.73 166.88,166.89 166.88,160.7 168.7,158.87 168.7,157.53 169.08,157.15 169.08,156.45 169.74,155.79 169.74,154.1 169.34,153.69 169.34,151.28 169.51,151.1 169.51,149.68 169.34,149.5 169.34,147.01 168.45,146.12 168.45,145.31 168.27,145.13 168.27,140.61 167.94,140.28 167.94,135.28 168.83,134.39 168.83,126.92 170.25,125.5 v1(170.25,124.38)
  IN4 w0.089: v2(165.39,116.88) 166.18,116.88 167.56,118.26 171.62,118.26 172.77,119.4 176.58,119.4 177.34,120.16 177.34,121.43 180.51,124.61 187.24,124.61 188.47,123.38 190.08,123.38 192.2,125.5 199.56,125.5 199.94,125.88 204.13,125.88 206.42,123.59 210.61,123.59 v2(211.25,122.96)
  BOTTOM w0.114: v1(110.21,104.09) 110.21,104.19 110.66,104.64 110.66,105.16 PC10.1 PR13.2 109.31,106.54 PD3.1 ; v2(165.39,116.88) 165.16,117.12 163.93,117.12 163.67,117.37 163.37,117.37 163.11,117.63 PR19.2 ; v2(133.52,177.15) 133.52,176.68 133.79,176.42 Q13.6
MBDATA_THM: length 166.5
  IN1 w0.089: v1(192.98,124.1) 192.98,122.78 190.93,120.72 188.82,120.72 187.93,119.83 184.78,119.83 183.43,121.18 182.39,121.18 182.24,121.03 179.57,121.03 178.94,121.66 177.54,121.66 177.21,121.99 170.05,121.99 168.24,123.8 168.24,124.69 166.42,126.51 164.33,126.51 162.94,127.91 159.63,127.91 157.78,129.77 157.78,131.16 155.95,132.99 155.42,132.99 151.71,136.7 144.04,136.7 141.6,139.14 141.6,144.73 139.75,146.58 139.75,164.56 138.93,165.38 136.85,165.38 133.27,168.96 125.04,168.96 123.21,170.79 123.21,173.02 122.7,173.53 122.7,175.21 118.69,179.22 118.36,179.22 117.29,180.29 114.4,180.29 113.69,179.57 111.91,179.57 111.61,179.87 107.96,179.87 107.82,179.73 105.07,179.73 104.44,180.36 102.56,180.36 101.54,181.38 101.14,181.38 99.99,182.52 93.47,182.52 92.5,181.56 v1(92.5,181.35)
  BOTTOM w0.114: U2.7 88.42,186.86 88.56,186.71 88.56,186.08 90.27,184.37 91.13,184.37 91.31,184.19 91.31,182.01 91.56,181.76 92.1,181.76 v1(92.5,181.35) 92.63,181.23 92.63,180.62 92.76,180.49 92.76,180.31 93.82,179.24 94.69,179.24 95.14,179.7 95.14,180.1 94.86,180.37 R67857.2 94.86,180.71 94.42,181.15 Q6564.1 ; v1(192.98,124.1) 192.98,124.71 v2(193.47,125.19) U6517.7
MBP0#: length 4.2
  BOTTOM w0.102: U6539.Y2 123.53,157.15 124.48,157.15 124.76,156.87 125.9,156.87 126.41,157.38 R68308.2
MBP1#: length 5.4
  BOTTOM w0.102: R68309.2 126.92,155.85 126.66,156.11 125.65,156.11 125.32,156.44 124.56,156.44 124.38,156.61 123.74,156.61 123.59,156.46 123.59,156.08 123.44,155.93 122.99,155.93 122.94,155.98 122.81,156.11 U6539.AB4
MBP2#: length 8.9
  TOP w0.114: R68310.2 129.46,162.2 128.85,161.59 v2(128.85,161.44) 128.85,160.73 128.54,160.42 123.36,160.42 123.18,160.24 122.86,160.24 122.85,160.23 v1(122.83,160.23)
  BOTTOM w0.102: U6539.M4 122.83,160.4 v1(122.83,160.23)
MBP3#: length 3.3
  BOTTOM w0.102: R68311.2 125.45,156.61 125.42,156.64 124.66,156.64 124.42,156.88 U6539.Y1
MCT1: length 3.6
  TOP w0.114: v2(38.53,187.65) 38.53,186.99 v2(38.5,186.97)
  TOP w0.508: v2(38.5,186.97) 38.5,186.17 38.15,185.81 R516.2
  BOTTOM w0.508: U25.24 v2(38.5,186.97)
MCT2: length 3.6
  TOP w0.114: v2(35.73,187.47) v2(35.73,186.74)
  TOP w0.508: R517.2 35.86,185.81 35.73,185.94 v2(35.73,186.74)
  BOTTOM w0.508: v2(35.73,186.74) 35.5,186.97 U25.21
MCT3: length 4.4
  TOP w0.114: R518.2 33.45,185.69 33.46,185.7 33.83,185.7 v2(34.06,185.47)
  TOP w0.508: v2(32.5,186.97) 32.5,185.87 32.56,185.81 R518.2
  BOTTOM w0.508: U25.18 v2(32.5,186.97)
MCT4: length 4.5
  TOP w0.114: v2(28.75,186.08) 28.87,186.2 28.87,186.7 29,186.82 v2(29.5,186.82)
  TOP w0.508: R519.2 30.14,185.81 30.03,185.81 29.5,186.34 v2(29.5,186.82)
  BOTTOM w0.508: U25.15 v2(29.5,186.82)
MDI0+: length 28.8
  TOP w0.089: v2(23.76,170.18) 23.48,170.46 23.16,170.46 22.62,169.92 22.62,169.74 22.69,169.67 U6521.13
  BOTTOM w0.089: v2(23.76,170.18) 23.46,170.48 23.13,170.48 22.27,171.35 22.27,172.97 22.54,173.25 22.91,173.25 23.83,172.33 24.2,172.33 24.37,172.5 24.37,172.68 23.98,173.07 23.98,173.44 24.43,173.89 24.79,173.89 25.25,173.43 25.43,173.43 25.7,173.7 25.7,174.01 25.19,174.52 25.19,174.97 25.61,175.38 25.98,175.38 27.22,174.14 27.4,174.14 27.69,174.43 27.69,174.61 26.84,175.46 26.84,175.91 27.1,176.17 27.82,176.17 29.09,174.9 29.27,174.9 29.79,175.43 29.79,175.7 28.63,176.85 28.63,177.2 29.1,177.67 30.68,177.67 30.84,177.83 30.84,178.22 30.5,178.56 U25.9
