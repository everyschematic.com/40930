# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N34070870: length 1.2
  TOP w0.114: v1(107.76,156.74) 107.76,157.23 TP13418.1
  BOTTOM w0.102: v1(107.76,156.74) U6539.W37
N34070885: length 1.4
  TOP w0.114: TP13419.1 119.12,148.16 v1(118.46,148.16)
  BOTTOM w0.102: v1(118.46,148.16) 118.51,148.1 118.79,148.1 U6539.AY12
N34070900: length 1.5
  TOP w0.114: v1(107.06,156.74) 107.08,156.74 TP13420.1
  BOTTOM w0.102: U6539.W38 107.11,156.79 v1(107.06,156.74)
N34070915: length 2.5
  TOP w0.102: v1(106.83,158.62) 107.23,159.03 107.74,159.03 108.35,159.64
  TOP w0.114: 108.35,159.64 TP13421.1
  BOTTOM w0.102: v1(106.83,158.62) 107.11,158.34 U6539.U38
N34108788: length 7.1
  BOTTOM w0.079: 101.1,120.12 101.52,120.55 101.52,120.67 101.65,120.8 101.65,121.76 U6539.DV51
  BOTTOM w0.102: R69064.1 96.72,119.43 96.82,119.53 99.49,119.53 100.08,120.12 101.1,120.12
N34384094: length 2.3
  BOTTOM w0.114: R68972.1 26.83,43.21 26.35,43.7 U6564.4
N34859022: length 2.9
  TOP w0.508: Q6646.3 58.86,174.16 v2(58.39,173.68) 57.59,173.68 R69073.2
N34933887:
  vias: v2(13.84,37.41)
N34933983: length 2.9
  BOTTOM w0.114: Q21.2 31.81,27.19 v2(31.62,27)
  BOTTOM w0.203: Q21.2 31.37,28.13 31.26,28.25 R69076.1 R69077.1
N34974672: length 2.1
  TOP w0.114: R101.1 138.12,100.13 137.98,99.98 Q6651.3 137.98,99.33 138.09,99.21 138.35,99.21 138.48,99.34 Q6651.2
N35012653: length 8.1
  TOP w0.114: R25468.1 111.74,179.06 R69109.2 112.85,179.06 113.9,178.02 115.86,178.02 116.48,178.63 D13161.1 116.94,179.75 116.74,179.96 Q6652.3
N35456412: length 5.4
  TOP w0.114: U37.87 168.44,105.94 v2(168.89,106.39) 169.23,106.73 169.9,106.73 170.29,106.34 R69085.2 170.94,106.97 R68868.1 171.34,106.92 R69107.2
N35456674: length 5
  TOP w0.114: R69103.2 156.53,114.8 156.48,114.86 155.92,114.86 155.8,114.73 R69087.2 156.05,114.4 156.23,114.22 156.23,113.66 156.39,113.51 R69086.2 156.39,113.18 v2(157.02,112.54) 157.06,112.5 U37.119
N35456734: length 83.7
  TOP w0.114: U37.95 166.64,109.14 166.54,109.24 166.54,109.72 166.78,109.96 R69088.2 169.39,109.96 169.62,110.18 v1(169.62,110.87) ; R68883.1 174.05,115.36 174.57,114.85 v1(174.57,114.8) ; v2(204.11,97.08) 204.02,97.17 R68568.2 ; v1(147.77,104.8) 147.77,103.85 147.43,103.51 147.43,103.42 147.18,103.17 R69014.2
  IN2 w0.102: v1(147.77,104.8) 147.82,104.75 150.89,104.75 152.54,106.4 154.04,106.4 154.37,106.73 160.02,106.73 161.08,107.79 161.08,108.61 161.62,109.14 166.95,109.14 168.27,110.46 169.21,110.46 v1(169.62,110.87) 170.86,112.11 171.14,112.11 172.79,113.76 173.53,113.76 v1(174.57,114.8) 174.85,115.08 176.59,115.08 176.83,114.84 176.83,113.99 178.33,112.49 180,112.49 180.51,111.99 183.03,111.99 184.22,110.79 184.22,109.87 185.96,108.12 194.94,108.12 195.17,108.35 v2(195.27,108.35)
  IN4 w0.089: v2(195.27,108.35) 195.32,108.3 195.32,104.16 195.88,103.6 195.88,100.61 197.2,99.29 199.89,99.29 202.01,97.17 204.02,97.17 v2(204.11,97.08)
N35456780: length 51.6
  TOP w0.102: 151.96,102.74 U37.18
  TOP w0.114: 151.96,102.74 153.29,102.74 154.17,103.62 v1(154.17,103.93) ; R68570.1 169.97,111.78 169.72,111.53 168.96,111.53 168.55,111.12 168.55,110.61 168.19,110.26 166.7,110.26 165.3,108.86 165.3,108 163.81,106.51 v1(163.81,104.29) ; U37.18 151,102.74 150.89,102.64 150.49,102.64 v2(150.44,102.59) 150.41,102.56 R69089.1 149.75,102.16 149.57,101.98 R69090.1 ; R68736.1 135.31,102.51 135.76,102.51 136.44,103.2 v2(136.44,103.45) 136.7,103.71 v1(136.7,104.16) 136.7,104.76 R69080.1
  IN1 w0.089: v1(136.7,104.16) 136.82,104.04 138.6,104.04 138.76,104.19 145.15,104.19 145.23,104.1 147.8,104.1 148.08,103.83 149.09,103.83 149.78,103.15 153.39,103.15 v1(154.17,103.93) 154.96,103.15 158.86,103.15 160.63,104.92 163.18,104.92 v1(163.81,104.29)
N35630525: length 3.7
  BOTTOM w0.114: R68975.1 15.68,43.97 15.84,44.14 15.84,45.36 v2(15.49,45.72) 15.31,45.9 U6555.18
N35745518: length 2.7
  BOTTOM w0.203: PR7064.1 162.25,139.06 162.25,139.06 162,139.06 161.87,138.93 161.87,138.57 161.69,138.4 161.42,138.4 161.29,138.27 PR7065.1 PR7063.2
N35745545: length 1.7
  BOTTOM w0.508: PR7071.2 153.73,130.32 PQ7002.4
N35745570: length 1.9
  BOTTOM w0.114: v2(166.7,130.17) 166.47,129.94 PR7084.2
  BOTTOM w0.203: PC7068.2 165.89,130.83 PR7084.2
N35745574: length 2.4
  BOTTOM w0.114: v2(168.96,131.39) 168.96,131.91 PR7083.1
  BOTTOM w0.203: PC7067.2 PR7083.1
N35745601:
  vias: v2(146.96,131.31)
N35785828: length 4.7
  BOTTOM w0.102: R69091.2 108.79,111.74 108.19,111.14
  BOTTOM w0.114: Q6649.3 107.14,109.01 R68392.2 107.87,109.01 108.05,109.19 108.05,110.16 107.98,110.22 107.98,110.69 108.19,110.9 108.19,111.14
N36079396: length 4.6
  TOP w0.381: Q6655.3 20.65,76.88 21,77.24 v2(22.73,77.24) C96930.2 23.44,77.72 23.28,77.88 R69092.1
N36079412: length 9.2
  TOP w0.114: Q6656.3 22.8,80.68 v2(22.39,80.28) 21.6,79.48 Q6655.2 20.45,78.56 20.19,78.81 20.19,79.14 20.06,79.27 18.84,79.27 18.69,79.11 C96929.2 R69093.2
N36122863: length 8.6
  TOP w0.114: v2(20.7,79.19) 20.7,79.65 v2(20.92,79.88) 21.51,80.46 R69099.1
  IN1 w0.089: v2(21.56,74.95) 21.56,78.33 v2(20.7,79.19)
  BOTTOM w0.114: CN16.54 21.1,74.29 21.56,74.75 v2(21.56,74.95)
N36201799: length 37.2
  TOP w0.114: v1(134.72,104.16) 134.78,104.1 134.78,103.15 R69101.1 ; U37.93 166.43,108.34 v1(166.37,108.28)
  IN2 w0.102: v1(166.37,108.28) 166.37,108.3 166.36,108.31 166.36,108.66 166.14,108.89 161.79,108.89 161.39,108.48 161.39,107.74 160.14,106.5 154.46,106.5 154.13,106.17 152.63,106.17 150.98,104.52 148.18,104.52 148.05,104.39 138.83,104.39 138.43,103.98 137.64,103.98 137.05,104.57 135.12,104.57 v1(134.72,104.16)
N36446693: length 2.7
  TOP w0.114: Y4.3 30.96,170.96 C639.2 29.61,170.61 29.77,170.45 R512.2
N36874581:
  vias: v2(61.72,176.37)
N36969721: length 2.4
  BOTTOM w0.114: QG17.3 113.81,177.79 RG79.2 113.74,178.28 v2(113.05,178.28) 113.03,178.25 QG17.2
N36969723: length 6.2
  BOTTOM w0.114: DG4.3 109.44,178.15 v2(109.9,178.61) 110.9,178.61 QG15.1 111.23,178.28 RG77.2 111.23,177.08 111.7,176.6 112.9,176.6 113.03,176.48 QG17.5
N36971051: length 2.3
  BOTTOM w0.114: R69111.2 107.66,174.14 v2(108.33,174.8) 108.79,175.27 DG4.1
N36977514: length 3.5
  BOTTOM w0.114: Q31.3 214.17,120.42 213.38,121.21 v2(213.38,121.31) 213.49,121.41 R579.2 214.7,121.41 214.74,121.37 Q30.2
N37012493: length 2.5
  BOTTOM w0.114: R69110.1 110.02,179.3 110.28,179.04 111.09,179.04 111.45,179.4 QG15.3
N37012817: length 2.2
  BOTTOM w0.114: R69112.2 111.28,176.37 v2(111.2,176.45) 110.51,176.45 110.12,176.06 110.12,175.91 DG4.2
N37162929: length 0.8
  BOTTOM w0.114: TP9023.1 23.91,37.62 R454.1
N37164070: length 3.8
  BOTTOM w0.114: R25371.1 v2(26.46,27.45) 26.46,27.71 26.11,28.06 R734.2 C844.2 C846.2
N37164724: length 0.8
  BOTTOM w0.114: R25371.2 R735.2
N37352433: length 2.1
  BOTTOM w0.61: PC9012.1 104.97,200.89 104.97,201.27 105.2,201.51 v2(105.2,201.71) 105.4,201.91 106.03,202.49
N38680880: length 3.7
  BOTTOM w0.114: R576.1 165.74,124.49 165.48,124.23 165.02,124.23 164.76,123.97 164.76,123.34 164.06,122.64 Q6523.2
N38756671: length 5.2
  TOP w0.114: U37.66 168.28,97.54 168.97,96.85 169.18,96.85 169.31,96.72 C6568.2 169.31,96.18 168.91,95.78 168.57,95.78 v2(168.07,95.27) 168.32,95.02 R25318.1
N38756768: length 38
  TOP w0.114: R69102.1 134.78,105.32 134.46,105 v1(134.46,104.85) ; v1(165.45,103.55) 165.45,103.37 166,102.82 166,101.91 166.37,101.54 U37.76
  IN1 w0.089: v1(134.46,104.85) 134.74,104.57 135.5,104.57 135.71,104.37 135.71,103.96 135.89,103.78 138.73,103.78 138.95,104 145.07,104 145.15,103.91 147.49,103.91 148.51,102.89 158.87,102.89 160.4,104.42 163.11,104.42 164.26,103.27 165.17,103.27 v1(165.45,103.55)
N38756834: length 9.8
  BOTTOM w0.114: R25321.2 13.75,154.32 12.88,153.44 SW2.4 SW2.3 v2(11.97,148.36) 11.97,148 Q81.3
N38757336: length 4.9
  TOP w0.114: R25308.1 C6563.1 151.12,110.69 v2(151.18,110.64) 151.43,110.64 151.53,110.54 152.8,110.54 153.1,110.24 153.33,110.24 153.46,110.36 U37.128
N38757406: length 95.6
  IN4 w0.089: v2(43.12,158.92) 42.49,159.56 42.49,171.11 45.87,174.49 56.48,174.49 59.35,177.37 59.35,184.05 60.5,185.19 60.5,187.6 61.13,188.24 v2(61.72,188.24)
  BOTTOM w0.114: Q81.2 15.1,148.29 15.22,148.17 v2(15.73,148.17) 15.92,147.98 C1044.1 16.78,147.44 24.97,155.63 28.14,155.63 28.44,155.33 32.67,155.33 34.08,156.74 35.88,156.74 36.77,157.63 41.83,157.63 v2(43.12,158.92) ; R25310.2 68.47,181.22 68.37,181.12 67.86,181.12 67.65,180.91 SW4.4 66.56,179.9 66.43,180.03 66.43,181.98 67.65,183.2 SW4.3 65.94,186.1 64.82,187.21 62.79,187.21 61.77,188.24 v2(61.72,188.24)
N38758998: length 1.9
  TOP w0.114: R402.1 149.22,104.85 149.01,104.64 v2(148.49,104.64) 148.23,104.9 148.23,105.35 C6562.2
N38759178: length 2.9
  TOP w0.114: U37.12 150.81,105.14 150.24,105.71 v2(150.24,106.04) 149.85,106.04 C1190.1
N40437801: length 10
  BOTTOM w0.114: TP9033.1 118.99,193.58 119.77,194.36 123.77,194.36 123.97,194.56 123.97,195.81 124.2,196.04 124.74,196.04 U8.V7
N40437812: length 9.3
  BOTTOM w0.114: U8.W7 124.72,196.83 124.08,196.83 123.89,196.64 123.89,196.28 123.63,196.02 120.41,196.02 119.29,194.91 TP9032.1
N40437815: length 7.7
  BOTTOM w0.114: TP9031.1 117.64,196.75 119.97,196.75 120.1,196.88 123.73,196.88 124.11,197.27 U8.W6
N40437818: length 8.8
  BOTTOM w0.114: TP9030.1 117.34,198.04 118.35,197.04 119.57,197.04 120.24,197.71 123.96,197.71 U8.Y6
N40911013: length 5.1
  BOTTOM w0.127: VRAM1.J13 159.4,182.62 159.02,183 159.02,183.47 158.27,184.21 v2(158.27,185.82) 158.27,186.18 158.77,186.68 R405.2
N40911015: length 4.6
  BOTTOM w0.102: VRAM2.J13 159,195.62 159,194.18
  BOTTOM w0.114: R406.2 158.61,192.41 v2(158.78,192.58) 159,192.8 159,194.18
N41129495: length 22.6
  TOP w0.114: R68505.1 116.48,115.44 v2(116.12,115.08) 115.51,115.08 R68506.1 115.69,115.41 115.69,115.52 v1(115.23,115.97)
  IN2 w0.178: 112.06,127.78 112.31,127.78 112.57,128.04 112.57,129.16 v1(112.12,129.61)
  IN2 w0.254: v1(115.23,115.97) 115.11,115.97 114.73,116.35 114.73,116.99 114.22,117.5 111.17,117.5 110.03,118.64 110.03,122.32 110.79,123.09 110.92,123.09 111.3,123.47 111.3,127.4 111.68,127.78 112.06,127.78
  BOTTOM w0.2: U6539.DA28 111.74,129.31 v1(112.12,129.61)
N41131693: length 7.4
  TOP w0.114: Q6583.2 v2(85.26,168.37) 84.7,168.37 84.5,168.17 83.48,168.17 83.23,168.42 83.23,170.82 Q6582.3 83.01,171.05 R68250.2
N41131697: length 11.3
  TOP w0.114: Q6582.2 82.15,168.36 82.72,167.79 v2(89.83,167.79) R68254.2 90.75,168.18 90.87,168.3 91.61,168.3 91.77,168.14 R68256.2
N41733375: length 9.9
  TOP w0.089: v1(109.93,126.36) 110.3,125.99 110.3,122.85 109.52,122.07
  TOP w0.114: TP13424.1 109.52,117.9 109.52,122.07
  BOTTOM w0.102: v1(109.93,126.36) 110.06,126.36 U6539.DG31
N43472926: length 2.8
  TOP w0.114: R68380.2 120.16,110.27 119.99,110.11 119.78,110.11 119.65,109.98 R68386.1 119.94,109.75 120.14,109.55 v2(120.47,109.55) 120.82,109.9 R68381.2
N43474340: length 2.7
  TOP w0.114: R68376.1 123.49,112.67 v2(123.06,112.24) 122.98,112.16 R68370.2 R68369.2
N43686188: length 2.3
  TOP w0.254: PR9275.1 163.37,120.82 v2(162.83,120.29) 162.66,120.29 162.26,120.69 PQ17.3
N44885066: length 4.4
  TOP w0.254: PD9002.3 155,121.91 v2(154.86,122.04) v2(154.86,122.71)
  BOTTOM w0.254: v2(154.86,122.71) 154.86,123.38 154.63,123.62 PR16.2
N44994019: length 2.4
  TOP w0.114: R25526.1 33.07,155.44 v2(33.02,155.39) 32.58,155.39 32.49,155.49 32.31,155.49 32.18,155.36 U67.9
N44994033: length 1.6
  TOP w0.114: U67.10 31.78,155.45 32.18,155.85 R25527.1
N44994150: length 5.6
  TOP w0.114: U67.11 31.38,155.56 31.57,155.75 31.57,157.4 31.9,157.73 33.47,157.73 TP2.1
N44994160: length 3.5
  TOP w0.114: TP9046.1 30.78,157.38 31.24,156.92 31.24,155.88 30.98,155.63 U67.12
N44994181: length 1.4
  TOP w0.114: U67.13 30.58,156.03 TP9064.1
N45124268:
  vias: v2(28.44,177.03)
N45302727: length 3.1
  BOTTOM w0.114: Q21.3 34.29,29.55 v2(34.29,30.71) 33.71,31.28 D12.1
N45366166: length 3.7
  BOTTOM w0.114: v2(202.81,123.59) 202.51,123.9 202.51,124.25 202.21,124.55 C96272.1 202.05,124.61 201.47,125.19 U6517.2
N45366191: length 2.4
  BOTTOM w0.114: C96272.2 201.87,124.1 v2(201.29,124.69) 201.14,124.54 U6517.3
N45366210: length 2.4
  BOTTOM w0.114: U6517.4 200.58,123.89 200.71,123.76 200.71,123.01 v2(200.82,122.89) 201.01,122.7 R67422.2
N45497503: length 1.2
  TOP w0.114: TP13384.1 39.96,99.24 PR8015.1
N45500595: length 3.1
  TOP w0.114: PU8000.1 23.22,116.75 v2(23.29,116.68) 23.6,116.37 PC8005.1 PR8033.2
N45500603: length 8.9
  TOP w0.114: PU8000.3 22.79,118.65 23.24,119.1 PC8007.1 23.74,118.91 PR8040.2 PR8035.2 24.28,118.31 24.52,118.55 25,118.55 25.14,118.41 25.14,117.94 25.54,117.55 v2(26.61,117.55) 28.31,117.55 PQ8015.3
N45500619: length 8.4
  TOP w0.114: PR8035.1 24.73,117.28 24.86,117.15 PR8033.1 25.66,117.15 25.91,116.91 27.99,116.91 28.32,116.57 28.32,115.88 v2(28.14,115.69) 27.49,115.05 PD8002.1 PD8003.1
N45500625: length 3.9
  TOP w0.114: PR8045.1 v2(25.27,112.57) PR8047.1 PR8042.1 25.93,113.93 25.82,114.05 25.24,114.05 25.08,113.89 PQ8016.6
N45500627: length 2.1
  TOP w0.114: PQ8016.5 24.43,113.1 24.15,112.83 PR8045.2 24.15,112.32 23.95,112.11 v2(23.49,112.11)
N45500633: length 3.2
  TOP w0.114: PR8048.1 26.16,115.72 26.16,115.8 26.57,116.21 PR8046.1 25.93,116.4 v2(25.9,116.43) 25.33,115.86 25.19,115.86 25.08,115.75 PQ8016.1
N45500637: length 5.1
  TOP w0.114: PR8047.2 26.41,112.59 26.64,112.59 26.97,112.93 26.97,113.83 26.22,114.58 v2(26.03,114.58) 25.98,114.53 24.56,114.53 24.43,114.65 PQ8016.2
N45500667: length 6.8
  TOP w0.114: v2(15.67,115.47) 16.97,114.16 PR8034.1 17.86,114.16 17.88,114.14 PR8037.1 18.82,114.14 19.35,114.66 20.09,114.66 20.67,114.09 PQ8014.3
N45500689: length 3.9
  TOP w0.114: PU8000.4 18.32,118.65 PR8039.1 17.7,118.45 PR8036.1 16.37,117.73 v2(16.1,118.01)
N45500733: length 8.8
  TOP w0.114: v2(28.04,118.28) 28.57,117.75 29.23,117.75 29.89,117.09 29.89,116.35 30.08,116.17 PQ8015.2 30.74,117.01 31.08,117.35 PR8043.1 PR8038.2 31.59,116.78 31.36,116.55 31.36,115.21 31.49,115.08 PR8041.2
N45509729: length 4.2
  TOP w0.114: v2(35.12,115.21) 35.85,114.48 PR8052.1 35.85,114.08 36.11,113.81 36.49,113.81 36.63,113.68 PC8008.2 36.63,113 36.35,112.73 PU8001.1
N45509733: length 8.8
  TOP w0.114: PR8052.2 36.63,114.57 36.37,114.83 35.99,114.83 35.6,115.21 35.6,115.47 35.38,115.69 33.55,115.69 33.32,115.47 33.32,114.83 33.65,114.5 PR8054.1 33.02,114.2 v2(32.99,114.17) 32.71,113.89 PD8006.1 PD8007.1
N45509737: length 4.4
  TOP w0.114: PU8001.4 34.45,108.72 33.82,108.1 PR8055.1 32.64,108.1 v2(32.3,108.43) 32.14,108.59 PR8053.2
N45509757: length 17.3
  TOP w0.114: v2(33.8,115.21) 33.8,115.11 34.1,114.81 PR8054.2 PR8057.1 34.64,113.62 PC8011.1 34.45,112.91 PU8001.3 ; v2(23.02,111.58) PQ8019.3
  BOTTOM w0.114: v2(33.8,115.21) 28.39,115.21 27.04,113.86 25.29,113.86 v2(23.02,111.58)
N45509773: length 5.3
  TOP w0.114: v2(22.73,113.31) 21.19,111.77 PQ8019.2 20.47,111.22 PR8064.1 PR8058.2 19.5,111.76 19.3,111.96 PR8060.1
N45509797: length 5.3
  TOP w0.114: PR8061.1 27.78,112.2 27.64,112.33 26.77,112.33 26.56,112.13 26.22,112.13 25.94,111.85 PQ8018.6 25.94,111.31 25.81,111.19 25.46,111.19 25.32,111.33 PR8056.1 PR8062.1 24.36,110.76 v2(24.2,110.92)
N45509799: length 2.9
  TOP w0.114: PQ8018.5 26.59,111.78 26.88,112.07 27.51,112.07 27.83,111.75 PR8061.2 28.2,111.75 28.49,112.04 v2(28.8,112.04)
N45509807: length 2.3
  TOP w0.114: PQ8018.2 26.59,110.32 26.41,110.5 25.48,110.5 25.29,110.31 PR8062.2
N45509836: length 3.4
  TOP w0.114: v2(23.79,109.6) 24.28,109.12 24.89,109.12 25.06,109.29 PR8063.1 25.44,109.15 25.76,109.15 25.94,109.33 PQ8018.1
N45509840: length 2.6
  TOP w0.114: v2(31.8,106.58) 31.76,106.61 PR8051.1
  TOP w0.508: PR8051.1 31.76,108.01 31.2,108.57 PQ8017.1
N45515909: length 3.8
  TOP w0.114: v2(31.8,105.18) 31.3,105.68 PR8050.1 30.41,105.68 30.08,106 PD8005.2 28.42,106 PR8049.2
N45782696: length 3.5
  BOTTOM w0.203: R450.1 18.94,26.27 18.94,27.99 19.51,28.56 U20.20
N46166321: length 4.1
  TOP w0.203: R69054.2 133.11,99.72 133.12,99.7 C695.1 133.12,98.08 132.98,97.94 v2(132.71,97.94)
  BOTTOM w0.203: CN33.1 133.1,98.79 132.71,98.4 v2(132.71,97.94)
N46166544: length 3.5
  TOP w0.114: R572.1 126.24,97.78 v2(126.08,97.94) 126.08,98.45 v2(125.88,98.65)
  BOTTOM w0.114: CN33.8 126.1,98.58 126.08,98.56 v2(126.08,97.94)
N46207407: length 5.4
  TOP w0.114: U6509.7 222.52,95.58 222.93,95.18 222.93,94.89 223.44,94.38 223.44,94.13 223.66,93.9 R25558.2 R25554.1 225.29,93.9 v2(225.5,93.7)
N46207590: length 3.8
  TOP w0.114: R25555.2 211.22,95.88 C20040.1 211.85,95.71 v2(212.26,95.3) 212.63,94.93 U6509.23
N46207592: length 4.8
  TOP w0.114: R25557.1 211.36,94.37 211.39,94.4 R25556.2 211.84,94.73 212.13,94.44 212.13,93.44 v2(212.21,93.36) 212.59,92.98 U6509.26
N46213996: length 2.2
  TOP w0.114: R593.2 84.48,99.87 85.03,99.32 U33.18
N46213998: length 6.8
  TOP w0.114: R592.2 82.89,94.67 83.05,94.51 85.39,94.51 v2(85.52,94.64) 88.25,94.64 88.44,94.82 U33.29
N46214095: length 1.1
  TOP w0.114: D22.2 92.38,98.42 92.6,98.19 R600.1
N47271970:
  vias: v2(121.71,176.88)
N47707560: length 3
  BOTTOM w0.114: PR5024.1 74.67,188.69 74.69,188.71 PC5024.2 75.15,188.41 74.98,188.24 74.09,188.24 73.83,187.98 PU5000.1
N47707814: length 1.8
  TOP w0.305: PC5023.1 77.78,185.45 77.64,185.32 PR5022.2
  TOP w0.381: PC5023.1 78.15,186.1 v2(78.25,186.2)
N47707867: length 10.6
  TOP w0.114: v1(70.53,189.38) v2(70.53,186.97) 71.55,185.95 74.09,185.95 74.98,185.06 76.53,185.06 PR5022.1
  BOTTOM w0.114: PR5026.1 71.12,188.92 70.99,189.05 70.86,189.05 v1(70.53,189.38)
N47707873: length 3.5
  TOP w0.508: v2(71.86,185.44) 72.05,185.26 PC5020.1 72,184.63 71.83,184.46 PR5020.2
  BOTTOM w0.508: v2(71.86,185.44) 71.64,185.66 PU5000.4
N47707884: length 2.4
  BOTTOM w0.114: PR5025.1 73.5,188.67 73.53,188.69 PR5024.2 73.94,188.93 74.09,189.08 74.09,189.46 74.06,189.49 PR5023.2
N47707886: length 3.4
  BOTTOM w0.114: PR5026.2 71.57,188.26 71.42,188.11 70.91,188.11 70.83,188.03 PU5000.6 70.11,187.56 70.02,187.47 69.74,187.47 69.61,187.61 PR5027.1
N47707900: length 1.8
  BOTTOM w0.114: PU5000.5 69.79,186.61 69.54,186.35 PR5021.1
N47707998: length 2.1
  TOP w0.508: PR5008.1 86.81,177.91 86.81,178.67 v2(87.04,178.9) PC5008.2
N47708004: length 3.1
  TOP w0.203: PU5001.4 90.79,173.55 v4(90.61,173.36) 90.44,173.2 PR5009.2 90.44,172.08 90.22,171.85 PC5014.1
N47708130: length 2.4
  TOP w0.203: PR5014.1 89.43,172.79 90.39,173.76 PU5001.3
N48587681: length 2.2
  TOP w0.102: v2(124.68,193.47) 124.68,192.61 R329.2
  TOP w0.254: v1(123.96,192.7) 124.06,192.6 R329.2
  BOTTOM w0.254: U8.N6 124.35,192.31 v1(123.96,192.7)
N48650493: length 4.6
  BOTTOM w0.114: Q15.2 105.48,181.15 105.45,181.12 R382.1 105.45,180.26 105.57,180.14 106.88,180.14 107.03,179.98 v2(107.49,179.98) 107.61,180.1 R384.2
N54133206: length 6
  TOP w0.114: U6537.36 27.9,122.41 28.09,122.22 28.27,122.22 28.49,122.45 29.46,122.45 29.85,122.06 30.27,122.06 30.53,121.8 R68202.1 30.94,121.15 31.03,121.05 v2(31.03,119.66)
N64506943: length 2.4
  BOTTOM w0.114: Y5.2 105.89,115.24 105.74,115.39 104.92,115.39 104.79,115.52 R68435.2
N69856481: length 4.1
  TOP w0.114: TP13427.1 123.93,125.65 122.75,125.65 122.6,125.8 122.25,125.8 122.07,125.63 121.01,125.63 120.96,125.68 v1(120.88,125.68)
  BOTTOM w0.102: U6539.DJ6 120.95,125.68 v1(120.88,125.68)
N69856484: length 8.5
  TOP w0.114: TP13428.1 125.09,122.02 v1(125.09,121.41)
  IN4 w0.089: v1(119.94,124.99) 120.31,124.62 120.31,123.85 120.7,123.47 121.08,123.47 121.97,122.58 124.12,122.58 125.09,121.61 v1(125.09,121.41)
  BOTTOM w0.102: U6539.DK8 120.34,125.39 v1(119.94,124.99)
N159797420: length 3
  TOP w0.114: T1.1 59.06,129.09 v2(59.06,129.59)
  BOTTOM w0.114: v2(59.06,129.59) 58.79,129.32 JDIM02.162
N159810220: length 5.6
  TOP w0.114: v2(61.05,129.62) 61.05,129.28 T2.1
  BOTTOM w0.114: JDIM02.165 62.09,128.57 v2(61.05,129.62)
N241366410: length 1.4
  TOP w0.114: U6537.37 29.2,123.55 T3.1
N302640860: length 3
  TOP w0.114: TP9066.1 157.83,211.93 156.12,213.64 U6516.E2
N302641560: length 4.2
  TOP w0.114: TP9069.1 159.18,212.62 157.91,212.62 156.61,213.91 156.56,213.91 156.33,214.14 U6516.E3
N3026424317: length 10.3
  TOP w0.079: 156.74,213.4 156.25,213.89 155.86,213.89 U6516.D3
  TOP w0.114: TP9074.1 160.57,207.92 159.94,208.56 158.41,208.56 158.29,208.68 158.29,210.99 158.41,211.12 158.41,211.73 156.74,213.4

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 95.84,183.41 95.97,183.32 96.13,183.28 96.25,183.3 96.36,183.35 96.43,183.37 96.49,183.34 96.55,183.29 96.62,183.27 96.64,183.26 97.05,182.85 97.05,182.34 96.94,182.2 96.9,182.03 96.9,182.02 96.94,181.84 97.05,181.7 97.05,181.3 96.85,181.1 95.25,181.1 95.19,181.15 94.89,181.15 94.66,181.38 94.66,182.14 94.79,182.27 94.91,182.27 95.01,182.36 95.02,182.48 94.99,182.59 94.99,182.6 94.99,182.79 95.01,182.84 95.02,182.88 95.02,183.07 95.76,183.07 95.76,183.27 95.02,183.27 95.02,183.41
1V8_AON_S on BOTTOM (solid shape): 96.45,183.98 96.45,182.39 96.69,182.15 96.69,181.76 96.57,181.63 95.7,181.63 95.5,181.83 95.5,182.45 95.29,182.66 95.29,183.92 95.3,183.92 95.48,184.11 96.32,184.11
+1.2V on TOP (solid shape): 28.87,143.53 28.87,142.01 28.3,141.44 28.3,139.15 28.11,138.96 26.72,138.96 26.46,139.21 26.46,141.75 27.22,142.52 27.22,143.53 27.6,143.91 28.49,143.91
+1.2V on TOP (solid shape): 27.48,134.26 27.48,133.63 26.97,133.12 26.31,133.12 26.31,133.23 26.26,133.34 26.16,133.38 25.32,133.38 25.32,134.26 25.45,134.39 27.35,134.39
+1.2V on IN4 (solid shape): 27.6,141.5 27.6,140.48 26.46,139.34 26.46,135.53 27.48,134.52 27.48,134.01 27.35,133.88 25.95,133.88 25.57,134.26 25.57,141.25 26.08,141.75 27.35,141.75
+1.2V_HDMI on TOP (solid shape): 26.46,132.74 26.46,130.58 26,130.12 26,128.53 25.97,128.5 25.84,128.5 25.8,128.54 25.8,129.72 25.7,129.82 25.7,130.96 25.32,131.34 25.32,132.74 25.45,132.86 26.34,132.86
+1.2V_HDMI on BOTTOM (solid shape): outline of 393 points within 17.32,122.83 34.59,134.93
+1.2VSUS on TOP (solid shape): 30.53,141.12 30.53,139.98 30.14,139.6 29.38,139.6 28.75,140.23 28.75,141.25 28.87,141.37 30.27,141.37
+1.2VSUS on TOP (solid shape): outline of 28544 points within 43.38,109.55 108.91,181.89
+1.2VSUS on BOTTOM (solid shape): 32.58,140.69 34.77,140.69 37.51,137.94 42.97,137.94 43.35,138.33 43.86,138.33 44.11,138.07 44.11,135.91 43.86,135.66 37,135.66 34.34,138.33 30.4,138.33 29.64,139.09 29.64,140.87 29.76,140.99 32.27,140.99
+1.2VSUS on BOTTOM (solid shape): 90.37,192.86 90.37,192.2 90.57,192 93.21,192 93.67,191.54 93.67,190.89 93.1,190.32 93.1,189.6 92.18,188.68 90.79,188.68 90.7,188.77 90.66,188.85 90.61,188.91 90.58,188.98 90.61,189.05 90.69,189.18 90.72,189.33 90.6,189.62 90.31,189.74 90.28,189.74 90.21,189.75 90.17,189.8 88.95,191.03 88.95,192.94 89.33,193.32 89.91,193.32
+1.2VSUS on BOTTOM (solid shape): outline of 126 points within 53.1,138.63 57.41,144.58
+1.2VSUS on BOTTOM (solid shape): outline of 249 points within 65.03,128.86 68.5,144.23
+1.2VSUS on BOTTOM (solid shape): outline of 274 points within 53.1,128.58 57.41,138.44
+1.2VSUS on BOTTOM (solid shape): outline of 514 points within 106.16,149.39 107.56,156.7
+1.2VSUS on BOTTOM (solid shape): outline of 491 points within 106.16,132.22 107.59,138.77
+1.2VSUS on IN4 (solid shape): 92.76,188.74 92.76,187.47 92.12,186.84 89.83,186.84 88.31,185.32 85.9,185.32 80.73,180.15 80.73,177.8 80.69,177.76 77.14,177.76 77.14,180.37 82.28,185.51 82.28,186.14 83.74,187.6 87.17,187.6 87.68,188.11 90.47,188.11 90.72,188.36 90.72,189.13 90.98,189.38 92.12,189.38
+1.2VSUS_TEMP on TOP (solid shape): 76.63,181.76 76.63,178.08 73.29,178.08 73.01,178.36 72.63,178.36 72.35,178.08 71.38,178.08 71.1,178.36 68.73,178.36 68.63,178.46 68.63,181.51 69.01,181.89 76.5,181.89
+1.2VSUS_TEMP on TOP (solid shape): 89.28,175.79 89.28,175.6 89.27,175.59 88.17,175.59 88.03,175.46 88.03,174.72 87.88,174.57 86.98,174.57 86.83,174.74 86.61,174.8 86.55,174.8 86.49,174.78 86.41,174.8 86.37,174.88 86.37,175.68 86.49,175.8 89.27,175.8
+1.2VSUS_TEMP on BOTTOM (solid shape): 76.5,183.03 76.5,178.46 76.12,178.08 73.83,178.08 73.71,178.2 73.71,179.85 73.45,180.11 70.28,180.11 69.64,179.47 69.26,179.47 69.13,179.6 69.13,179.98 70.15,181 70.15,182.65 70.28,182.78 74.34,182.78 74.72,183.16 76.37,183.16
+1.2VSUS_TEMP on IN1 (solid shape): outline of 234 points within 73.45,174.65 87.93,179.73
+1.2VSUS_VIN on TOP (solid shape): 86.02,179.93 86.02,178.76 85.77,178.51 81.21,178.51 80.88,178.84 80.88,180.45 81.12,180.69 85.26,180.69
+1.2VSUS_VIN on BOTTOM (solid shape): 89.39,181.61 89.45,181.61 89.52,181.61 89.6,181.63 90.98,181.63 91.1,181.51 91.1,179.98 89.98,178.85 89.85,178.94 89.71,178.97 89.47,178.88 89.33,178.66 89.29,178.6 89.2,178.59 89.14,178.6 89.07,178.61 88.79,178.49 88.67,178.2 88.67,178.12 88.7,178.04 88.69,177.93 88.59,177.9 88.54,177.9 88.3,177.82 88.15,177.61 88.1,177.55 88.01,177.55 87.94,177.57 87.85,177.58 87.69,177.54 87.55,177.44 83.36,177.44 81.96,178.84 81.96,179.42 83.38,179.42 83.9,179.94 87.26,179.94 87.8,180.49 87.8,181.51 87.93,181.63 89.31,181.63
+1.5V on BOTTOM (solid shape): 12.89,40.86 12.89,40.41 12.63,40.15 12.11,40.15 11.73,39.77 11.73,38.12 11.86,38 12.24,38 12.36,37.87 12.36,37.36 12.24,37.23 10.59,37.23 10.46,37.36 10.46,41.3 10.57,41.41 12.34,41.41
+1.05V_LAN on TOP (solid shape): 18.39,162.46 17.02,161.09 17.02,160.53 16.89,160.39 15.46,160.39 15.4,160.46 15.37,160.48 15.34,160.5 15.32,160.53 15.33,160.57 15.4,160.72 15.42,160.88 15.4,161.04 15.33,161.18 15.31,161.22 15.78,161.69 16.14,161.69 16.54,161.86 16.7,162.26 16.7,162.44 16.74,162.51 16.82,162.54 16.88,162.53 16.94,162.52 17.34,162.69 17.5,163.09 17.5,163.25 17.54,163.27 17.68,163.32 17.8,163.41 18.39,163.41
+1.05V_LAN on BOTTOM (solid shape): outline of 94 points within 13,157.5 21.33,164.16
+1.05V_LAN on IN2 (solid shape): outline of 418 points within 15.44,161.57 25.83,174.16
+1.05V_LAN_REGOUT on TOP (solid shape): 26.84,167.54 26.84,166.14 26.61,165.9 25.15,165.9 25.08,165.94 25.01,165.95 24.93,165.94 24.86,165.9 24.41,165.9 24.29,166.03 24.29,166.28 24.33,166.32 24.48,166.32 25.63,167.47 25.63,167.65 25.67,167.68 26.26,167.68 26.37,167.79 26.59,167.79
+1.05V_LAN_REGOUT on BOTTOM (solid shape): 12.87,161.82 13,161.73 13.15,161.69 13.31,161.73 13.44,161.82 14.14,161.82 14.4,161.57 14.4,157.63 14.27,157.5 13.51,157.5 13.38,157.63 13.38,159.18 13,159.56 12.72,159.56 12.62,159.66 12.62,159.8 11.87,160.55 11.35,160.55 10.96,160.94 10.96,161.45 11.34,161.82
+1.05V_LAN_REGOUT on IN2 (solid shape): outline of 791 points within 10.66,158.26 26.72,167.92
+1.8V on BOTTOM (solid shape): 30.42,28.17 30.42,27.43 30.44,27.41 30.49,27.32 30.59,27.29 30.95,27.29 30.96,27.28 30.96,27.13 30.91,27.07 29.13,27.07 29,27.2 29,27.66 29.05,27.71 29.76,27.71 29.83,27.77 29.83,27.77 29.89,27.84 29.89,28.22 30.01,28.34 30.25,28.34
+1.8V_DEEP_SUS on TOP (solid shape): 109.9,132.48 109.9,131.85 110.41,131.34 113.09,131.34 113.4,131.04 113.4,130.63 113.5,130.53 113.92,130.53 114.12,130.33 114.12,130 114.24,129.88 115.03,129.88 115.12,129.97 115.12,130.34 115.35,130.56 115.71,130.56 115.79,130.48 115.79,129.94 115.79,129.92 115.71,129.83 115.69,129.73 115.69,129.5 115.69,129.48 115.67,129.46 115.05,128.84 115.05,128.77 115.06,128.76 115.06,127.99 115.01,127.95 111.85,127.95 111.82,127.96 111.8,128 111.8,128.46 111.89,128.55 112.5,128.55 112.73,128.78 112.73,130.55 112.52,130.76 110.56,130.76 109.67,131.65 109.67,131.9 109.65,131.92 109.65,132.1 109.55,132.2 108.94,132.2 108.73,132.41 108.73,132.61 108.76,132.64 109.75,132.64
+1.8V_DEEP_SUS on BOTTOM (solid shape): 128.06,120.28 128.06,119.78 128.32,119.53 128.95,119.53 129.08,119.4 129.08,118.51 128.95,118.39 127.3,118.39 126.41,119.28 126.41,120.55 126.66,120.79 127.55,120.79
+1.8V_DEEP_SUS on SVCC (solid shape): 117.95,130.17 117.93,130.1 117.93,130.03 118.03,129.78 118.28,129.68 118.35,129.68 118.42,129.7 118.74,129.38 118.82,129.33 118.92,129.31 132.38,129.31 132.38,119.76 131.77,119.15 124.87,119.15 124.43,119.58 124.35,119.64 124.25,119.66 121.08,119.66 120.98,119.64 120.9,119.58 119.96,118.64 112.44,118.64 112.44,120.45 112.5,120.56 112.52,120.67 112.5,120.79 112.44,120.89 112.44,127.28 112.42,127.37 112.37,127.46 111.99,127.84 111.9,127.89 111.81,127.91 111.4,127.91 111.3,128.02 111.3,131.85 116.27,131.85
+1.8V_S5 on TOP (solid shape): 39.12,131.49 39.12,130.55 38.82,130.25 38.82,128.51 38.82,127.95 38.65,127.78 35.48,127.78 35.22,128.04 35.22,131.47 35.32,131.57 39.04,131.57
+1.8V_S5 on TOP (solid shape): 93.75,183.45 93.75,182.92 93.71,182.88 93.02,182.88 92.85,182.71 92.85,182.39 92.62,182.16 92.37,182.16 92.3,182.23 92.3,182.6 92.46,182.76 92.46,183.06 93.46,183.06 93.46,183.28 93.04,183.28 93.04,183.06 92.46,183.06 92.46,183.21 92.72,183.47 93.73,183.47
+1.8V_S5 on TOP (solid shape): 93.62,186.28 93.62,186.23 93.66,186.13 93.75,186.08 93.8,186.07 93.8,185.48 93.8,185.27 93.05,185.27 93.05,185.07 93.8,185.07 93.8,184.93 93.75,184.88 93.41,184.88 93.01,184.88 92.31,185.58 92.31,185.64 91.99,185.96 91.86,185.96 90.77,185.96 90.7,186.03 90.63,186.03 90.56,186.1 90.56,186.41 90.69,186.53 92.62,186.53 92.78,186.69 93.22,186.69
+1.8V_S5 on BOTTOM (solid shape): 129.08,117.5 129.08,116.74 128.95,116.61 128.95,115.34 128.82,115.21 127.68,115.21 127.55,115.34 127.55,117.5 127.68,117.62 128.95,117.62
+1.8V_S5 on SVCC (solid shape): 94.28,186.07 94.24,185.97 94.23,185.87 94.24,185.77 94.28,185.68 94.28,180.01 94.26,179.95 94.25,179.88 94.26,179.81 94.28,179.75 94.28,173.5 91.59,173.5 91.26,173.71 90.92,173.5 89.18,173.5 88.84,173.71 88.51,173.5 61.97,173.5 61.23,173.77 60.48,173.5 49.98,173.5 49.23,173.77 48.48,173.5 47.74,173.5 47.64,173.49 47.56,173.43 45.7,171.57 43.62,171.57 43.48,171.72 43.48,176.9 43.89,177.31 58.23,177.31 58.52,177.19 58.8,177.31 84.12,177.31 84.22,177.33 84.3,177.39 86.89,179.98 87.13,180.09 87.24,180.33 89.13,182.21 89.18,182.3 89.2,182.39 89.2,186.61 90.07,187.47 94.28,187.47
+1.8V_S5 on IN2 (solid shape): outline of 5133 points within 34.06,97 129.71,174.33
+1.8V_S5 on IN4 (solid shape): 93.01,185.82 93.01,182.14 92.88,182.01 92.5,182.01 92.25,182.27 92.25,184.68 91.23,185.7 90.85,185.7 90.6,185.95 90.6,186.46 90.72,186.59 92.25,186.59
+1.8V_SENSOR on TOP (solid shape): 155.37,211.86 155.37,210.08 155.75,209.7 155.75,209.06 155.62,208.94 155.24,208.94 155.11,209.06 155.11,209.7 154.83,209.98 154.83,209.99 154.83,210.82 154.83,211.96 154.99,212.11 155.11,212.11
+1.8V_SM on TOP (solid shape): 214.65,100.28 214.65,100.03 214.58,99.96 212.93,99.96 212.88,99.91 212.88,99.69 212.92,99.65 214.6,99.65 214.62,99.63 214.62,99.37 214.56,99.3 212.92,99.3 212.88,99.26 212.88,99.06 212.93,99.01 214.57,99.01 214.62,98.96 214.62,98.69 214.58,98.66 211.22,98.66 211.11,98.77 211.11,100.24 211.2,100.33 214.6,100.33
+1.35V_GFX on TOP (solid shape): outline of 12636 points within 130.02,168.58 168.47,207.4
+1.35V_GFX on BOTTOM (solid shape): 164.92,174.94 164.97,174.95 165.03,174.95 165.09,174.89 165.08,174.82 165.18,174.6 165.4,174.51 165.42,174.51 165.5,174.48 165.53,174.41 165.58,174.27 165.68,174.18 165.69,174.17 165.89,173.98 165.89,173.94 165.88,173.9 165.84,173.88 165.8,173.88 165.62,173.81 165.53,173.64 165.5,173.57 165.42,173.54 165.33,173.54 165.27,173.6 165.27,173.62 165.19,173.8 165.01,173.88 164.94,173.92 164.92,173.99 164.92,174.02 164.84,174.24 164.64,174.34 164.62,174.34 164.5,174.46 164.56,174.51 164.6,174.51 164.83,174.6 164.92,174.82 164.92,174.86 164.91,174.89
+1.35V_GFX on BOTTOM (solid shape): outline of 222 points within 129.38,185.81 137.94,197.61
+1.35V_GFX on BOTTOM (solid shape): outline of 7521 points within 144.93,167.9 168.47,209.9
+1.35V_GFX on IN1 (solid shape): outline of 1347 points within 130.01,185.75 142.57,197.93
+1.35V_GFX on IN1 (solid shape): outline of 3477 points within 154.58,169.94 167.81,207.41
+1.35V_GFX on IN3 (solid shape): outline of 274 points within 153.05,194.36 157.75,198.64
+1.35V_GFX on IN3 (solid shape): outline of 5269 points within 130.29,170.27 168.47,210.19
+1.35V_GFX on IN4 (solid shape): outline of 2027 points within 150.29,169.06 168.47,179.18
+1V8_AON on TOP (solid shape): 127.73,187.88 127.73,187.55 127.83,187.45 128.24,187.45 128.41,187.27 128.41,186.81 128.03,186.43 127.14,186.43 126.8,186.09 126.25,186.09 126.13,186.21 126.13,187.47 126.13,187.7 126.38,187.96 127.66,187.96
+1V8_AON on BOTTOM (solid shape): 98.24,183.77 98.24,182.25 98.24,182.24 98.24,181.81 98.14,181.71 97.22,181.71 97,181.94 97,183.79 97.12,183.92 98.09,183.92
+1V8_AON on BOTTOM (solid shape): outline of 86 points within 112.66,174.37 123.7,187.12
+1V8_AON on SVCC (solid shape): 117.98,184.5 118.06,184.45 118.16,184.43 123.63,184.43 123.75,184.2 123.99,184.11 124.22,184.2 124.34,184.43 125.31,184.43 125.42,184.19 125.67,184.1 125.91,184.19 126.02,184.43 126.28,184.43 126.38,184.45 126.46,184.5 126.97,185.01 127.03,185.09 127.05,185.19 127.05,187.22 131.11,187.22 131.11,187.14 131.03,187.03 131,186.89 131.03,186.75 131.11,186.63 131.11,186.2 131.09,186.13 131.09,186.07 131.09,186.01 131.11,185.94 131.11,185.43 131.09,185.36 131.08,185.29 131.09,185.22 131.11,185.15 131.11,184.6 131.1,184.54 131.09,184.49 131.1,184.43 131.11,184.37 131.11,182.29 131.06,182.19 131.04,182.08 131.06,181.98 131.11,181.88 131.11,181.5 131.11,181.46 131.11,181.43 131.11,180.49 131.13,180.39 131.18,180.31 132.2,179.29 132.28,179.24 132.38,179.22 133.67,179.22 135.43,177.46 135.43,173.38 125.65,173.38 125.55,173.36 125.47,173.3 123.89,171.73 96.42,171.73 94.79,173.36 94.79,179.57 94.92,179.7 94.97,179.88 94.92,180.06 94.79,180.19 94.79,184.68 106.22,184.68 106.32,184.7 106.4,184.75 110.39,188.74 113.73,188.74
+1V8_GFX_MAIN on TOP (solid shape): 128.17,199.77 129.92,199.77 130.08,199.61 130.08,199.32 129.96,199.2 129.38,199.2 129.25,199.06 129.25,198.31 129.2,198.27 127.65,198.27 127.43,198.5 126.63,198.5 126.61,198.52 126.61,198.92 126.73,198.92 127,199.19 127,199.33 127.44,199.77 128.07,199.77
+1V8_GFX_MAIN on TOP (solid shape): outline of 145 points within 113.15,187.45 125.87,193.03
+1V8_GFX_MAIN on TOP (solid shape): outline of 316 points within 137.56,200.61 145.84,208.18
+1V8_GFX_MAIN on BOTTOM (solid shape): 98.87,187.42 98.87,185.89 98.73,185.75 98.54,185.75 98.39,185.9 98.39,186.26 96.99,186.26 96.99,186.27 96.85,186.41 96.85,187.56 96.98,187.69 98.6,187.69
+1V8_GFX_MAIN on BOTTOM (solid shape): 146.45,207.51 146.63,207.51 146.76,207.39 146.76,206.68 146.58,206.5 146.58,204.72 146.48,204.62 144.06,204.62 143.65,205.03 143.65,207.26 143.91,207.51 146.45,207.51
+1V8_GFX_MAIN on BOTTOM (solid shape): 127.14,187.96 127.14,187.34 127.01,187.2 126.96,187.15 126.93,187.09 126.91,187.07 126.88,187.07 126,187.07 125.37,187.7 125.24,187.7 124.86,188.08 124.86,188.46 124.99,188.59 126.51,188.59
+1V8_GFX_MAIN on IN1 (solid shape): outline of 3502 points within 124.79,187.27 145.85,205.46
+1V8_GFX_MAIN on SVCC (solid shape): 123.61,190.29 123.61,190.25 123.71,189.99 124.01,189.89 126.54,187.37 126.54,185.29 126.18,184.93 118.26,184.93 114.02,189.18 113.94,189.23 113.84,189.25 110.28,189.25 110.18,189.23 110.1,189.18 106.11,185.19 94.79,185.19 94.79,185.54 94.94,185.68 94.99,185.87 94.94,186.07 94.79,186.21 94.79,192.45 100.23,197.89 116.02,197.89
+1V8_GFX_MAIN on IN3 (solid shape): outline of 1571 points within 125.01,187.14 145.96,205.84
+2.5V_SUS on TOP (solid shape): 65.79,105.61 65.79,105 65.32,104.54 64.05,104.54 63.67,104.16 63.67,103.65 63.74,103.59 63.76,103.51 63.8,103.44 63.8,103.4 63.67,103.27 62.91,103.27 62.83,103.36 62.83,104.39 62.96,104.52 63.14,104.52 63.29,104.67 63.29,105.31 63.4,105.42 64.55,105.42 65.07,105.94 65.45,105.94
+2.5V_SUS on TOP (solid shape): 51.83,106.51 51.48,106.17 51.48,105.78 51.74,105.52 52.19,105.52 52.21,105.51 52.21,103.48 51.93,103.21 50.13,103.21 50.04,103.26 50.04,103.36 50.14,103.96 49.84,104.49 49.84,104.79 49.83,104.8 49.83,105.05 49.86,105.08 49.86,105.13 49.91,105.22 50.02,105.22 50.02,105.21 50.13,105.17 50.24,105.15 50.53,105.27 50.64,105.56 50.52,105.85 50.24,105.97 50.15,105.96 50.07,105.93 49.99,105.93 49.93,105.98 49.89,106.06 49.84,106.12 49.84,106.39 50.02,106.57 51.77,106.57
+2.5V_SUS on BOTTOM (solid shape): 83.1,185.95 83.1,185.32 82.47,184.68 80.31,184.68 80.06,184.93 80.06,185.3 80.31,185.55 81.18,185.55 81.83,186.2 82.85,186.2
+2.5V_SUS on BOTTOM (solid shape): 68.22,178.46 68.22,176.96 68.77,176.41 68.77,175.72 68.75,175.7 68.75,175.28 68.5,175.03 67.38,175.03 66.7,175.71 66.7,178.4 66.96,178.66 68.02,178.66
+2.5V_SUS on BOTTOM (solid shape): 51.88,105.65 51.96,105.65 52.03,105.65 52.12,105.69 54.15,105.69 54.18,105.66 54.18,105.45 52.45,105.45 52.45,105.2 54.16,105.2 54.16,104.96 53.56,104.36 51.94,104.36 51.53,104.36 51.1,104.8 51.1,105.51 51.28,105.69 51.79,105.69
+2.5V_SUS on BOTTOM (solid shape): outline of 98 points within 62.58,102.67 68.24,105.69
+2.5V_SUS on IN2 (solid shape): outline of 320 points within 50.95,102.51 64.61,105.54
+2.5V_SUS on IN3 (solid shape): outline of 356 points within 66.85,178.13 81.83,186.46
+3V on TOP (solid shape): 64.53,106.91 64.53,105.99 64.21,105.67 63.63,105.67 63.55,105.75 63.55,106.21 63.38,106.38 63.38,106.82 63.54,106.97 64.47,106.97
+3V on TOP (solid shape): 235.96,121.99 235.96,119.22 235.88,119.15 234.87,119.15 234.68,119.33 234.68,121.76 235.12,122.2 235.76,122.2
+3V on TOP (solid shape): 74.52,196.31 74.52,193.87 74.21,193.57 71.75,193.57 71.65,193.67 71.65,195.42 72.59,196.36 73.58,196.36 73.58,196.36 74.47,196.36
+3V on TOP (solid shape): 53.6,106.55 53.6,106.09 53.46,105.96 53.23,105.96 53.06,105.78 53.06,105.31 52.87,105.11 52.87,104.07 52.46,104.07 52.46,104.07 52.46,105.62 52.3,105.78 51.84,105.78 51.74,105.88 51.74,106.07 52.32,106.65 53.5,106.65
+3V on TOP (solid shape): 30.65,137.69 31.67,137.69 32.3,137.06 32.3,133.63 32.05,133.37 30.53,133.37 30.14,132.99 29.89,132.99 29.81,133.07 29.81,133.65 29.76,133.65 29.76,134.01 30.02,134.26 31.03,134.26 31.16,134.39 31.16,135.66 30.59,136.23 30.21,136.23 28.87,137.56 26.84,137.56 26.46,137.94 26.46,138.45 26.59,138.58 29.76,138.58
+3V on TOP (solid shape): 38.27,148.74 38.27,146.28 38.1,146.1 36.87,146.1 36.82,146.04 36.8,146.04 36.75,146.03 36.7,146 36.63,145.97 36.56,146 36.37,146.2 36.37,147.72 36.52,147.88 36.55,147.88 36.66,147.92 36.7,148.03 36.7,148.06 36.75,148.1 37.26,148.1 37.26,148.74 37.39,148.87 38.14,148.87
+3V on TOP (solid shape): outline of 159 points within 94.41,96.95 99.61,106.77
+3V on TOP (solid shape): outline of 244 points within 59.99,91.97 73.27,108.1
+3V on BOTTOM (solid shape): 25.95,27.58 25.95,27.07 25.83,26.95 24.81,26.95 24.43,27.33 24.43,27.96 24.56,28.09 25.45,28.09
+3V on BOTTOM (solid shape): 130.09,210.21 130.09,209.83 130.22,209.7 131.11,209.7 131.24,209.57 131.24,209.32 131.11,209.19 130.7,209.19 130.57,209.06 129.59,209.06 129.33,209.32 129.33,210.21 129.46,210.33 129.97,210.33
+3V on BOTTOM (solid shape): 71.93,190.4 72.82,190.4 72.94,190.27 72.94,189.76 72.82,189.63 72.58,189.63 72.5,189.65 72.44,189.66 72.37,189.65 72.3,189.63 72.05,189.63 71.93,189.76 70.66,189.76 70.28,190.14 70.15,190.14 70.02,190.27 70.02,190.52 70.15,190.65 71.67,190.65
+3V on BOTTOM (solid shape): 29.13,70.79 29.13,70.78 29.08,70.73 29.07,70.66 29.07,69.85 29.07,69.8 29.09,69.76 29.11,69.73 28.87,69.49 27.86,69.49 27.48,69.11 27.48,67.97 27.35,67.84 26.72,67.84 26.59,67.97 26.59,70.51 26.3,70.8 26.3,71.62 26.47,71.8 28.12,71.8
+3V on BOTTOM (solid shape): 224.63,114.4 224.63,113.45 224.28,113.1 222.27,113.1 222.17,113.2 222.17,113.4 222.99,113.4 222.99,113.6 222.17,113.6 222.17,113.88 222.19,113.9 222.99,113.9 222.99,113.91 223.03,113.91 223.14,114.01 223.15,114.1 223.15,114.28 223.33,114.47 223.86,114.47 223.96,114.58 224.45,114.58
+3V on BOTTOM (solid shape): 197.21,119.81 197.21,119.25 197.2,119.19 197.19,119.14 197.2,119.09 197.21,119.03 197.21,118.74 197.2,118.68 197.19,118.63 197.19,118.38 197.2,118.32 197.21,118.27 197.21,117.55 196.9,117.24 195.75,117.24 195.53,117.47 195.53,119.73 195.78,119.99 197.04,119.99
+3V on BOTTOM (solid shape): 212.49,131.31 212.49,129.59 212.49,129.45 212.48,129.3 212.49,129.15 212.49,129.01 212.49,128.36 212.39,128.25 210.21,128.25 209.86,128.61 209.86,130.18 209.51,130.18 209.4,130.28 209.39,130.28 209.36,130.31 208.99,130.31 208.89,130.41 208.89,130.87 209.01,131 209.03,131 210.69,131.17 212.35,131.42 212.37,131.42
+3V on SVCC (solid shape): outline of 1094 points within 32.94,103.65 226.87,177.31
+3V on IN2 (solid shape): outline of 914 points within 222.68,112.54 235.86,122.32
+3V on IN2 (solid shape): outline of 3347 points within 35.71,175.34 119.36,195.56
+3V on IN2 (solid shape): outline of 6337 points within 18.45,70.63 30.14,157.12
+3V on IN3 (solid shape): outline of 297 points within 26.21,145.44 37.71,148.99
+3V on IN3 (solid shape): outline of 786 points within 116.94,186.77 134.31,213.35
+3V3_TPM on TOP (solid shape): 84.48,97.46 84.68,97.41 84.88,97.46 86.01,97.46 86.06,97.42 86.06,97.22 86,97.17 84.96,97.17 84.76,96.97 84.76,96.29 84.96,96.09 84.99,96.06 85.02,96.03 85.14,95.91 85.14,95.65 84.98,95.49 84.41,95.49 83.99,95.91 83.99,97.06 84.39,97.46
+3V3_TPM on TOP (solid shape): 96.18,101.75 96.18,100.31 92.95,100.31 92.76,100.5 92.69,100.5 92.64,100.56 92.13,100.56 91.94,100.36 91.94,99.82 91.81,99.69 91.54,99.69 91.54,99.69 90.37,99.69 90.32,99.74 90.32,101.09 90.52,101.29 90.56,101.28 90.64,101.25 90.72,101.24 90.87,101.27 90.99,101.35 91.01,101.37 91.07,101.37 91.09,101.35 91.36,101.24 91.63,101.35 91.64,101.37 91.71,101.37 91.78,101.3 91.93,101.23 92.01,101.23 92.28,101.34 92.39,101.61 92.36,101.74 92.3,101.86 92.27,101.89 92.63,102.26 95.68,102.26
+3V3_TPM_VSB on TOP (solid shape): 94.06,97.06 94.06,96.66 94.23,96.49 95.25,96.49 96.69,96.49 96.79,96.39 96.79,95.63 96.69,95.53 94.05,95.53 93.94,95.64 92.77,95.64 92.55,95.42 92.55,94.74 92.4,94.59 90.7,94.59 90.32,94.97 90.32,96.39 90.37,96.44 91.42,96.44 91.44,96.42 91.58,96.32 91.75,96.28 92.04,96.4 92.16,96.68 92.16,96.74 92.14,96.8 92.14,97.15 92.22,97.23 93.9,97.23
+3V_CCD_PWR1_C on BOTTOM (solid shape): 72.3,193.33 72.3,192.51 72.5,192.51 72.5,193.33 72.51,193.34 72.79,193.34 72.8,193.32 72.8,191.86 72.96,191.7 72.96,191.08 72.88,191 72.19,191 72.03,191.16 72.03,192.46 72,192.49 72,193.31 72.03,193.34 72.29,193.34
+3V_CR on BOTTOM (solid shape): 27.73,66.95 28.75,66.95 29,67.21 29.38,67.21 29.38,65.94 29.51,65.81 29.89,65.81 29.89,65.81 30.02,65.68 30.02,64.6 29.97,64.51 29.95,64.41 29.95,64.26 29.91,64.21 29.91,63 29.85,62.94 29.64,62.94 29.61,62.97 29.61,63.21 29.67,63.33 29.69,63.46 29.69,64.08 29.67,64.22 29.61,64.34 29.6,64.36 29.6,64.48 28.77,65.3 28.29,65.3 28.04,65.55 27.35,65.55 26.72,66.19 26.72,67.21 27.48,67.21
+3V_DEEP_SUS on BOTTOM (solid shape): 103.8,111.66 103.8,111.4 103.3,110.89 103.3,110 103.17,109.88 102.03,109.88 101.9,110 101.9,110.77 102.03,110.89 102.66,110.89 102.66,111.02 101.77,111.02 101.65,111.15 101.65,111.27 102.15,111.78 103.68,111.78
+3V_HDMI on TOP (solid shape): 29.47,133.54 29.47,132.84 29.51,132.84 29.51,130.2 28.75,129.44 27.99,129.44 27.86,129.56 27.86,129.69 28.11,129.94 28.37,129.94 28.75,130.32 28.75,131.72 28.62,131.85 28.37,131.85 28.24,131.98 28.24,133.5 28.37,133.63 29.38,133.63
+3V_HDMI on BOTTOM (solid shape): outline of 239 points within 21.25,119.4 32.3,133.25
+3V_LAN on TOP (solid shape): 15.67,168.93 15.67,167.85 16.38,167.14 16.38,166.88 16.28,166.77 15.86,166.77 15.63,167 15.63,167.18 15.16,167.65 15.16,168.93 15.29,169.06 15.54,169.06
+3V_LAN on TOP (solid shape): 24.84,165.5 24.92,165.46 25.01,165.44 25.1,165.46 25.18,165.5 27.18,165.5 27.27,165.4 27.27,165.1 27.12,164.94 26.79,164.94 26.74,164.89 26.72,164.89 26.59,164.82 26.52,164.69 26.52,164.68 26.31,164.47 24.8,164.47 24.34,164.93 23.13,164.93 23.1,164.96 23.1,165.07 23.14,165.11 24.11,165.11 24.15,165.15 24.15,165.28 24.11,165.32 23.15,165.32 23.12,165.35 23.12,165.47 23.15,165.5
+3V_LAN on TOP (solid shape): 25.33,177.49 25.55,177.29 25.84,177.22 25.89,177.22 25.89,175.38 25.07,174.56 24.27,174.56 24.16,174.62 24.02,174.64 23.74,174.52 23.62,174.23 23.62,173.89 23.56,173.83 23.56,173.75 23.51,173.71 23.51,173.25 23.51,173.25 23.51,171.26 23.43,171.18 23.38,171.08 23.38,171.07 23.28,170.97 23.26,170.95 22.82,170.95 22.75,171.02 22.75,172.68 22.86,172.87 22.9,173.09 22.9,173.84 22.27,174.48 21.63,173.84 21.63,173.47 21.56,173.47 21.52,173.46 21.48,173.44 21.35,173.44 21.31,173.44 21.27,173.43 21.22,173.43 20.87,173.08 20.87,171.99 20.64,171.76 20.32,171.76 20.08,172 20.08,172.19 20.09,172.2 20.12,172.29 20.13,172.39 20.07,172.62 19.89,172.77 19.89,173.19 19.88,173.24 19.88,173.94 20.55,174.61 20.61,174.64 20.64,174.7 20.65,174.71 20.65,175.57 21.21,176.13 21.21,176.76 21.51,177.06 24.33,177.06 24.76,177.49
+3V_LAN on IN3 (solid shape): outline of 1694 points within 12.62,159.03 31.11,175.54
+3V_LDO_EC on IN2 (solid shape): outline of 315 points within 134.28,120.55 144.19,129.31
+3V_RTC on TOP (solid shape): 77.77,100.35 77.9,100.23 78.15,100.23 78.18,100.19 78.3,100.19 78.42,100.12 78.56,100.1 78.68,100.12 78.8,100.18 78.81,100.19 78.91,100.19 78.93,100.18 79.04,100.12 79.17,100.1 79.55,100.48 79.17,100.86 79.14,100.86 78.91,100.86 78.91,101.01 78.98,101.04 78.99,101.03 79.55,101.03 79.73,101.21 80.03,101.21 80.18,101.06 80.18,100.81 80.14,100.81 79.94,100.7 79.85,100.48 79.93,100.26 80.14,100.15 80.18,100.15 80.18,100.09 80.18,99.21 79.93,98.96 79.55,98.96 79.29,99.21 77.39,99.21 77.24,99.36 77.24,99.63 77.26,99.66 77.26,100.54 77.3,100.63 77.31,100.73 77.3,100.83 77.26,100.92 77.26,102.77 77.77,102.77
+3V_RTC_1 on TOP (solid shape): 77.28,98.95 78.28,98.95 78.66,98.57 78.66,98.34 78.79,98.21 78.79,97.69 78.66,97.56 78.37,97.56 78.28,97.65 78.28,98.07 77.9,98.45 76.88,98.45 76.75,98.32 76.75,98.08 76.74,98.06 76.74,97.18 77.51,96.41 77.64,96.41 77.71,96.35 77.71,96.21 77.66,96.16 76.92,96.16 76.25,96.83 76.25,98.57 76.63,98.96 77.28,98.96
+3V_S5 on TOP (solid shape): 75.99,97.94 75.99,96.72 76.71,96 76.71,95.74 76.63,95.65 75.52,95.65 74.98,96.2 74.98,97.94 75.36,98.32 75.61,98.32
+3V_S5 on TOP (solid shape): 30.91,68.35 31.41,68.35 31.67,68.09 31.67,67.33 31.54,67.21 30.4,67.21 29.76,67.84 29.24,67.84 29.11,67.97 27.73,67.97 27.6,68.09 27.6,68.35 27.73,68.48 30.78,68.48
+3V_S5 on TOP (solid shape): 77.94,108.18 77.94,107.69 78.35,107.28 78.35,106.77 77.95,106.38 77.72,106.38 77.33,105.99 77.33,105.76 76.88,105.31 76.88,104.67 76.5,104.29 76.12,104.29 75.86,104.54 75.86,105.78 76.2,106.12 76.2,107.67 77.01,108.48 77.64,108.48
+3V_S5 on TOP (solid shape): 34.81,144.17 34.95,144.17 34.95,144.16 35.02,143.98 35.2,143.91 35.48,143.91 35.5,143.9 36.67,143.9 36.69,143.87 36.69,143 36.64,142.89 36.62,142.77 36.62,141.89 36.62,141.81 36.65,141.73 36.65,141.45 36.62,141.42 36.39,141.42 36.35,141.46 36.35,142.33 36.34,142.33 36.34,142.52 36.23,142.63 34.07,142.63 33.83,142.39 33.83,141.5 33.7,141.37 33.07,141.37 32.94,141.5 32.94,142.5 32.96,142.57 32.97,142.64 32.96,142.72 32.94,142.79 32.94,144.17 33.11,144.34 34.64,144.34
+3V_S5 on BOTTOM (solid shape): 195.08,119.64 195.08,117.46 194.99,117.37 193.59,117.37 193.34,117.62 193.34,119.61 193.47,119.73 194.99,119.73
+3V_S5 on BOTTOM (solid shape): 210.1,126.67 210.1,125.55 209.8,125.24 207.05,125.24 206.99,125.31 206.64,125.31 206.45,125.5 206.45,126.77 206.6,126.92 209.85,126.92
+3V_S5 on BOTTOM (solid shape): 4.11,33.8 5.25,33.8 5.38,33.68 5.38,33.3 5.04,32.95 4,32.95 3.89,32.84 3.89,32.48 3.61,32.2 3.24,32.2 3.05,32.39 3.05,34.01 3.22,34.19 3.73,34.19
+3V_S5 on BOTTOM (solid shape): 104.06,108.67 103.62,108.23 103.62,107.59 103.49,107.46 102.23,107.46 102.15,107.51 102.14,107.6 102.15,107.66 102.15,107.72 102.06,107.97 101.82,108.1 101.77,108.1 101.77,108.99 103.42,108.99 103.55,109.12 103.55,109.62 103.68,109.75 104.06,109.75
+3V_S5 on BOTTOM (solid shape): outline of 359 points within 73.08,105.43 78.91,122.32
+3V_S5 on BOTTOM (solid shape): outline of 462 points within 17.95,115.76 41.44,130.35
+3V_S5 on IN1 (solid shape): outline of 5370 points within 38.87,108.73 75.23,136.8
+3V_S5 on IN2 (solid shape): 5.25,35.2 5.25,33.42 4.36,32.53 3.35,32.53 3.09,32.79 3.09,33.93 4.11,34.95 4.11,35.58 4.36,35.84 4.62,35.84
+3V_S5 on IN2 (solid shape): 30.65,69.49 30.65,66.82 30.14,66.32 29.76,66.32 29.26,66.82 29.26,67.69 28.98,67.97 28.49,67.97 27.6,67.97 27.6,68.47 28.49,68.47 28.85,68.47 29.26,68.88 29.26,69.11 30.02,69.87 30.27,69.87
+3V_S5 on IN2 (solid shape): 77.01,96.29 77.01,95.91 76.25,95.15 74.98,95.15 74.85,95.02 74.21,95.02 73.96,95.27 73.96,95.89 74.01,95.93 74.05,95.99 74.24,96.19 74.38,96.21 74.49,96.29 74.54,96.29 74.74,96.35 74.87,96.51 74.89,96.54 76.75,96.54
+3V_S5 on IN2 (solid shape): outline of 5639 points within 76.14,103.78 210.09,127.07
+3V_S5 on IN3 (solid shape): outline of 590 points within 32.94,123.85 39.7,143.84
+3V_SM on TOP (solid shape): 222.55,102.26 222.55,100.61 221.91,99.97 220.52,99.97 220.39,100.1 220.39,100.35 221.03,100.99 221.03,102.26 221.15,102.38 222.42,102.38
+3V_SPI on TOP (solid shape): 105.07,98.45 105.07,96.54 104.95,96.42 103.94,96.42 103.81,96.55 103.81,97.05 104.27,97.51 104.27,98.41 104.44,98.58 104.94,98.58
+3V_SPI on TOP (solid shape): 94.31,99.8 94.34,99.79 94.38,99.78 95.19,99.78 95.42,99.55 95.42,98.71 95.37,98.59 95.35,98.45 95.37,98.31 95.42,98.18 95.42,97.18 95.31,97.06 94.42,97.06 94.17,97.32 94.17,98.15 94.18,98.2 94.17,98.35 94.13,98.45 94.13,99.69 94.24,99.8
+3V_SPI on IN2 (solid shape): 105.18,96.96 105.18,96.49 103.35,96.49 103.3,96.53 103.3,97.21 103.45,97.35 104.79,97.35
+3V_SPI on IN2 (solid shape): 95.44,98.6 95.47,98.56 95.48,98.51 95.47,98.45 95.58,98.18 95.85,98.07 95.89,98.07 95.93,98.07 96.02,98.08 96.1,98.1 96.13,98.12 96.82,97.43 96.82,97.3 96.57,97.05 94.66,97.05 93.9,97.81 93.9,98.14 93.96,98.2 94.02,98.28 94.08,98.35 94.08,98.51 94.29,98.71 95.33,98.71
+3V_SSD on BOTTOM (solid shape): outline of 984 points within 12.68,68.35 34.47,78.49
