# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1P05_CTRL: length 3.7
  TOP w0.089: v1(117.2,123.87) 117.2,123.53 117.65,123.09 TP13403.1
  BOTTOM w0.102: U6539.DT12 118.75,122.79 118.25,123.3 117.94,123.3 117.52,123.72 117.35,123.72 v1(117.2,123.87)
V3A_BOOT:
  vias: v2(176.86,133.37)
V3A_BOOT_R: length 2.7
  BOTTOM w0.508: v2(180.56,135.07) 180.45,134.96 ; 180.45,134.96 PC6001.1 ; 180.45,134.96 180.34,134.85 180,134.85 PR6000.1
V3A_EN: length 10.2
  TOP w0.114: v2(177.24,134.03) 176.55,134.03 v2(176.52,134.06)
  TOP w0.203: v2(176.52,134.06) 176.39,134.06 176.37,134.04 PR6002.2 ; PC6007.2 175.58,128.98 v2(174.98,128.98)
  IN4 w0.254: v2(174.98,128.98) 175.94,129.94 175.94,132.48 176.52,133.06 v2(176.52,134.06)
  BOTTOM w0.203: PU6000.6 176.03,129.15 175.86,128.98 v2(174.98,128.98) 174.67,128.67 PR6006.2
V3A_PWRGD: length 1.2
  BOTTOM w0.203: PR6005.2 174.75,129.44 174.81,129.5 175.15,129.5 175.18,129.53 PU6000.7
V3A_VBYP: length 292.3
  TOP w0.114: v2(27.83,116.41) 27.02,116.41 PR8046.2 ; v2(16.94,112.8) 16.94,112.8 16.94,112.98 PR8034.2
  TOP w0.203: v2(174.09,133.12) 174.09,133.17 174.24,133.32 v2(174.75,133.32) 174.75,133.04 174.43,132.73 PR6017.2 174.92,132.23 175.26,132.56 PR6009.2
  IN3 w0.102: v2(116,95.65) 116.38,95.65 117.42,96.69 118.89,96.69 119.38,97.18 124.86,97.18 125.12,96.92 134.89,96.92 135.91,97.94 138.73,97.94 140.51,99.72 143.05,99.72 143.81,98.96 148.64,98.96 149.78,97.81 149.78,96.16 150.16,95.78 150.57,95.78 151.46,96.67 151.94,96.67 152.19,96.42 153.34,96.42 154.63,95.12 171.55,95.12 172.66,96.24 180.79,96.24 181.12,95.91 194.71,95.91 195.6,96.8 199.94,96.8 200.83,97.69 202.1,97.69 202.74,98.32 203.37,98.32 204.01,98.96 204.01,101.11 204.24,101.34 204.24,102.56 207.44,105.75 207.44,108.23 206.93,108.73 205.02,108.73 202.99,110.77 202.99,111.99 200.27,114.7 193.21,114.7 192.45,115.47 192.45,116.61 191.26,117.8 178.05,117.8 176.58,119.28 175.31,119.28 174.98,119.61 v1(174.98,120.27)
  IN4 w0.089: v2(174.09,133.12) 174.04,133.07 174.04,131.59 173.3,130.86 173.3,128.39 174.67,127.02 174.67,125.88 173.91,125.12 172.89,125.12 172.51,124.74 172.51,123.85 174.98,121.38 v1(174.98,120.27) ; v2(116,95.65) 114.4,94.06 97.15,94.06 95.62,95.58 93.57,95.58 92.88,94.89 79.68,94.89 76.63,91.84 75.1,91.84 74.32,91.06 50.74,91.06 49.58,92.22 49.58,93.8 48.38,94.99 45.46,94.99 44.83,95.63 38.68,95.63 36.62,97.69 35.61,97.69 33.19,100.1 33.19,103.4 31.51,105.08 31.51,114.48 30.51,115.49 28.76,115.49 v2(27.83,116.41)
  BOTTOM w0.114: v2(16.94,112.8) 17.03,112.9 18.49,112.9 18.6,113.01 23.69,113.01 25.07,114.39 25.61,114.39 26.43,115.21 27.23,115.21 27.83,115.8 v2(27.83,116.41)
  BOTTOM w0.203: PU6000.11 175.23,131.33 175,131.55 175,131.91 PC6023.1 174.43,132.73 174.09,133.07 v2(174.09,133.12)
V3A_VOUT: length 34.3
  TOP w0.203: v2(194.73,127.15) v2(193.45,128.43) 192.09,129.79 190.95,129.79 188.92,131.82 188.92,132.48 184.78,134.87 179.24,134.87 178.61,134.74 177.89,134.73 175.47,134.73 175.25,134.51 173.4,134.51 v2(172.51,133.63)
  BOTTOM w0.203: PR6008.1 v2(194.73,127.15) ; PU6000.10 175.25,130.88 175.22,130.91 174.6,130.91 PC6017.2 174.17,131.58 173.78,131.98 173.35,131.98 172.51,132.81 v2(172.51,133.63) 172.64,133.75 173.08,133.75 173.66,134.34 PR6011.2 173.83,134.36 174.53,133.67 PR6010.2
V5P5A_BOOT_R: length 2.4
  BOTTOM w0.114: PR6018.1 55.82,178 v2(55.6,177.77)
  BOTTOM w0.508: PR6018.1 55.17,178.77 55,178.6 PC6035.1
V5P5A_EN: length 3.7
  BOTTOM w0.203: PU6003.6 56.29,185.4 v2(56.59,185.7) 56.56,185.72 PC6039.2 57.03,186.55 57.07,186.59 PR6021.2 PR6020.2
V5P5A_PWRGD: length 2.4
  BOTTOM w0.203: PR6022.2 57.35,185.39 v2(57.75,184.98) 57.83,184.91 57.83,184.33 57.7,184.2 PU6003.7
V5P5A_VOUT: length 25.7
  BOTTOM w0.203: PR6026.1 45.34,177.16 45.59,176.91 57.45,176.91 57.71,176.65 60.08,176.65 61.31,177.88 v2(61.31,178.79) 61.31,179.06 61.05,179.33 PR6029.2 60.88,180.96 PR6030.2 60,180.96 59.24,181.72 PC6055.2 58.96,181.72 57.82,182.85 PU6003.10
V18: length 5.7
  BOTTOM w0.114: C1649.2 24.56,64.67 v2(24.25,64.36) 24.94,63.67 25.62,63.67 25.8,63.85 26.51,63.85 26.84,63.52 26.84,62.76 27.12,62.49 U40.24
VCC3V3_FLASH: length 82
  TOP w0.203: R68875.2 29.74,58.98 29.89,58.82 ; v1(30.96,81.56) 31.16,81.35 R68637.2 R68638.2 ; 32.43,65.68 32.4,65.65 ; R68607.2 17.58,59.08 17.19,58.7 v1(17.19,58.54) ; v1(31.41,83.13) 32.25,83.13 32.81,82.57 R68639.2 34.75,80.77 35.86,79.65 35.86,76.48 35.58,76.2 34.44,76.2 33.95,75.71 33.95,73.3 33.26,72.61 32.81,72.61 ; 32.56,70.25 R68636.2
  TOP w0.381: 32.4,65.65 R68634.2 32.42,62.78 34.07,62.78 34.59,62.25 34.59,61.36 34.21,60.98 33.45,60.98 31.29,58.82 29.13,58.82 28.41,58.1 22.79,58.1 22.37,57.68 20.62,57.68 20.3,58 18.27,58 17.72,58.54 v1(17.19,58.54)
  IN1 w0.381: v1(9.42,44.22) 9.44,44.19 9.44,43.84 10.71,42.57 v1(11.22,42.57) 14.14,42.57 14.52,42.19 14.52,42.08 v1(14.55,42.06)
  IN2 w0.203: v1(31.41,83.13) 30.96,82.67 v1(30.96,81.56)
  IN2 w0.381: v1(17.19,58.54) 17.47,58.54 17.75,58.26 17.75,57.07 17.01,56.33 17.01,53.06 11.98,48.03 11.35,48.03 9.44,46.12 9.44,44.24 v1(9.42,44.22)
  BOTTOM w0.203: Q6629.2 14.47,41.98 v1(14.55,42.06) ; Q6623.2 10.5,44.64 10.21,44.35 9.57,44.35 9.44,44.22 v1(9.42,44.22) ; R68984.1 12.08,43.17 11.44,42.53 11.26,42.53 v1(11.22,42.57) 11.22,42.51 11.09,42.38 Q6621.2 ; R68899.2 R68898.2 R68896.2 19.19,58.98 19.07,59.11 R68895.2 R68897.2 17.47,59.11 17.19,58.82 v1(17.19,58.54)
VCC_AUX_SENSE: length 10.9
  TOP w0.114: v1(120.3,150.09) 120.47,149.92 120.47,148.97 120.65,148.79 123.59,148.79 124.05,149.25 128.06,149.25 v2(128.32,148.99)
  BOTTOM w0.114: U6539.AT9 120.3,150.06 v1(120.3,150.09) ; v2(128.32,148.99) 128.47,149.15 PR7088.2
VCCA_CLKLDO_1V8: length 12.8
  TOP w0.254: v1(116.89,120.67) 116.76,120.55 116.76,120.35 C96766.2 117.2,119.57 v2(117.85,118.92) 118.38,118.39 R68497.1
  IN1 w0.203: v1(117.15,128.29) 116.79,127.93 116.79,123.34 117.14,122.99 117.14,120.93 v1(116.89,120.67)
  BOTTOM w0.2: U6539.DC15 117.23,128.32 117.2,128.32 117.18,128.29 v1(117.15,128.29)
  BOTTOM w0.203: v1(116.89,120.67) 116.79,120.77 U6539.DV16
VCCAUX_VID: length 99
  TOP w0.114: U6559.1 209.07,109.54 208.83,109.3 208.83,107.72 207.64,106.52 207.13,106.52 206.04,105.43 204.9,105.43 204.39,104.92 202.05,104.92 199.82,107.16 199.82,108.02 200.07,108.28 200.07,110.13 198.8,111.4 198.8,115.08 v2(199.05,115.34) 199.21,115.49 199.21,123.03 199.44,123.26 v2(199.51,123.26)
  TOP w0.203: U6562.1 169.86,145.31 170.08,145.53 170.32,145.53 170.33,145.54 v2(170.4,145.54)
  IN1 w0.089: v2(199.51,123.26) 199.51,124.02 198.29,125.24 197.15,125.24 197.02,125.37 191.94,125.37 191.28,124.71 191.28,123.57 190.47,122.75 184.91,122.75 184.07,123.59 181.27,123.59 181.02,123.34 178.23,123.34 177.92,123.64 172.08,123.64 169.21,126.51 168.96,126.51 165.4,130.07 165.4,132.61 164.64,133.37 162.35,133.37 161.84,133.88 161.84,135.28 160.83,136.29 160.83,136.67 161.21,137.06 161.21,138.17 162,138.96 162.86,138.96 164.13,140.23 167.43,140.23 169.64,142.44 169.64,144.78 v2(170.4,145.54)
  BOTTOM w0.203: v2(170.4,145.54) 170.51,145.64 C96904.1 R68856.2
VCCAUX_VID0: length 200.7
  TOP w0.203: v1(101.39,104.04) v2(101.39,105.05) 101.65,105.31 101.65,107.08 100.5,108.23 R68502.1 ; v2(201.72,110) 201.72,110.51 201.96,110.75 D13150.2 201.34,111.06 201.14,111.26 201.14,116.81 200.83,117.12 200.83,123.72 201.09,123.97 v2(201.34,123.97)
  IN1 w0.203: v2(201.34,123.97) 200.83,124.48 199.82,124.48 198.8,125.5 197.4,125.5 197.28,125.63 191.82,125.63 191.03,124.84 191.03,123.69 190.34,123.01 185.11,123.01 184.27,123.85 181.02,123.85 180.77,123.59 178.35,123.59 178.05,123.9 172.21,123.9 169.21,126.9 168.93,126.9 165.78,130.04 165.78,132.99 165.02,133.75 165.02,134.26 163.62,135.66 162.99,135.66 161.46,137.18 161.46,138.02 162.02,138.58 162.71,138.58 v1(163.34,137.94) 163.75,138.35 163.75,139.21 164.51,139.98 167.69,139.98 170.1,142.39 170.1,143.28 v2(170.61,143.79)
  IN2 w0.203: v1(101.39,104.04) 101.39,103.91 102.05,103.25 106.22,103.25 106.27,103.3 108.91,103.3 109.24,103.63 109.24,103.83 110.05,104.64 112.34,104.64 112.57,104.42 112.57,104.01 112.9,103.68 114.75,103.68 115.13,104.06 123.21,104.06 123.34,103.93 130.2,103.93 131.34,102.79 138.98,102.79 139.36,103.17 146.32,103.17 147.01,102.49 151.13,102.49 153.04,104.4 160.17,104.4 161.74,105.97 166.57,105.97 167.37,106.76 167.37,107.06 168.36,108.05 172.61,108.05 176.42,111.86 179.61,111.86 180.16,111.31 182.77,111.31 183.56,110.51 183.56,109.62 185.67,107.51 199.59,107.51 201.72,109.65 v2(201.72,110)
  BOTTOM w0.203: PR7064.2 162.7,138.61 162.88,138.43 PR7067.1 163.11,138.17 v1(163.34,137.94) 163.47,137.82 163.47,137.46 163.34,137.33 PR7077.1 ; U6563.2 169.21,143.41 169.59,143.79 v2(170.61,143.79)
VCCAUX_VID0_R: length 26.8
  TOP w0.203: v1(102.79,112.8) 102.79,112.16 103.02,111.93 103.02,111.05 102.61,110.64 102.03,110.64 v2(101.65,110.26) 101.21,109.83 R68509.2 R68502.2
  IN2 w0.254: v1(102.79,112.8) 102.41,112.8 102.13,113.08 102.13,116.58 102.92,117.37 105.33,117.37 106.85,118.89 106.85,122.68 107.66,123.49 107.66,127.45 107.91,127.69 107.91,128.64 107.53,129.02 107.52,129.31 v1(107.52,129.36)
  BOTTOM w0.254: v1(107.52,129.36) 107.52,129.14 U6539.DB37
VCCAUX_VID1: length 199.4
  TOP w0.203: R68504.1 102.64,108.71 102.28,108.35 v2(102.28,107.21) 102.28,106.96 102.03,106.7 v1(102.03,104.04) ; v2(201.34,123.31) 201.21,123.19 201.21,117.5 201.66,117.05 201.66,112.61 202.36,111.91 202.41,111.91 v2(202.43,111.88) 202.89,111.88 203.26,111.51 D13150.1
  IN1 w0.203: v2(170.61,143.13) 170.61,142.39 167.86,139.65 164.69,139.65 164.13,139.09 164.13,137.82 163.62,137.31 162.48,137.31 162.22,137.56 v1(162.22,138.12) 162.1,138.12 161.84,137.87 161.84,137.31 162.99,136.17 163.62,136.17 165.4,134.39 165.4,134.01 166.16,133.25 166.16,130.17 169.06,127.28 169.34,127.28 171.62,124.99 177.46,124.99 178.56,123.9 180.56,123.9 180.89,124.23 187.12,124.23 188.03,123.31 190.14,123.31 190.72,123.9 190.72,125.04 191.69,126.01 197.4,126.01 197.53,125.88 198.93,125.88 199.94,124.86 201.21,124.86 201.85,124.23 201.85,123.72 201.44,123.31 v2(201.34,123.31)
  IN2 w0.203: v2(202.43,111.88) 202.2,111.88 198.17,107.85 185.85,107.85 183.94,109.75 183.94,110.64 182.93,111.66 180.39,111.66 179.83,112.21 176.3,112.21 172.49,108.4 168.24,108.4 166.8,106.96 164.64,106.96 163.98,106.3 161.56,106.3 160.02,104.75 152.9,104.75 151,102.84 147.14,102.84 146.45,103.53 139.24,103.53 138.83,103.12 131.52,103.12 130.18,104.45 129.75,104.45 128.21,105.99 123.26,105.99 121.69,104.42 115.21,104.42 114.96,104.67 112.95,104.67 112.64,104.97 109.9,104.97 108.91,103.98 108.91,103.81 108.73,103.63 106.01,103.63 105.96,103.58 102.48,103.58 v1(102.03,104.04)
  BOTTOM w0.203: PR7076.1 162.07,137.33 161.97,137.23 PR7068.1 PR7065.2 162.05,137.94 v1(162.22,138.12) ; U6563.1 169.86,143.29 169.97,143.41 170.23,143.41 170.51,143.13 v2(170.61,143.13)
VCCAUX_VID1_R: length 28.5
  TOP w0.203: v1(103.42,112.8) 103.68,112.54 v2(103.68,112.16) 103.4,111.88 103.4,110.92 102.64,110.16 R68504.2 R68510.2
  IN2 w0.254: v1(106.91,129.36) 106.91,129.44 107.34,129.87 107.72,129.87 108.12,129.46 108.12,128.99 108.31,128.8 108.31,127.6 108.56,127.35 108.56,124.16 108.06,123.66 108.06,123.28 107.49,122.7 107.49,118.77 106.47,117.75 106.47,116.48 105.89,115.9 102.97,115.9 102.53,115.47 102.53,113.46 102.71,113.28 103.2,113.28 103.42,113.05 v1(103.42,112.8)
  BOTTOM w0.254: U6539.DB38 107.11,128.96 106.9,129.17 106.9,129.35 v1(106.91,129.36)
VCCD_SP: length 2
  BOTTOM w0.203: C96866.1 15.31,54.79 15.31,54.78 U6555.33
VCCDSW_3P3: length 26.3
  TOP w0.203: v1(104.19,112.8) 104.34,112.64 C96772.2 104.34,111.81 103.92,111.39 R68503.1 103.92,111.21 104.31,110.82 v2(104.31,110.13) 103.94,109.76 R68501.1
  IN2 w0.254: v1(107.42,128.42) 107.42,127.97 106.75,127.3 106.75,123.44 106.62,123.31 106.07,123.31 103.93,121.18 103.93,118.64 103.49,118.2 103.11,118.2 101.52,116.61 101.52,112.93 102.15,112.29 103.68,112.29 v1(104.19,112.8)
  BOTTOM w0.254: v1(107.42,128.42) 107.45,128.4 107.45,128.3 U6539.DD37
VCCK_V12: length 7.1
  IN3 w0.508: v2(34.47,152.14) 33.67,152.14 31.92,150.39 28.51,150.39 v2(28.23,150.11)
  vias: v2(34.46,152.8)
VCCRTC_3:
  vias: v2(6.62,13.31)
VCCRTC_4:
  vias: v2(8.4,13.51)
VCCSENSE: length 73.5
  TOP w0.114: v2(138.35,154.71) 138.6,154.45 139.48,154.45 139.86,154.07 140.52,154.07 140.63,154.19 PR7052.2 141.04,154.61 141.11,154.68 PR7056.2 ; v2(105.51,173.76) 105.71,173.55 105.71,173.25 101.77,169.31 101.77,167.03 102.53,166.27 105.07,166.27 106.98,164.36 106.98,162.33 107.11,162.2 107.11,159.8 v1(106.8,159.49)
  IN2 w0.102: v2(105.51,173.76) 105.94,173.33 108.3,173.33 108.58,173.05 117.45,173.05 117.95,172.54 117.95,170.66 118.44,170.18 121.36,170.18 121.71,169.82 126.79,169.82 127.68,168.93 127.68,167.54 128.65,166.57 135.63,166.57 138.98,163.22 138.98,154.58 138.86,154.45 138.6,154.45 v2(138.35,154.71)
  BOTTOM w0.305: U6539.R38 106.8,159.41 v1(106.8,159.49)
VCCST_DIS1: length 8.3
  TOP w0.114: R68855.1 R68854.2 165.4,140.74 165.02,141.12 165.02,141.63 164.51,142.14 v2(163.24,142.14) 162.9,141.79 Q6598.6 162.44,141.16 162.22,141.37 162.22,141.63 161.97,141.88 161.34,141.88 161.08,141.63 Q6597.5
VCCST_DIS2: length 3.2
  TOP w0.114: R68847.2 160.96,137.18 161.73,137.96 v2(161.73,138.58) Q6597.3
VCCST_EN_1: length 23.2
  TOP w0.114: R68853.2 166.66,141.71 v2(166.87,141.5) ; Q6598.2 163.55,138.78 163.75,138.58 v2(164.41,138.58) 166.57,138.58 v1(166.77,138.78) ; R68840.2 170.73,140.36 v2(170.48,140.61)
  TOP w0.203: v2(171.88,146.45) 171.25,146.45 R68844.2
  IN1 w0.089: v2(170.48,140.61) 168.65,138.78 v1(166.77,138.78)
  IN2 w0.102: v2(166.87,141.5) 166.77,141.4 v1(166.77,138.78)
  IN3 w0.102: v2(171.88,146.45) 171.5,146.45 171.11,146.07 171.11,145.44 170.02,144.34 170.02,141.07 v2(170.48,140.61)
  BOTTOM w0.114: C96893.1 166.8,138.81 v1(166.77,138.78)
  BOTTOM w0.203: C96893.1 167.13,139.5 167.25,139.37 167.25,139.03 167.38,138.9 Q6609.2
VCCST_EN_2: length 4.2
  TOP w0.114: R68949.1 R68841.1 U6560.2 ; R68949.1 168.32,136.93 168.43,137.04 U6560.1 ; R68949.1 167.66,136.67 v2(167.53,136.55)
VCCST_OVERRIDE: length 64
  TOP w0.114: R68848.1 166.8,148.64 v2(166.67,148.51)
  IN3 w0.102: v1(154.27,137.87) 155.19,137.87 155.81,137.25 157.21,137.25 157.3,137.16 160.17,137.16 161.95,138.93 162.83,138.93 164.49,140.59 166.82,140.59 167.43,141.2 167.43,143.53 166.59,144.37 166.59,146.5 167.2,147.11 167.2,147.98 v2(166.67,148.51)
  IN4 w0.089: v1(154.27,137.87) 153,137.87 151.18,136.04 146.98,136.04 146.48,135.53 142.29,135.53 141.9,135.91 139.62,135.91 139.36,135.66 134.41,135.66 134.28,135.79 134.28,138.05 134.13,138.2 128.48,138.2 128.26,138.42 128.26,138.68 127.15,139.79 127.15,140.1 126.64,140.61 124.63,140.61 124.51,140.48 123.36,140.48 122.35,141.5 120.7,141.5 v1(120.27,141.93)
  BOTTOM w0.102: U6539.BP9 119.94,141.6 v1(120.27,141.93)
VCCST_OVERRIDE_EN: length 101.8
  TOP w0.114: U6558.2 207.44,111.01 207.22,111.23 204.27,111.23 204.13,111.1 204.13,109.62 203.12,108.61 202.94,108.61 202.35,108.01 D13149.2 201.68,108.01 201.21,108.48 201.21,110.64 200.81,111.05 200.81,115.36 200.32,115.85 v2(200.32,116.23) 200.32,123.14 v2(200.2,123.26)
  TOP w0.203: v2(172.64,148.26) 172.54,148.26 172.26,147.98 U6561.2
  IN1 w0.089: v2(200.2,123.26) 199.79,122.86 199.28,122.86 199.05,123.09 199.05,123.97 198.04,124.99 197.02,124.99 196.9,125.12 191.99,125.12 191.49,124.61 191.49,123.49 190.55,122.55 184.73,122.55 184.5,122.78 181.88,122.78 181.53,123.14 178.1,123.14 177.8,123.44 170.63,123.44 169.72,124.36 169.72,125.47 165.02,130.17 165.02,132.48 164.51,132.99 162.22,132.99 161.46,133.75 161.46,135.12 160.57,136.01 160.57,136.93 160.95,137.31 160.95,138.25 161.98,139.28 162.54,139.28 163.75,140.48 167.3,140.48 169.21,142.39 169.21,145.18 172.28,148.26 v2(172.64,148.26)
  BOTTOM w0.203: Q6610.3 170.48,148.23 170.86,148.61 172.13,148.61 172.29,148.77 R68843.1 173.4,148.41 173.27,148.28 172.66,148.28 v2(172.64,148.26)
VCCST_PWRGD_TCSS: length 61.9
  TOP w0.114: v2(166.67,149.17) 166.67,149.17 R68850.1
  IN3 w0.102: v2(166.67,149.17) 167.43,148.41 167.43,146.99 166.87,146.43 166.87,144.85 167.79,143.94 167.79,141.09 166.92,140.23 164.76,140.23 163.24,138.71 162.1,138.71 160.32,136.93 157.2,136.93 157.11,137.02 155.15,137.02 v1(154.73,137.44)
  IN4 w0.089: v1(154.73,137.44) 153.46,137.44 151.68,135.66 147.17,135.66 146.66,135.15 142.03,135.15 141.52,135.66 140,135.66 139.8,135.45 134.21,135.45 134.06,135.61 134.06,137.87 133.93,137.99 128.42,137.99 v1(127.88,138.53)
  BOTTOM w0.089: 126.72,138.35 126.36,137.99 125.98,137.99 125.17,137.18 124.51,137.18 124.46,137.23 123.75,137.23 123.5,137.22 123.16,137.22 123.11,137.2 122.98,137.16 122.65,137.1 122.54,137.1 U6539.CE5
  BOTTOM w0.114: v1(127.88,138.53) 126.89,138.53 126.72,138.35
VCCSTG_DIS1: length 4.8
  TOP w0.114: v2(203.4,117.37) R68835.2
  TOP w0.203: Q6608.5 202.36,119.3 ; 202.36,119.3 202.89,119.3 203.01,119.42 Q6608.6 ; 202.36,119.3 202.33,119.27 R68836.1 202.33,118.42 202.61,118.13 R68835.2
VCCSTG_EN: length 3.7
  TOP w0.114: U6557.2 C96884.1 R68828.1 204.39,109.27 204.5,109.38 U6557.1
VCCSTG_EN_1: length 6.1
  TOP w0.114: U6557.4 205.8,113.42 v2(205.28,113.94) 205.66,114.32 205.66,115.21 206.68,116.23 207.48,116.23 R68829.1
VCCSTG_EN_2: length 20.4
  TOP w0.114: R68857.2 210.49,115 210.1,115.39 v2(210.1,117.24) ; v2(210.1,117.24) 210.1,117.37 208.83,118.64 205.91,118.64 205.15,119.4 v2(205.15,119.66) 205.15,120.16 204.52,120.8 202.48,120.8 202.36,120.93 Q6608.2 ; v2(210.1,117.24) 209.6,116.74 R68837.2 R68829.2 208.77,115.32 208.68,115.23 R68831.2
  BOTTOM w0.114: v2(210.1,117.24) 209.98,117.37 209.98,117.75 209.47,118.26 C96885.1 209.47,119.08 C96886.1 210.16,119.78 Q6607.2
VDD_SUPPLY_1P: length 60.3
  IN1 w0.381: v1(23.29,46.25) 23.54,46 v2(28.16,46)
  IN1 w0.508: v2(23.54,53.82) v2(23.54,52.35)
  IN3 w0.381: v2(15.18,57.2) v2(15.18,56.54) 15.9,55.83 16.89,55.83 18.71,54 v2(19.3,54) 19.3,53.67 20.62,52.35 v2(23.54,52.35) 23.54,51.58 22.78,50.82 22.78,47.39 23.29,46.89 v1(23.29,46.25) 22.78,46.25 22.52,46 22.52,44.98 21.25,43.71 19.48,43.71 18.92,44.27 v1(18.33,44.27) v1(17.34,44.27) v1(16.45,44.27) 16.23,44.27 15.79,43.84 11.22,43.84 v1(10.84,44.22) 10.08,44.98 10.08,46.09 v1(9.32,46.86)
  BOTTOM w0.203: R68733.2 23.41,53.87 23.46,53.82 v2(23.54,53.82) ; R68711.1 22.78,46 23.03,46.25 v1(23.29,46.25) ; v1(16.45,44.27) 16.3,44.42 R68725.2 ; R68720.2 11.32,44.82 10.84,44.35 v1(10.84,44.22) ; v1(17.34,44.27) 17.34,44.29 17.32,44.32 R68726.2 ; R68695.1 20.34,55.01 19.32,54 v2(19.3,54) ; R68727.2 v1(18.33,44.27) ; U6564.5 26.1,45 26.31,45.21 26.31,45.46 26.59,45.74 27.73,45.74 27.99,46 v2(28.16,46) ; v2(23.54,52.35) 23.54,52.09 23.34,51.89 R68730.2 R68731.2 ; v1(9.32,46.86) R68721.2
  BOTTOM w0.254: v2(28.16,46) 28.75,45.41 R68968.2 28.51,45.08 28.43,45 U6564.1
  BOTTOM w0.305: U6555.31 14.31,54.03 TP13360.1 14.81,54.22 U6555.32
VSS_AUX_SENSE: length 10.6
  TOP w0.114: v1(120.92,149.25) 121.37,149.7 123.03,149.7 123.24,149.5 128.11,149.5 v2(128.32,149.7)
  BOTTOM w0.114: U6539.AV9 120.4,149.25 v1(120.92,149.25) ; v2(128.32,149.7) 128.32,150.36 v2(128.34,150.39) 128.57,150.62 PR7090.2
VSSSENSE: length 73.9
  TOP w0.114: v2(106.17,173.76) 105.96,173.55 105.96,173.12 102.03,169.19 102.03,167.15 102.66,166.52 105.2,166.52 108.01,163.71 108.01,159.93 107.59,159.51 v1(107.49,159.51) ; PR7057.2 140.99,153.21 140.92,153.28 PR7058.2 140.63,153.69 140.51,153.82 139.75,153.82 139.36,154.2 138.6,154.2 v2(138.35,153.95)
  IN2 w0.102: v2(106.17,173.76) 106.37,173.55 108.45,173.55 108.71,173.3 117.52,173.3 118.18,172.64 118.18,170.81 118.56,170.43 121.48,170.43 121.84,170.08 126.92,170.08 127.93,169.06 127.93,167.66 128.82,166.77 135.81,166.77 139.24,163.34 139.24,154.45 138.98,154.2 138.6,154.2 v2(138.35,153.95)
  BOTTOM w0.305: U6539.R37 107.49,159.37 v1(107.49,159.51)
1.03_GFX_PGD: length 88.3
  IN1 w0.089: v2(106.14,183.18) 106.67,182.65 110.57,182.65 111.4,183.49 112.49,183.49 112.94,183.04 113.62,183.04 114.19,183.61 114.4,183.61 114.66,183.87 118.87,183.87 118.92,183.92 122.6,183.92 124.25,182.27 127.3,182.27 129.27,180.3 130.54,180.3 132.6,178.24 134.64,178.24 136.43,176.45 139.36,176.45 140.82,174.99 140.82,173.39 143.93,170.28 154.63,170.28 155.42,169.49 159.33,169.49 160.37,168.45 166.97,168.45 168.24,167.18 168.24,165.85 167.66,165.27 167.66,160.91 169.01,159.56 169.01,156.8 170.1,155.7 170.1,155.34 170.6,154.85 v1(170.84,154.85)
  BOTTOM w0.114: PR9078.1 PR9076.1 106.12,183.21 v2(106.14,183.18)
  BOTTOM w0.203: v1(170.84,154.85) v2(170.84,154.2) 170.67,154.03 PR9096.1
1P35V_BOOT: length 2.3
  TOP w0.203: PU5001.18 87.85,176.09 87.73,176.22 v2(87.73,176.25)
  TOP w0.508: PR5008.2 87.31,176.66 v2(87.73,176.25)
1P35V_CS: length 1.6
  TOP w0.203: PU5001.13 90.39,178.38 90.22,178.56 90.22,179.1 PR5005.2
1P35V_FB: length 2.6
  TOP w0.203: PU5001.6 92.36,175.29 92.63,175.03 92.63,174.65 92.35,174.36 PR5018.1 PR5019.1
1P35V_LGATE: length 6.4
  TOP w0.203: v2(89.07,178.2) 89.07,177.95 89.33,177.69 PU5001.15
  IN4 w0.508: v2(89.07,178.2) 88.97,178.3 88.97,180.59 87.55,182.01 v2(87.55,182.04)
  BOTTOM w0.508: v2(87.55,182.04) 86.96,182.04 PQ5000.4
1P35V_PGOOD: length 3
  TOP w0.203: PR5002.1 92.37,179.47 92.12,179.22 92.12,178.2 91.99,178.08 PU5001.10
1P35V_PHASE: length 6.1
  IN4 w0.508: v2(88.54,177.47) 87.68,178.33 87.68,180.49 86.89,181.28 v2(85.31,181.28)
  vias: v2(83.4,181.25)
1P35V_S3: length 9.5
  TOP w0.203: PU5001.7 92.58,175.69 93.01,175.26 93.01,173.33 92.49,172.81 90.97,172.81 90.85,172.68 90.85,171.73 91.06,171.51 PC5000.1 91.36,171.09 91.21,170.94 PR5013.1 91.21,170.25 PR5006.2 PR5015.2
1P35V_S5: length 9.2
  TOP w0.203: PU5001.8 92.78,176.09 93.44,175.44 93.44,173.76 93.64,173.55 93.64,171.98 93.18,171.51 PC5001.1 92.32,171.09 92.45,170.96 PR5004.1 92.1,170.6 92.04,170.66 PR5013.2 91.66,170.28 91.69,170.25 PR5003.2
1P35V_TON: length 2.4
  TOP w0.203: PR5007.2 92.71,177.49 92.76,177.44 92.76,176.7 92.55,176.49 PU5001.9
1P35V_UGATE: length 5.8
  TOP w0.203: v2(87.85,177.17) 87.85,176.86 88.22,176.49 PU5001.17
  IN4 w0.508: v2(87.85,177.17) 86.86,178.16 v2(86.86,180.36)
  BOTTOM w0.508: PQ5001.4 86.61,180.59 86.84,180.36 v2(86.86,180.36)
1P35V_VDD: length 5.3
  TOP w0.114: PR5011.2 88.51,181.1 v2(88.41,181)
  TOP w0.203: PR5011.2 89.32,180.72 89.49,180.55 89.69,180.55 89.93,180.31 PC5019.1 89.93,179.88 90.07,179.75 90.36,179.75 90.6,179.51 90.6,178.69 90.79,178.49 PU5001.12
1P35V_VDDQ: length 26.9
  TOP w0.203: PR5018.2 91.9,174.62 v2(91.75,174.76) 91.48,174.49 PU5001.5
  BOTTOM w0.203: PR5012.2 69.21,178.94 v2(69.21,178.46) 69.64,178.46 70.02,178.08 70.02,177.54 70.2,177.36 82.8,177.36 83.1,177.06 87.04,177.06 87.52,176.58 88.54,176.58 89.2,175.92 89.2,175.41 89.83,174.77 91.74,174.77 v2(91.75,174.76)
1P35V_VID: length 2.8
  TOP w0.203: PR5017.2 PR5016.1 91.58,179.12 91.76,178.94 91.76,178.56 91.19,177.99 PU5001.11
2ND_MBCLK: length 247.5
  TOP w0.114: R67448.1 R383.1 146.76,109.32 146.65,109.22 v2(146.65,108.91) ; U37.115 158.66,112.61 v2(158.87,112.82) 159.18,113.13 v1(159.18,113.61)
  IN1 w0.089: v2(223.69,119.91) 218.87,119.91 217.98,119.02 215.95,119.02 213.15,116.23 204.77,116.23 204.47,116.53 203.3,116.53 202.74,115.97 201.59,115.97 200.96,115.34 198.32,115.34 197.94,114.96 196.39,114.96 196.13,114.7 193.34,114.7 192.1,113.46 189.33,113.46 187.96,114.83 186.1,114.83 184.93,116 178.81,116 177.52,114.7 177.52,114.17 176.78,113.43 174.85,113.43 173.93,114.35 172.23,114.35 171.7,113.81 168.19,113.81 167.56,113.18 165.91,113.18 165.65,112.93 161.72,112.93 161.08,113.56 161.08,113.94 160.73,114.3 159.41,114.3 159.18,114.07 v1(159.18,113.61) ; v1(94.61,179.88) 99.23,179.88 100.88,178.23 103.47,178.23 104.03,177.68 109.11,177.68 109.55,177.24 114.7,177.24 115.41,176.53 v1(117.65,176.53)
  IN3 w0.102: v2(140.63,126.01) 141.27,126.01 141.9,125.37 148,125.37 151.18,128.55 151.18,134.06 149.96,135.28 144.01,135.28 141.57,137.72 141.57,143.74 140.1,145.21 140.1,147.49 139.92,147.67 139.92,156.23 139.62,156.54 139.62,163.34 136.38,166.59 131.55,166.59 130.27,167.87 130.27,169.9 127.4,172.77 124.18,172.77 121.03,175.92 118.16,175.92 117.65,176.43 v1(117.65,176.53) ; v2(146.65,108.91) 146.65,109.17 147.11,109.62 148.51,109.62 150.79,111.91 154.1,111.91 155.11,112.93 158.49,112.93 v1(159.18,113.61)
  IN4 w0.089: v2(140.63,126.01) 141.27,126.01 141.65,125.63 141.65,125.5 142.03,125.12 149.78,125.12 151.3,123.59 155.8,123.59 156.71,122.68 156.71,122.09 157.1,121.7 159.68,121.7 162.73,118.65 162.73,116.29 160.57,114.13 159.7,114.13 v1(159.18,113.61)
  BOTTOM w0.114: v2(140.63,126.01) 140,126.01 139.87,126.13 139.87,128.93 138.48,130.32 R68866.2 137.72,129.93 138.13,129.52 Q6606.1 ; CN49.22 223.57,117.25 223.95,117.62 223.95,119.66 v2(223.69,119.91) ; Q6564.3 93.12,181.25 93.01,181.14 93.01,180.78 93.91,179.88 v1(94.61,179.88)
2ND_MBDATA: length 248.2
  TOP w0.114: R25304.1 145.9,108.73 v2(145.71,108.91) 145.27,108.91 R67447.1 ; U37.116 158.26,111.98 158.44,112.17 158.44,113.49 v1(158.57,113.61)
  IN1 w0.089: v1(158.57,113.61) 158.57,114.22 159,114.65 160.88,114.65 161.46,114.07 161.46,113.69 161.87,113.28 164.64,113.28 164.89,113.53 167.28,113.53 167.91,114.17 171.55,114.17 172.08,114.7 174.09,114.7 175,113.79 176.63,113.79 177.13,114.3 177.13,114.83 178.66,116.35 185.08,116.35 186.23,115.21 188.08,115.21 189.48,113.81 191.69,113.81 192.96,115.08 195.75,115.08 196.01,115.34 197.53,115.34 198.04,115.85 200.83,115.85 201.34,116.35 202.48,116.35 203.02,116.89 204.74,116.89 205.02,116.61 212.9,116.61 215.67,119.38 217.83,119.38 218.71,120.27 223.29,120.27 v2(223.69,120.67) ; v2(95.68,180.29) 99.33,180.29 101.04,178.58 103.63,178.58 104.19,178.02 109.27,178.02 109.7,177.59 114.85,177.59 115.39,177.06 117.72,177.06 v1(118.26,176.53)
  IN3 w0.102: v2(145.71,108.91) 145.77,108.91 146.86,110 148.31,110 150.72,112.42 154,112.42 154.86,113.28 158.24,113.28 v1(158.57,113.61) ; v1(118.26,176.53) 118.28,176.53 118.51,176.3 121.18,176.3 124.35,173.12 127.68,173.12 130.63,170.18 130.63,168.02 131.69,166.95 136.52,166.95 140,163.47 140,156.77 140.28,156.49 140.28,147.95 140.46,147.77 140.46,145.49 141.93,144.01 141.93,137.87 144.14,135.66 150.08,135.66 151.56,134.18 151.56,128.29 148.25,124.99 141.65,124.99 v2(141.14,125.5)
  IN4 w0.089: v1(158.57,113.61) 159.43,114.48 160.43,114.48 162.39,116.43 162.39,118.5 159.53,121.36 156.95,121.36 156.37,121.95 156.37,122.54 155.69,123.21 151.18,123.21 149.63,124.76 141.88,124.76 v2(141.14,125.5)
  BOTTOM w0.114: CN49.23 223.71,116.75 224.33,117.37 224.33,120.05 223.71,120.67 v2(223.69,120.67) ; v2(95.68,180.29) 95.68,180.87 94.79,181.76 94.79,182.78 94.42,183.14 Q6564.6 ; Q6606.4 136.1,127.95 135.81,127.66 135.81,127.22 R68865.2 137.22,125.8 v2(138.55,125.8) 138.86,125.5 v2(141.14,125.5)
27M_XTAL_IN: length 10.7
  BOTTOM w0.102: U8.C11 128.19,183.7 128.19,183.13 128.25,183.07 128.25,181.94
  BOTTOM w0.114: Y3.3 126.66,176.04 126.66,177.19 127.17,177.69 127.17,177.95 C463.1 127.1,178.72 127.1,179.65 128.19,180.74 128.19,181.89 128.25,181.94
27M_XTAL_OUT: length 9.7
  BOTTOM w0.102: U8.B10 127.7,183.01 127.81,182.9 127.92,182.9 128.04,182.78 128.04,182.25 127.81,182.01
  BOTTOM w0.114: 127.81,182.01 127.77,181.98 127.77,181.67 127.93,181.51 127.93,180.91 127.77,180.74 127.47,180.74 127.15,180.43 127.15,180.13 126.83,179.81 126.41,179.81 126.28,179.68 126.28,179.47 126.41,179.35 126.5,179.35 126.59,179.25 126.59,179.07 126.28,178.76 126.28,178.54 C464.1 126.52,177.95 126.39,177.82 125.39,177.82 125.29,177.71 125.29,177.55 125.56,177.27 Y3.1
80PORT_CLK: length 68
  TOP w0.114: R68570.2 171.63,111.27 171.88,111.27 172.28,110.87 v1(172.28,110.64) ; CN66.3 v2(204.9,93.49)
  IN1 w0.089: v1(172.28,110.64) 172.16,110.51 172.16,109.75 172.46,109.45 174.24,109.45 174.87,110.08 180.94,110.08 183.21,107.82 199.46,107.82 200.58,106.7 203.88,106.7 204.64,107.46 207.44,107.46 208.96,105.94 211.88,105.94 212.26,105.56 v2(214.93,105.56)
  IN2 w0.102: v2(214.93,105.56) 214.68,105.56 212.44,103.32 212.44,102.56 211.25,101.37 211.25,96.16 209.98,94.89 207.06,94.89 205.66,93.49 v2(204.9,93.49)
80PORT_DAT: length 4.6
  TOP w0.114: CN66.4 205.4,95.78 v2(205.02,96.16) 205.02,96.97 204.05,97.95 R68568.1
5213EN_1.8V: length 19.3
  TOP w0.254: PU9005.4 31.27,138.31 31.09,138.13 30.85,138.13 v2(29.89,139.09) v2(29.05,139.09) ; v2(38.37,140.48) 38.43,140.43 PR566.1 PC581.1 38.17,138.83 37.16,138.83 37,138.99 PU3004.7
  BOTTOM w0.254: v2(29.05,139.09) 29.05,141.04 29.51,141.5 32.3,141.5 32.74,141.07 35.02,141.07 35.99,140.1 37.99,140.1 v2(38.37,140.48)
5213FB_1.8V: length 3.8
  TOP w0.254: PC574.2 PR568.2 38.19,143.52 38.09,143.42 PR567.2 37.5,143.29 PU3004.1
5213FB_1.8V_S: length 9.5
  TOP w0.254: PR568.1 38.77,144.3 39.22,143.85 39.22,141.82 39.03,141.62 PC574.1 38.65,141.25 38.83,141.07 39.34,141.07 39.67,140.74 v2(39.67,139.72) 39.54,139.6 39.54,137.44 39.13,137.03 PR569.1
5213LX_1.8V:
  vias: v2(38.65,137.66)
5213PG_1.8V: length 4.4
  TOP w0.254: PU3004.2 37,142.77 37.07,142.84 37.07,145.05 37.39,145.36 37.85,145.36 37.88,145.34 PR9256.2
8813BOOT1: length 1.2
  TOP w0.114: PC9008.2 101.63,200.59 v2(102.05,201.01)
8813EN: length 11.2
  TOP w0.254: PU9000.3 100.38,197.96 100.38,198.11 v1(100.12,198.37) 99.97,198.51 99.54,198.51 PC9013.1
  BOTTOM w0.254: PR9284.1 99.11,194.32 99.36,194.58 PR9085.2 99.55,194.58 99.61,194.64 99.68,194.64 99.96,194.92 99.96,196.14 99.61,196.49 98.47,196.49 98.18,196.78 PD1.2 98.18,197.98 98.57,198.37 v1(100.12,198.37) v2(101.14,198.37)
8813ILIM: length 4.3
  TOP w0.254: PU9000.12 101.21,193.45 101.21,193.01 v1(101.37,192.86)
  BOTTOM w0.254: v1(101.37,192.86) 101.37,192.91 101.39,192.94 101.39,193.27 PC9030.1 100.78,193.21 v2(100.2,193.21) 100.2,194.03 PR9032.2
8813ISEN1: length 3.1
  TOP w0.254: PU9000.15 v1(103.88,193.75)
  BOTTOM w0.254: PR9013.2 104.71,193.75 v1(103.88,193.75) 103.88,194.16 103.38,194.67
8813ISEN2: length 2.9
  TOP w0.254: v1(103.88,193.14) 103.77,193.14 103.67,193.24 103.37,193.54 103.37,193.55 PU9000.14
  BOTTOM w0.254: v1(103.88,193.14) 103.74,193.14 PR9025.2
8813LGAT1: length 5.4
  TOP w0.254: PU9000.23 102.86,197.95 103.21,198.3 v3(103.21,198.87)
  BOTTOM w0.61: PQ9000.8 103.86,200.81 104.24,200.42 104.24,199.9 v2(103.94,199.6) v3(103.21,198.87) 103.21,198.74 102.79,198.32 PR9011.1
8813LGAT2: length 12.2
  TOP w0.254: v3(104.92,197.1) 104.67,197.35 104.41,197.35 PU9000.20
  IN4 w0.61: v3(113.39,196.03) 105.99,196.03 v3(104.92,197.1)
  BOTTOM w0.114: v3(104.92,197.1) 104.67,196.85 v2(104.67,196.39)
  BOTTOM w0.61: PQ9001.8 112.57,195.79 112.8,196.03 v3(113.39,196.03)
8813PG: length 2.1
  TOP w0.254: PR9009.2 PR9008.2 104.27,194.1 104.09,194.28 104.06,194.28 PU9000.16
8813PHASE1: length 4.8
  IN4 w0.61: v3(104.26,203.02) 104.26,203 104.26,202.02 102.36,200.12 v3(102.36,199.03)
  vias: v2(104.31,203.96)
8813PHASE2: length 1.2
  TOP w0.61: PC9020.1 106.21,197.16 106.38,197.16 v3(106.85,197.63)
  vias: v2(106.83,198.35)
8813PSI: length 4.7
  TOP w0.254: PU9000.4 99.87,197.76 v2(99.44,197.76) 99.39,197.76 98.63,198.51 PR9022.2 98.05,198.51 PR9016.2 PR9018.2
8813PVCC: length 4.8
  TOP w0.114: v2(106.24,198.37) 106.24,199.39 PR9001.2
  TOP w0.254: PR9001.2 105.47,199.09 105.43,199.09 PC9000.1 104.47,198.13 104.47,198.12 PU9000.21
8813REFADJ: length 1.7
  TOP w0.254: PU9000.6 99.34,196.87 98.57,196.87 PR9023.2
8813REFIN: length 6.7
  TOP w0.254: v2(94.79,196.49) 94.84,196.54 PR9024.2 95.71,196.5 PR9027.1 95.71,195.51 96.15,195.95 96.21,195.95 96.24,195.98 97.15,195.98 97.45,195.68 PC9026.1 99,195.45 99.23,195.22 99.45,195.22 PU9000.7
8813RGN: length 4.4
  TOP w0.203: PR9029.1 98.92,193 PC9029.1
  TOP w0.254: PU9000.10 100.38,194.02 100.38,193.41 100.18,193.21 PC9028.2 100.15,193.13 100.15,193.03 100.15,193.03 100.15,192.78 v2(99.74,192.38) 99.08,193.04 PC9029.1
8813TON: length 2
  TOP w0.203: PU9000.9 99.99,194.35 99.99,194.13 v2(99.77,193.9) 99.24,193.9 99.09,194.05 PR9002.1
8813UGATE1: length 3.2
  TOP w0.254: PU9000.2 100.78,198.26 v3(100.78,199.06)
  BOTTOM w0.61: PR9006.1 v2(99.97,199.06) v3(100.78,199.06)
8813UGATE1_1: length 2.3
  BOTTOM w0.61: PQ9000.1 97.86,200.81 v2(97.12,200.07) 97.12,199.62 PR9006.2
8813UGATE2: length 11.6
  IN4 w0.61: v3(104.97,194.81) 104.97,193.11 106.39,191.69 v3(113.25,191.69)
  BOTTOM w0.61: PR9014.1 113.75,192.19 v3(113.25,191.69)
  vias: v2(105.79,194.74)
8813UGATE2_1: length 1.7
  BOTTOM w0.61: PQ9001.1 113.72,190.62 PR9014.2
9336ADJ:
  vias: v2(99.74,185.75)
9336DRV: length 14.4
  IN2 w0.508: v2(93.88,193.04) 95.2,193.04 98.98,189.27 98.98,188.92 99.41,188.49 100.12,188.49 100.63,189 v2(100.63,189.25)
  BOTTOM w0.508: v2(100.63,189.25) 100.8,189.08 PD9001.1 100.8,187.39 100.7,187.29 PR9080.1 100.7,186.12 100.86,185.96 PU9003.6 ; PQ9008.4 93.47,192.63 v2(93.88,193.04)
24780_ACDET: length 7.7
  TOP w0.254: v2(163.24,121.94) 163.37,121.81 PR9275.2 163.78,121.41 163.88,121.3 PR211.2 164.26,121.74 164,121.99 v2(164,122.12) 164,122.42 164.38,122.81 PR31.2
  BOTTOM w0.152: PU1.6 159.59,121.77 159.8,121.98 160.66,121.98 160.88,121.76 161.56,121.76 161.74,121.94 v2(163.24,121.94)
24780_ACDRV: length 4.5
  BOTTOM w0.152: PU1.4 158.79,121.84 159.55,122.59 160.76,122.59 160.96,122.79 161.97,122.79 PR29.2
24780_ACN: length 149.4
  TOP w0.114: v2(77.64,199.79) PR2.1 ; v2(158.62,124.43) 158.11,124.43 v2(157.94,124.26)
  IN3 w0.102: v2(157.94,124.26) 158.8,124.26 158.92,124.13 158.92,123.85 158.8,123.72 157.78,123.72 157.4,124.1 157.4,132.36 155.49,134.26 154.73,134.26 149.4,139.6 144.7,139.6 144.05,140.25 144.05,145.83 142.92,146.96 142.92,151.38 142.36,151.94 142.36,154.96 142.82,155.42 142.82,166.06 142.36,166.52 142.36,168.73 138.6,172.49 132,172.49 130.35,174.14 130.35,174.9 129.46,175.79 129.46,178.46 129,178.91 124.07,178.91 123.62,178.46 120.19,178.46 117.73,180.91 117.73,185.44 111.64,191.54 107.23,191.54 106.73,191.03 97.33,191.03 95.8,192.55 93.35,192.55 92.59,193.32 92.59,198.46 90.77,200.28 78.86,200.28 78.18,199.59 77.85,199.59 v2(77.64,199.79)
  BOTTOM w0.114: PC35.1 158.25,123.95 v2(157.94,124.26)
  BOTTOM w0.152: PU1.1 157.59,121.81 157.69,121.91 157.69,122.03 157.94,122.28 PC25.2 157.94,123.32 158.08,123.47 158.44,123.47 158.56,123.59 PC35.1
24780_ACP: length 150.2
  TOP w0.114: v2(76.88,199.79) PR1.1
  IN3 w0.102: v2(160.22,124.33) 159.41,124.33 159.18,124.1 159.18,123.72 158.92,123.47 157.65,123.47 157.14,123.97 157.14,132.23 155.43,133.94 154.67,133.94 149.27,139.34 144.57,139.34 143.81,140.1 143.81,145.69 142.67,146.83 142.67,151.03 142.13,151.56 142.13,155.09 142.59,155.55 142.59,165.93 142.13,166.39 142.13,168.63 138.51,172.26 131.85,172.26 130.09,174.01 130.09,174.77 129.2,175.66 129.2,178.33 128.85,178.69 124.23,178.69 123.74,178.2 120.11,178.2 117.5,180.81 117.5,185.32 111.53,191.28 107.36,191.28 106.85,190.78 97.2,190.78 95.73,192.25 93.34,192.25 92.36,193.23 92.36,198.37 90.68,200.05 79.14,200.05 78.43,199.34 77.31,199.34 76.88,199.77 v2(76.88,199.79)
  BOTTOM w0.152: v2(160.22,124.33) 159.84,123.95 PC36.2 158.72,123.14 PC25.1 158.72,122.63 157.99,121.9 PU1.2
24780_BATDRV: length 12.1
  TOP w0.381: PR4.2 150.24,117.02 150.89,116.37 150.89,115.88 151.43,115.34 v2(151.81,115.34) 152.46,114.69 154.06,114.69 155.06,115.7 155.06,116.3 155.52,116.76 158.03,116.76 v2(158.49,116.3)
  BOTTOM w0.152: v2(158.49,116.3) 158.79,116.6 PU1.18
24780_BATSRC: length 14.8
  TOP w0.381: PR7.2 148.78,116.08 v2(148.94,115.92) 149.96,115.92 151.15,114.73 151.63,114.73 152.2,114.16 154.29,114.16 155.62,115.49 155.62,115.87 155.98,116.23 157.68,116.23 158.21,115.69 158.74,115.69 159.15,116.11 v2(159.15,116.28)
  BOTTOM w0.152: PU1.17 159.19,116.32 v2(159.15,116.28)
24780_BM#: length 3
  BOTTOM w0.152: PR9.1 160.69,115.55 v2(160.4,115.85) 160.29,115.95 160.29,116.51 160.09,116.71 159.74,116.71 159.59,116.86 PU1.16
24780_BST: length 0.9
  TOP w0.508: v3(155.44,119.43) 155.42,119.43 155.34,119.5 PR11.1
24780_CMPIN: length 3.4
  TOP w0.152: v2(161.78,118.02) 162.24,118.02 162.48,118.26 v2(162.48,118.41) 162.38,118.51 161.84,118.51 161.74,118.61 PR207.1
  BOTTOM w0.152: v2(161.78,118.02) 161.78,118.17 161.4,118.55 PU1.13
24780_CMPOUT: length 5.4
  BOTTOM w0.114: v2(164.38,116.23) 164.26,116.23 163.95,115.92 163.74,115.92 PR15.1
  BOTTOM w0.152: PU1.14 161.09,118.15 161.3,117.94 161.3,117.73 161.5,117.52 162.05,117.52 162.62,116.95 162.62,116.21 162.91,115.92 163.35,115.92 PR15.1
24780_CMSRC: length 3.3
  BOTTOM w0.152: PR28.2 159.83,123.33 v2(159.58,123.09) 159.18,122.68 159.18,122.65 158.39,121.87 PU1.3
24780_DH: length 9
  TOP w0.114: v2(149.19,119.4) 148.9,119.4 v2(148.59,119.1)
  IN1 w0.508: v2(148.59,119.1) 153.66,119.1 154.78,120.21 v3(155.44,120.21)
  BOTTOM w0.381: 149.03,118.66 PQ30.4
  BOTTOM w0.508: v2(148.59,119.1) 149.03,118.66
24780_DL: length 5.7
  TOP w0.508: v2(152.7,115.3) 153.77,115.3 154.45,115.97 154.45,116.74 v2(154.73,117.01) v3(155.9,118.18)
  BOTTOM w0.381: v2(152.7,115.3) 152.35,114.95 PQ29.4
24780_ILIM: length 5.2
  BOTTOM w0.114: PR204.1 154.98,114.98 154.98,114.54 v2(154.71,114.27)
  BOTTOM w0.152: PU1.21 157.17,117.35 156.01,116.19 155.98,116.19 155.93,116.14 PC8.2 PR206.1 154.91,116.09 154.9,116.09 154.9,115.72 154.85,115.66 PR204.1
24780_LX: length 13.1
  TOP w0.508: v3(155.93,120.85) 155.77,121.01 PC15.1
  IN1 w0.508: v3(155.93,120.85) 155.6,121.18 154.22,121.18 153.08,120.04 148,120.04 146.6,118.64 v2(146.6,117.62)
24780_SRN: length 24.8
  TOP w0.114: PR208.1 139.46,111.43 139.59,111.3 139.59,111.02 139.72,110.89 v1(139.72,110.87)
  BOTTOM w0.152: PR6.2 157.96,114.66 157.96,114.35 PC3.1 158.14,114.14 157.78,113.78 157.78,113.3 158.03,113.05 PC4.2 158.03,112.43 v2(158.29,112.16) 157.78,111.66 157.78,111.15 157.5,110.87 154,110.87 153.13,111.73 152.27,111.73 151.46,110.92 141.07,110.92 140.57,110.41 140.1,110.41 139.72,110.79 v1(139.72,110.87)
24780_SRP: length 22.7
  TOP w0.114: PR210.2 140.25,111.18 140.25,110.94 v1(140.33,110.87)
  BOTTOM w0.152: PR5.2 157.53,114.33 157.45,114.25 PC3.2 157.36,113.69 157.39,113.67 157.39,113.42 157.03,113.05 PC6.2 157.03,112.17 v2(157.02,112.16) 157.4,111.78 157.4,111.3 157.27,111.17 154.2,111.17 153.33,112.04 152.14,112.04 151.33,111.22 140.91,111.22 140.56,110.87 v1(140.33,110.87)
24780_VCC:
  vias: v2(156.76,121.97)
+1.03_GFX: length 19.6
  TOP w0.305: C366.1 135.78,198.24 v1(135.53,198.5)
  TOP w0.381: v2(142.62,209.98) 142.76,209.98 143.05,209.7 C354.1
  IN2 w0.508: v2(99.77,189.25) 99.74,189.28 99.74,191.66 95.6,195.81 v2(95.6,198.35)
  BOTTOM w0.305: U8.AC24 139.32,200.67 v1(138.96,201.04) ; v1(135.53,198.5) 137.23,198.5 U8.AA22 ; v1(140.53,201.85) U8.AD25 ; U8.AE26 140.92,202.27 v1(141.33,202.68) 141.72,202.29 U8.AE27 ; v1(138.13,200.14) U8.AB23
  BOTTOM w0.508: PR9081.1 99.77,187.41 v2(99.77,189.25)
  vias: v2(94.84,199.06) v2(94.94,198.35) v2(95.5,199.06) v2(95.68,197.38) v2(142.62,210.66)
+601_VCC:
  vias: v2(226.11,113.56) v2(226.87,113.56) v2(232.58,118.26) v2(233.04,117.6) v2(233.27,118.26)
+AZA_VDD: length 3.8
  BOTTOM w0.203: R455.2 25,38.12 23.67,38.12 23.1,37.56 R478.2
  vias: v2(25.19,35.2)
+CRT_AVCC_33:
  vias: v2(34.46,149.63)
+CRT_VDDA33: length 19.7
  TOP w0.203: v2(26.55,154.63) 26.81,154.36 C20012.1 26.81,153.89 27.83,152.88 U67.20 ; R458.1 R1616.1 v2(30.78,147) v2(31.5,146.28) 31.67,146.1 R25533.1
  TOP w0.508: L17.2 29.05,146.84 C20010.2 30.63,146.84 v2(30.78,147)
  BOTTOM w0.508: v2(30.78,147) 30.78,149.5 29.09,151.2 29.09,151.99 26.55,154.53 v2(26.55,154.63)
+FB_PLLAVDD: length 32.8
  TOP w0.203: C454.2 136.7,192.17 136.42,192.46 v1(136.42,192.65) ; C455.2 133,186.71 v1(133.3,187.01)
  TOP w0.305: C453.2 138.01,187.7 v1(138.1,187.79)
  IN2 w0.508: 132.57,187.58 129.93,187.58 128.43,189.08 127.87,189.08 127.14,188.36 126.08,188.36 125.56,188.87 120.46,188.87 117.91,191.42 117.91,193.44 116.81,194.54 v2(115.43,194.54) ; 135.55,188.18 135.55,191.79 v1(136.42,192.65)
  BOTTOM w0.305: U8.P22 137.57,193.15 137.21,192.78 136.54,192.78 v1(136.42,192.65) ; v1(138.1,187.79) 137.7,188.19 U8.H22
  BOTTOM w0.381: U8.F16 132.75,186.49 133.22,186.96 133.25,186.96 v1(133.3,187.01)
  vias: v2(114.57,194.66)
+MOD_VUP: length 7.6
  TOP w0.381: R67565.2 57.83,96.16 v2(59.13,97.46) 60.14,97.46 60.5,97.81 60.5,98.32 60.85,98.68 61.49,98.68 v2(62.1,98.07)
  BOTTOM w0.114: v2(62.1,98.07) 62.2,98.17 CN58.12
+PBA_PWR: length 5.7
  TOP w0.114: v2(116.12,106.35) 116.73,106.35 v2(116.89,106.19)
  TOP w0.508: v2(116.12,106.35) 115.84,106.07 C749.2 R25295.2
  BOTTOM w0.508: Q32.1 115.27,107.2 v2(116.12,106.35)
+PBA_PWR_C: length 156.3
  IN2 w0.508: v2(94.76,94.59) 94.79,94.56 94.79,94.13 94.99,93.93 120.62,93.93 120.95,94.26 v2(120.95,94.89) 122.35,94.89 122.8,95.35 136.49,95.35 137.87,93.98 153.21,93.98 153.49,94.26 170.63,94.26 171.14,94.76 180.21,94.76 182.67,97.23 183.26,97.23 183.94,96.54 186.86,96.54 187.54,95.86 202.48,95.86 202.94,95.4 209.47,95.4 210.61,96.54 210.61,99.23 v2(210.23,99.62)
  IN4 w0.508: v2(118.32,98.06) 119.58,96.8 120.44,96.8 120.62,96.62 120.62,95.35 120.95,95.02 v2(120.95,94.89)
  BOTTOM w0.254: CN52.1 210.85,100.08 210.38,99.62 v2(210.23,99.62)
  BOTTOM w0.305: 73.96,98.4 73.95,98.41 CN14.8
  BOTTOM w0.508: R614.2 118.5,98.66 118.32,98.48 v2(118.32,98.06) ; 73.96,98.4 73.96,98.24 74.39,97.81 75.61,97.81 78.79,94.64 83.41,94.64 83.82,94.23 92.6,94.23 93.64,95.27 94.41,95.27 94.79,94.89 94.79,94.61 v2(94.76,94.59)
+PBA_PWR_R: length 13.3
  BOTTOM w0.508: R608.2 114.32,110.26 114.04,109.98 114.04,109.34 114.32,109.06 Q32.3 114.32,106.73 115.61,105.44 C752.2 C753.2 115.61,102.52 v2(118.13,100) 118.27,99.86 R614.1
+PSWOUT: length 23.5
  TOP w0.203: R25554.2 225.32,94.35 v2(225.34,94.38) ; C20050.2 216.37,102.35 216.17,102.54 C20051.1 216.17,103.59 v2(216.45,103.87)
  TOP w0.381: U6509.11 222.04,98.18 222.59,98.73 222.74,98.73
  TOP w0.508: v2(216.45,103.87) F2.1 ; 222.74,98.73 223.46,98.73 C20042.1 223.48,99.42 v2(223.02,99.42) ; v2(216.37,101.11) C20050.2
  IN4 w0.508: v2(225.34,94.38) 225.98,95.02 225.98,97.94 225.53,98.39 224.39,98.39 223.36,99.42 v2(223.02,99.42) 221.19,99.42 219.5,101.11 v2(216.37,101.11)
+SENSOR_POWER: length 246.9
  TOP w0.079: 155.49,212.62 155.49,212.75 155.37,212.88 155.37,213.39 U6516.C2
  TOP w0.203: v2(132.64,217.2) 132.64,217.18 132.61,217.15 R25634.1 132.61,215.06 132.81,214.86 Q6540.2 ; Q6567.5 Q6567.2 151.94,215.8 152.57,216.43 v2(152.57,216.56) ; v2(143.17,216.3) 142.64,216.84 C20133.1 142.23,216.38 142.15,216.29 U6515.7 ; R25635.1 v2(158.41,215.27) ; U6515.11 139.63,215.41 C20134.2 ; v2(156,211.6) 156,211.73 155.49,212.24 155.49,212.62 ; v2(141.73,212.87) 141.81,212.95 C96907.1 141.81,213.73 141.65,213.89 U6515.3 ; v2(141.97,207.43) 141.97,208.12 142.29,208.43 142.29,209.09 R25623.1 ; R68995.1 146.19,217.09 v2(146.1,217.19) ; v2(136.2,212.49) 136.29,212.58 136.29,213.67 136.03,213.93 R25625.1 ; R68994.1 v2(157.02,217.07)
  TOP w0.381: v2(119.71,196.31) 119.1,196.31 v2(116.02,199.39) v2(115.33,199.39)
  TOP w0.508: v2(144.7,210.08) 145.14,209.64 Q6637.2 ; R25625.1 R25622.2 137.97,216.18 138.59,215.55 C20134.2 139.49,216.18 139.85,216.53 v2(139.85,217.18) ; v1(121.53,179.3) 121.53,179.55 120.8,180.29 118.26,180.29 117.77,179.8 v2(117.77,179.02)
  IN1 w0.508: v2(139.85,217.18) 139.57,217.18 138.97,216.58 133.25,216.58 132.64,217.19 v2(132.64,217.2)
  IN2 w0.508: v2(117.77,179.02) 115.66,176.9 109.6,176.9 109.24,177.26 107.31,177.26 107.11,177.06 v1(107.11,176.57)
  IN3 w0.381: v2(119.71,196.31) 119.49,196.09 119.49,193.24 120.29,192.44 120.29,189.03 121.58,187.73 121.58,179.37 121.53,179.32 v1(121.53,179.3) ; v2(51.61,200.43) 51.86,200.17 54.15,200.17 55.93,201.95 55.93,203.48 56.31,203.86 57.07,203.86 57.45,203.48 57.45,198.14 58.08,197.51 60.75,197.51 62.02,198.78 66.97,198.78 67.74,199.54 67.74,200.3 68.37,200.94 77.13,200.94 78.79,202.59 80.44,202.59 82.09,200.94 91.49,200.94 93.26,199.16 93.26,196.11 95.3,194.08 103.17,194.08 104.64,195.55 112.36,195.55 112.57,195.35 113.84,195.35 114.35,195.86 114.35,196.36 115.33,197.35 v2(115.33,199.39)
  IN3 w0.508: v2(144.7,210.08) 144.63,210.08 v2(141.97,207.43) 139.35,207.43 138.86,207.92 138.86,209.83 138.35,210.33 137.97,210.33 136.2,212.1 v2(136.2,212.49)
  IN4 w0.381: v2(115.33,199.39) 115.23,199.49 115.23,205.89 114.85,206.27 114.85,207.29 115.18,207.62 117.22,207.62 118.28,208.68 118.28,209.32 120.06,211.1 120.06,211.73 121.41,213.08 125.64,213.08 129.02,216.46 132.1,216.46 132.64,216.99 v2(132.64,217.2)
  BOTTOM w0.203: R25633.1 155.34,214.62 155.75,215.03 156.13,215.03 156.36,215.27 v2(158.41,215.27) ; R25629.1 106.32,174.55 106.34,174.52 ; R68993.1 150.79,211.7 150.92,211.83 v2(150.92,211.86) ; Q6631.2 147.87,209.4 148.08,209.2 149.15,209.2 149.4,209.45 v2(149.4,210.33) ; Q6632.2 103.61,179.54 104.57,178.58 104.57,176.81 105.05,176.33 R25631.1 105.05,175.31 105.84,174.52 ; v2(152.57,216.56) 152.47,216.46 R25636.1 ; Q6631.5 147.87,212.24 148,212.37 v2(148.31,212.37) 148.4,212.27 R68992.1
  BOTTOM w0.381: Q6633.2 107.11,177.24 v1(107.11,176.57) 107.11,176.42 107.14,176.39 107.14,174.91 106.75,174.52 105.84,174.52 ; Q6653.2 52.18,194.77 52.62,195.22 52.62,196.37 52.5,196.49 CN67.6 52.5,199.54 v2(51.61,200.43) ; D13093.1 156.64,213.44 157.32,214.12 157.32,214.27 157.58,214.53 158.03,214.53 158.41,214.91 v2(158.41,215.27) 158.41,215.8 157.4,216.81 157.27,216.81 v2(157.02,217.07)
  BOTTOM w0.508: v2(149.4,210.33) 154.73,210.33 v2(156,211.6)
+SMDDR_VREF_DIMM: length 3.6
  TOP w0.508: R242.2 44.66,122.47 v2(44.27,122.86) 44.27,123.33 R67574.1
  BOTTOM w0.254: v2(46.49,129.19) 46.44,129.19 46.08,128.82 JDIM1.164
+SMDDR_VREF_DQ1_M1: length 15.8
  TOP w0.508: v2(43.79,125.99) 44.1,125.99 44.31,126.2 R67575.1
  IN3 w0.508: v2(55.45,128.77) 55.45,128.45 53.73,126.74 51.65,126.74 51.46,126.93 45.29,126.93 44.35,125.99 v2(43.79,125.99)
  BOTTOM w0.254: JDIM02.164 55.5,128.82 v2(55.45,128.77)
  vias: v2(56.15,128.62)
+TS_PWR:
  vias: v2(70.96,192.07) v2(71.01,191.23) v2(71.62,192.07)
+USBPWR0:
  vias: v2(18.97,89.53)
+USBPWR1:
  vias: v2(17.42,110.31) v2(17.42,109.65) v2(18.08,110.31) v2(18.08,109.65) v2(21.76,94.51) v2(27.48,104.44) v2(27.48,103.78) v2(28.19,104.44) v2(28.19,103.78) v3(22.52,95.78) v3(22.52,95.02) v3(23.29,95.78) v3(23.29,95.02)
+USBPWRD2:
  vias: v2(211.72,111.3) v2(211.72,110.64) v2(212.65,111.29) v2(212.66,110.63) v2(219.23,105.07) v2(219.23,104.41) v2(219.23,103.75) v2(219.92,105.07) v2(219.92,104.41) v2(219.92,103.75) v2(220.59,103.83) v2(227.12,124.48) v2(227.12,123.72) v2(227.88,124.48) v2(227.88,123.72)
+VAC_IN: length 91.8
  TOP w0.254: PR8001.1 54.78,200.28 56.09,201.58 56.97,201.58
  TOP w0.508: PD8006.2 30.29,114.02 29.78,114.02 29.19,114.6 PD8002.2 v2(29.19,116.38)
  IN3 w0.508: v2(41.83,188.62) 41.57,188.36 41.57,185.32 40.94,184.68 40.94,183.19 39.38,181.64 37.97,181.64 32.16,175.82 v2(28.94,175.82)
  IN4 w0.508: v2(29.19,116.38) 27.68,117.89 27.68,121.74 26.72,122.7 26.72,127.66 25.45,128.93 25.45,133.75 25.19,134.01 25.19,148.23 26.46,149.5 26.46,150.56 25.44,151.58 25.44,153.26 25.82,153.64 25.82,161.81 25.93,161.92 25.93,163.95 27.22,165.25 27.22,166.03 28.94,167.75 v2(28.94,175.82)
  vias: v2(12.8,196.65) v2(13.19,199.25) v2(13.32,198.57) v2(13.38,197.87) v2(13.37,197.16) v2(14,198.98) v2(58.11,199.23) v2(58.11,198.5) v2(58.82,199.26) v2(58.82,198.55) v2(59.53,199.26) v2(59.51,198.55) v2(59.56,196.52) v2(60.22,199.26) v2(60.22,198.57)
+VCONN_5V_3: length 2
  BOTTOM w0.305: U6555.8 20.57,48.81 v2(20.85,48.54)
  BOTTOM w0.508: v2(21.41,48.16) 21.23,48.16 v2(20.85,48.54)
  vias: v1(23.16,45.39) v1(23.77,45.39)
+VGPU_CORE: length 69
  TOP w0.356: v1(129.54,189.62) 129.95,190.02 C407.2 ; v1(131.34,189.61) 131.2,189.74 C369.2 ; C372.2 133.76,189.74 v1(133.49,189.48)
  TOP w0.381: v3(112.55,201.21) 112.55,200.29 C422.2 112.99,199.66 113.96,198.69 115.76,198.69 v2(117.01,197.44) ; v1(127.22,189.64) 127.27,189.6 C406.2
  BOTTOM w0.254: v1(127.22,189.64) 127.24,189.64 127.28,189.68 127.3,189.68 127.76,190.15 U8.L11 128.02,190.23 128.41,190.62 v1(128.46,190.62) 128.46,190.67 128.94,191.15 U8.M12 129.02,191.33 v1(129.46,191.77) 129.84,192.15 U8.N13 130.02,192.15 130.52,192.65 v1(130.57,192.65) 130.57,192.69 U8.P14 131.02,193.15 131.54,193.67 v1(131.77,193.67) 131.77,193.89 132.02,194.15 U8.R15 132.35,194.48 v1(132.35,194.69) 132.64,194.69 133.02,195.07 U8.T16 ; U8.V10 127.17,197.15 v1(127.5,197.48) ; U8.M16 132.88,191.15 132.58,190.84 v1(132.58,190.77)
  BOTTOM w0.305: U8.P10 127.02,193.44 v1(127.22,193.65) 127.72,194.15 U8.R11 128.02,194.25 v1(128.42,194.65) 128.52,194.65 U8.T12 129.13,195.15 129.43,195.45 v1(129.43,195.7) 129.68,195.7 130.02,196.04 U8.U13 v1(130.52,196.64) U8.V14 131.02,197.16 v1(130.57,197.61) ; v1(126.03,195.22) 126.1,195.15 U8.T10 127.29,195.41 v1(127.29,195.68) 127.75,196.15 U8.U11 v1(128.52,196.65) U8.V12 ; U8.K16 133.16,189.15 v1(133.49,189.48) 133.49,189.62 U8.L17 v1(134.63,190.76) U8.M18 ; U8.K12 129.05,189.15 129.52,189.62 v1(129.54,189.62) 129.54,189.65 130.02,190.12 U8.L13 130.58,190.7 v1(130.58,190.84) 130.88,191.15 U8.M14 131.51,191.64 v1(131.77,191.64) 131.77,191.89 132.02,192.15 U8.N15 132.48,192.61 v1(132.48,192.65) 132.53,192.65 133.02,193.15 U8.P16 133.35,193.48 v1(133.55,193.48) 133.55,193.68 U8.R17 134.26,194.39 134.26,194.39 134.51,194.64 v1(134.81,194.64) 134.81,194.94 U8.T18 ; v1(132.58,190.77) 132.58,190.71 U8.L15 131.88,190.15 v1(131.34,189.61) 131.02,189.29 U8.K14 ; v1(134.38,188.72) 134.81,189.15 U8.K18 ; U8.M10 127.02,191.44 v1(127.25,191.66) 127.73,192.15 U8.N11 128.02,192.15 128.47,192.6 v1(128.47,192.65) 128.52,192.65 129.02,193.15 U8.P12 129.47,193.59 v1(129.48,193.59) 129.48,193.61 U8.R13 130.42,194.55 v1(130.62,194.55) 130.62,194.75 U8.T14 131.26,195.15 v1(131.77,195.65) 131.77,195.89 U8.U15 v1(132.59,196.72) U8.V16 133.02,197.77 v1(133.11,197.86) ; v1(133.54,195.4) 134.02,195.87 U8.U17 ; U8.V18 135.02,197.17 134.61,197.58 v1(134.36,197.58) ; U8.M16 133.08,191.15 v1(133.6,191.66) 133.65,191.66 134.02,192.04 U8.N17 134.53,192.65 v1(134.81,192.65) 134.81,192.94 U8.P18
  BOTTOM w0.356: v1(127.22,189.64) 127.02,189.44 U8.K10
  BOTTOM w0.381: v2(117.01,197.44) 115.99,197.44 115.57,197.02 115.57,195.41 116.12,194.86 116.12,194.19 115.87,193.94 115.87,192.81 116.76,191.92 PR9026.1
  vias: v2(113.81,206.65) v2(126.03,194.51) v2(130.93,206.69) v2(131.22,205.48) v2(131.22,204.76) v2(131.6,206.69) v2(131.98,205.48) v2(131.98,204.76) v2(132.26,206.69) v2(132.77,205.48) v2(132.77,204.76) v2(133.33,215.33) v2(133.52,205.48) v2(133.52,204.76) v2(134,215.33) v2(134.28,205.48) v2(134.26,204.77) v2(134.74,217.2) v2(134.66,215.34) v2(134.98,205.48) v2(134.95,204.77) v2(135.32,215.34) v2(135.4,217.2) v2(135.67,209.38) v2(135.68,208.19) v2(135.66,206.85) v2(136.06,217.2) v2(136.72,217.2) v2(136.98,213.15) v2(136.98,212.49) v2(137.39,217.2) v2(137.64,213.15) v2(137.64,212.49) v2(138.05,217.2) v2(138.35,212.49) v2(138.71,217.2) v2(139.11,213.15) v2(139.11,212.49) v2(139.73,208.23) v2(139.87,212.49) v2(140.13,208.86) v3(110.08,212.32) v3(110.84,212.34) v3(110.84,211.58) v3(110.84,210.82) v3(110.87,216.15) v3(110.87,215.39) v3(110.87,213.1) v3(110.87,208.53) v3(110.87,207.77) v3(110.87,207.01) v3(110.87,206.24) v3(111.26,216.84) v3(111.63,216.15) v3(111.63,215.39) v3(111.63,214.63) v3(111.63,213.86) v3(111.63,213.1) v3(111.6,212.34) v3(111.6,211.58) v3(111.6,210.82) v3(111.6,210.05) v3(111.63,209.29) v3(111.63,208.53) v3(111.63,207.77) v3(111.63,207.01) v3(111.63,206.24) v3(111.78,201.98) v3(111.76,201.21) v3(111.94,205.51) v3(112.39,216.15) v3(112.39,215.39) v3(112.39,214.63) v3(112.36,210.82) v3(112.36,210.05) v3(112.39,209.29) v3(112.39,208.53) v3(112.39,207.77) v3(112.39,207.01) v3(112.39,206.24) v3(112.55,201.98) v3(113.15,209.29) v3(113.15,208.53) v3(113.18,205.89) v3(114.44,205.63) v3(114.41,204.84)
