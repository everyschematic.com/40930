# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Nets (continued)
N46213996: R593.2 U33.18
N46213998: R592.2 U33.29
N46214095: D22.2 R600.1
N47271970: R363.2 R364.1 R366.2 R367.2 R368.2
N47707560: PC5024.2 PR5024.1 PU5000.1
N47707814: PC5021.1 PC5022.1 PC5023.1 PJ5000.2 PL5001.2 PR5022.2
N47707867: PR5022.1 PR5026.1
N47707873: PC5020.1 PR5020.2 PU5000.4(VIN)
N47707884: PR5023.2 PR5024.2 PR5025.1
N47707886: PR5026.2 PR5027.1 PU5000.6
N47707900: PR5021.1 PU5000.5
N47707998: PC5008.2 PR5008.1
N47708004: PC5014.1 PR5009.2 PU5001.4
N47708130: PR5014.1 PU5001.3
N47708170: PC5018.1 PR5010.2
N48587681: R329.2 U8.N6
N48650493: Q15.2 R382.1 R384.2
N54133206: R68202.1 U6537.36
N64506943: R68435.2 Y5.2
N69856481: TP13427.1 U6539.DJ6
N69856484: TP13428.1 U6539.DK8
N159797420: JDIM02.162 T1.1
N159810220: JDIM02.165 T2.1
N241366410: T3.1 U6537.37
N302640860: TP9066.1 U6516.E2
N302641560: TP9069.1 U6516.E3
N3026424317: TP9074.1 U6516.D3

Pads without a net: CN1 3 4; CN4 3 5; CN11 2 7 11 12; CN13 3; CN14 1 2 3 4; CN16 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; CN17 16 58 60 62 66 68 70; CN21 4; CN29 10 13 38; CN37 13 14; CN48 5; CN49 5 15 17 28; CN50 3; CN52 3; CN55 15 16; CN62 13; CN66 5; CN67 5; HOLE33 1; HOLE34 1; JDIM1 162 165; NOREF#2 1; NOREF#4 1; NOREF#6 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; PQ7000 2; PQ7001 2; PQ9000 2; PQ9001 2; PU3004 5; PU9004 7; Q6597 1 2 6; Q6598 3 4 5; U2 6; U8 A3 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C2 C3 C7 C14 D4 D10 D11 D23 E6 E7 E9 F4 F5 F6 F7 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 W5 W22 Y3 Y4; U14 9; U20 14 15 16 23 24; U33 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; U67 27 31; U6509 20 21 22 24 25 27 28; U6515 10; U6517 6; U6537 2 4 9 10 12 25 26; U6539 A3 A15 A18 A20 A48 A52 AB2 AC1 AC2 AC41 AC42 AC45 AC47 AC50 AC53 AD1 AD2 AD5 AD7 AF5 AF7 AH5 AH7 AH9 AK9 AP9 AT1 AT2 AU1 AU2 B3 B15 B18 B20 B22 B53 BB5 BB7 BH5 BH7 BJ1 BJ2 BK1 BK2 BK5 BK7 BL53 BM5 BM7 BM12 BN10 BN51 BN53 BP42 BP44 BP45 BP47 BP52 BP53 BT7 BT8 BT45 BT47 BW1 BW2 BW4 BW5 C16 C53 CA51 CA53 CB1 CB2 CB39 CD41 CD42 CD45 CD47 CE1 CE2 CE50 CE53 CF39 CM39 CW12 CY52 CY53 D15 D16 D18 D20 D22 DA50 DB44 DB45 DC49 DD44 DD47 DF13 DF21 DF43 DF49 DF50 DF52 DG17 DG19 DJ8 DN29 DN33 DR7 DR15 DR18 DR21 DR27 DR30 DT25 DT35 DT38 DU14 DU31 DV6 DV24 DV31 DV38 DW6 DW15 DW21 DW27 DW47 DW49 E3 E15 E18 E22 E53 F53 G14 G16 G18 G20 H14 H16 H18 H20 J53 K51 K53 L14 L16 L18 L20 M52 M53 N14 N16 N18 N20 N42 N44 N45 N47 R45 R47 T11 T12 T35 U35 V35 W34 W51 W53 Y9 Y11; U6544 12 13 15 16; U6549 A1 A2 A12 L3; U6553 18; U6556 5 6; VRAM1 A5 A10 U5 U10; VRAM2 A5 A10 U5 U10

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 2661 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4905 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 249 vias
v4: diameter 0.305, hole 0.152, TOP to BOTTOM, 26 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 53 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_S:
  vias: v2(95.75,182.01) v2(96.42,182.02) v2(96.74,181.35)
1V8_MAIN_EN: length 119
  TOP w0.114: v1(109.22,185.32) 109.22,185.21 v2(110.08,184.35) 110.36,184.35 111.3,183.41 112.57,183.41 113.36,182.62 R403.1 114.7,182.62 114.9,182.83 115.53,182.83 115.73,183.03 R374.2 ; v2(90.16,186.32) 89.84,186 PR9072.1 ; PR9105.1 v2(159.86,211.43) 160.38,210.91 PQ9083.2
  IN1 w0.089: v2(159.86,211.43) 159.14,210.72 157.53,210.72 157.08,211.16 155.05,211.16 154.4,210.51 151.58,210.51 148.08,207.01 139.46,207.01 139.08,207.39 135.41,207.39 135.12,207.11 125.28,207.11 124.31,206.14 123.41,206.14 123.06,205.79 123.06,205.43 123.29,205.2 123.29,204.85 122.79,204.35 122.79,198.84 122.73,198.78 122.73,197.3 122.45,197.02 122.45,189.35 121.71,188.62 119.04,188.62 116.76,186.33 114.98,186.33 114.83,186.18 112.57,186.18 112.47,186.08 110.03,186.08 109.27,185.32 v1(109.22,185.32) 109.16,185.32 109.04,185.44 102.48,185.44 v1(101.9,186.03) 100.81,186.03 99.44,187.4 97.15,187.4 96.64,187.91 93.82,187.91 91.74,185.82 90.65,185.82 v2(90.16,186.32)
  IN4 w0.089: v1(101.9,186.03) 102.41,186.53 102.41,188.36 98.6,192.17 v1(97.96,192.17)
  BOTTOM w0.114: PD1.1 100.3,197.2 100.3,194.78 100.05,194.53 100.05,194.39 99.61,193.95 99.61,193.31 PR9284.2 98.59,192.8 v1(97.96,192.17)
1V8_MAIN_EN_N17: length 15.3
  TOP w0.102: v1(125.7,186.08) 126.08,185.69 126.08,184.25 125.31,183.47 123.91,183.47
  TOP w0.114: R374.1 116.78,182.81 v2(116.78,182.18) 117.99,182.18 119.05,181.12 120.86,181.12 123.22,183.47 123.91,183.47
  BOTTOM w0.102: v1(125.7,186.08) 126.49,186.08 U8.F9
8813VID: length 2.3
  TOP w0.203: PU9000.5 99.67,197.25 99.03,197.25 98.99,197.29 PR9017.2 98.3,197.29 98.19,197.41 PR9015.2
8813VOUT1: length 4.6
  TOP w0.203: PC9027.1 101.43,191.64 100.83,191.64 v2(100.71,191.51) 100.67,191.48 PR9028.1
  TOP w0.254: PC9027.1 101.56,191.78 PC9028.1 100.73,192.66 100.78,192.71 100.78,193.72 PU9000.11
8813VREF: length 11.3
  TOP w0.114: PR9033.2 103.91,192.28 v2(103.91,192)
  TOP w0.254: PU9000.8 99.7,194.76 98.88,194.76 v2(98.67,194.92) 97.98,194.92 97.55,194.48 PC9023.1 ; PR9033.2 103.36,192.38 103.22,192.38 v2(103.07,192.22)
  IN4 w0.254: v2(98.67,194.92) 98.75,194.76 101.47,192.05 102.41,192.05 102.59,192.22 v2(103.07,192.22)
  BOTTOM w0.254: PR9021.1 98.28,194.53 v2(98.67,194.92)
+1.0V_PWRGD_G1: length 8.1
  TOP w0.114: v2(87.04,108.54) Q6589.2 88.76,108.54 89.2,108.1 89.2,106.93 89.56,106.58 C96719.1 R68494.1 R68487.2 87.78,105.53 87.55,105.76 87.2,105.76 86.96,105.53 R68488.2
+1.0V_PWRGD_G2: length 3.6
  TOP w0.114: Q6588.2 90.73,107.58 90.72,107.59 Q6589.3 89.97,107.1 90,107.08 90,107.07 v2(90.44,106.63) 90.44,105.68 R68489.2
+1.2V:
  vias: v2(26.56,134.13) v2(27.22,141.37) v2(27.22,140.61) v2(27.22,134.13) v2(28.06,139.47)
+1.2V_HDMI: length 33.8
  TOP w0.178: C96569.2 30.62,128.14 29.64,127.15 U6537.46 ; U6537.11 23.9,129.58 23.79,129.69 ; U6537.18 21.07,125.95 20.21,125.09 C96557.2 ; U6537.30 25.5,121.95 v2(25.24,121.69) 24.84,121.29 C96559.2 ; U6537.15 21.25,127.15 21.13,127.28 ; v2(29.64,125.95) U6537.43
  TOP w0.203: C96569.2 C96570.2 32.42,128.14 C96571.2 ; 23.79,129.69 23.51,129.97 C96567.2 22.68,129.97 v2(22.65,129.94) ; C96557.2 C96556.2 v2(17.7,125.09) ; C96559.2 24.84,120.57 25.31,120.1 C96558.2
  TOP w0.381: C96558.2 24.68,119.78 v2(24.43,120.04)
  TOP w0.508: v2(20.11,128.17) 19.49,128.17 C96555.2 19.74,127.4 21,127.4 21.13,127.28 ; v2(34.21,128.17) 33.5,128.17 C96572.1 C96571.2
  BOTTOM w0.508: v2(24.43,120.04) 24.43,119.66 23.92,119.15 20.37,119.15 19.73,119.78 19.73,123.21 ; 17.7,123.59 v2(16.68,123.59)
  vias: v2(26.21,131.7) v2(26.21,130.98)
+1.2VSUS: length 90.4
  TOP w0.203: v2(55.84,125.43) 55.64,125.23 C256.1 ; C263.1 43.93,144.58 43.81,144.45 v2(43.81,144.2) ; 85.77,127.02 85.77,125.52 86.58,124.71 86.58,122.91 87.04,122.45 88.18,122.45 89.66,120.98 89.66,119.71 90.47,118.89 R68252.1 ; C254.1 46.43,131.37 v2(46.53,131.47)
  BOTTOM w0.079: U6539.AM40 106.56,151.32 ; U6539.AM40 106.27,151.6 ; U6539.AM40 106.27,151.04 ; 106.27,151.95 U6539.AK40 ; U6539.AK40 106.56,152.24 ; U6539.AK40 106.27,152.52 ; 106.27,150.69 U6539.AP40 ; U6539.AP40 106.56,150.41 ; U6539.AP40 106.27,150.12
  BOTTOM w0.102: 106.27,154.67 U6539.AD40 ; U6539.AD40 106.58,154.98 ; U6539.AD40 106.27,155.29 ; 106.27,152.84 U6539.AH40 ; U6539.AH40 106.58,153.15 ; U6539.AH40 106.27,153.46 ; 106.74,154.22 U6539.AE39 ; U6539.AE39 106.43,154.52 ; U6539.AE39 106.74,154.83 ; U6539.AE39 107.04,154.52 ; U6539.AJ39 107.04,152.69 ; U6539.AJ39 106.74,153 ; U6539.AJ39 106.74,152.39 ; U6539.AJ39 106.43,152.69 ; U6539.AC39 107.04,155.44 ; U6539.AC39 106.74,155.13 ; U6539.AC39 106.43,155.44 ; U6539.AC39 106.74,155.74 ; 106.43,156.35 U6539.AA39 106.74,156.05 ; 106.27,149.8 U6539.AU40 106.58,149.49 ; U6539.AN39 107.04,150.86 ; U6539.AN39 106.74,151.17 ; U6539.AN39 106.43,150.86 ; U6539.AN39 106.74,150.56 ; 106.22,132.43 U6539.CR40 106.51,132.29 ; U6539.AF40 106.27,154.37 ; U6539.AF40 106.58,154.06 ; U6539.AF40 106.27,153.76 ; 106.27,133.63 U6539.CL40 ; U6539.CL40 106.58,133.93 ; U6539.CL40 106.27,134.24 ; 106.74,151.47 U6539.AL39 ; U6539.AL39 106.43,151.78 ; U6539.AL39 106.74,152.08 ; U6539.AL39 107.04,151.78 ; 106.74,149.64 U6539.AR39 ; U6539.AR39 106.74,150.25 ; U6539.AR39 107.04,149.95 ; U6539.AR39 106.43,149.95 ; 106.27,133.33 U6539.CN40 ; U6539.CN40 106.58,133.02 ; U6539.CN40 106.27,132.71 ; 106.27,136.99 U6539.CE40 ; U6539.CE40 106.58,136.68 ; U6539.CE40 106.27,136.37 ; U6539.CC40 106.58,137.6 ; U6539.CC40 106.27,137.9 ; U6539.CC40 106.27,137.29 ; U6539.AG39 106.74,153.91 ; U6539.AG39 106.74,153.3 ; U6539.AG39 106.43,153.61 ; U6539.AG39 107.04,153.61 ; U6539.AB40 106.27,155.59 ; U6539.AB40 106.58,155.9 ; U6539.AB40 106.27,156.2 ; 106.27,138.2 U6539.CA40 106.58,138.51 ; 106.27,135.46 U6539.CG40 ; U6539.CG40 106.27,136.07 ; U6539.CG40 106.58,135.77 ; 106.27,134.54 U6539.CJ40 ; U6539.CJ40 106.27,135.16 ; U6539.CJ40 106.58,134.85 ; 106.74,135 U6539.CH39 ; U6539.CH39 106.74,135.61 ; U6539.CH39 107.04,135.31 ; U6539.CH39 106.43,135.31
  BOTTOM w0.114: 65.35,120.07 JDIM02.199 ; 65.35,109.57 JDIM02.241
  BOTTOM w0.152: U6539.AT52 100.82,149.91 101.18,149.55 101.69,149.55 101.79,149.66 v1(101.79,149.66) ; v1(101.77,154.75) 101.5,155.02 U6539.AD51
  BOTTOM w0.2: U6539.E51 101.47,164.16 U6539.D50 101.57,164.18 v1(102.03,163.73) ; U6539.AD52 U6539.AD51
  BOTTOM w0.203: v1(101.82,152.47) U6539.AK51 U6539.AK52 ; U6539.AW52 U6539.AW51 101.89,148.57 v1(101.97,148.66) ; v1(101.98,158.85) U6539.T51 U6539.T52 ; U6539.BK51 U6539.BK52
  BOTTOM w0.254: JDIM1.75 54.49,153.07 v2(55.13,152.43) ; v1(101.14,163.22) 101.47,163.55 U6539.E51 ; v2(54.73,109.98) 54.32,109.57 JDIM1.241 ; JDIM1.124 44.02,140.82 v2(43.83,141.01) ; JDIM02.220 55.84,114.82 55.6,115.07 v2(55.6,115.22) ; JDIM02.75 66.55,153.07 v2(66.67,153.18) ; JDIM1.178 46.45,125.32 v2(46.5,125.27) ; v2(43.83,132.85) 43.85,132.82 JDIM1.148 ; U6539.F49 101.94,162.62 v1(101.9,162.58) ; v2(43.82,138.08) 44.07,137.82 JDIM1.136 ; v2(43.81,142.71) 44.2,142.32 JDIM1.118 ; JDIM1.130 43.98,139.32 v2(43.84,139.47) ; v2(55.84,158.5) 56.02,158.32 JDIM02.54 ; 65.35,109.57 66.8,109.57 67.32,110.1 v2(67.32,110.24) ; v1(103.64,133.01) 103.21,132.58 U6539.CP47 ; JDIM02.33 66.44,163.57 66.82,163.19 v2(66.82,162.56) ; v2(46.81,114.84) 46.8,114.82 JDIM1.220 ; v2(43.81,144.2) 44.18,143.82 JDIM1.112 ; JDIM1.199 v2(54.83,120.07) ; U6539.AW40 U6539.AU40 ; JDIM1.33 54.82,163.57 v2(55.16,163.23) ; v2(46.48,168.65) 46.31,168.82 JDIM1.12 ; JDIM02.178 55.95,125.32 v2(55.84,125.43) ; v2(43.83,135.98) 44.17,136.32 JDIM1.142 ; v2(55.12,169.32) 55.12,169.13 55.49,168.75 55.93,168.75 55.99,168.82 JDIM02.12 ; JDIM1.160 43.98,129.82 43.78,130.02 v2(43.78,130.1) ; 65.35,120.07 66.61,120.07 66.86,120.33 v2(66.86,120.39) ; v2(46.53,131.47) 46.38,131.32 JDIM1.154 ; JDIM1.54 v2(46.52,158.32) ; v1(101.89,143.47) U6539.BK51
  vias: v1(101.9,146.02) v1(101.86,139.65) v1(102.89,137.69) v1(107.22,155.69) v1(107.22,155.11) v1(107.22,154.52) v1(107.22,153.94) v1(107.22,153.36) v1(107.22,152.77) v1(107.22,152.19) v1(107.22,151.6) v1(107.22,151.02) v1(107.22,150.44) v1(107.22,149.85) v1(107.22,136.79) v1(107.22,136.2) v1(107.22,135.62) v1(107.23,134.21) v1(107.22,133.63) v2(30.02,140.74) v2(30.02,139.98) v2(54.63,143.63) v2(54.61,130.92) v2(54.67,134.69) v2(54.66,132.14) v2(54.66,128.85) v2(55.1,142.83) v2(55.1,140.89) v2(55.22,132.51) v2(55.34,134.69) v2(55.78,143.66) v2(55.76,142.83) v2(55.76,140.93) v2(55.76,138.89) v2(55.84,131.29) v2(57.01,134.72) v2(66.7,143.74) v2(66.67,142.82) v2(66.72,140.71) v2(66.72,139.7) v2(66.72,138.25) v2(66.7,136.29) v2(66.67,131.39) v2(66.67,129.54) v2(67.33,142.85) v2(67.35,131.42) v2(67.33,129.54) v2(67.41,143.74) v2(67.43,140.71) v2(67.45,138.27) v2(67.36,136.32) v2(67.48,139.7) v2(68.02,142.85) v2(68.12,143.71) v2(68.12,140.71) v2(68.14,139.7) v2(69.77,172.49) v2(79.12,178) v2(79.8,177.99) v2(80.46,177.99) v2(90.94,189.07) v2(91.61,189.07)
+1.2VSUS_TEMP:
  vias: v2(73.32,180.36) v2(87.68,175.54) v2(87.68,174.88) v3(71.57,181.45) v3(72.33,181.45) v3(73.1,181.45) v3(73.86,181.43) v3(73.96,179.35) v3(73.96,178.58) v3(74.72,179.35) v3(74.72,178.58)
+1.2VSUS_VIN: length 4.1
  TOP w0.203: PR5007.1 93.23,179 v1(93.39,178.84)
  BOTTOM w0.203: v1(93.39,178.84) 92.36,179.87 92.36,180.24 92.23,180.36 90.85,180.36
  vias: v2(82.24,179.24) v2(82.57,178.66) v2(82.98,179.24) v2(89.2,179.6)
+1.5V: length 30.8
  IN2 w0.508: v2(12.56,40.77) 15.91,40.77 16.56,41.42 25.45,41.42 27.82,39.06 29.71,39.06 30.65,38.11 30.65,37.23 31.67,36.22 31.67,35.46 30.91,34.69 30.91,34.19 31.67,33.42 31.67,29.61 v2(31.29,29.23)
  BOTTOM w0.203: R69076.2 31.13,28.7 31.29,28.85 v2(31.29,29.23)
  vias: v2(12.11,40.28)
+1.05V_EXT: length 12
  TOP w0.254: R68499.1 123.52,129.56 123.36,129.71 123.36,130.91 122.85,131.42 119.76,131.42 119.25,130.91 117.58,130.91 v1(116.3,129.63)
  BOTTOM w0.2: v1(116.3,129.63) 116.38,129.63 U6539.DA17 U6539.DA15
+1.05V_LAN: length 30.1
  TOP w0.203: R67599.2 22.4,158.91 R67598.2 22.41,158.15 v2(22.4,158.14) ; U6521.8 24.17,166.61 25.37,167.82 25.37,168.22 25.52,168.37 25.78,168.37 26.11,168.71 C631.1 25.65,168.93 v1(25.59,168.87) ; v2(19.49,161.93) U6521.40 ; v2(20.69,161.92) U6521.43 ; v2(25.37,170.43) 25.73,170.43 25.98,170.18 C632.1 25.88,169.95 25.22,169.95 24.53,169.26 24.53,168.19 24.15,167.81 U6521.11 ; v2(16.66,172.47) 17.22,173.03 C634.1 18.33,170.96 19.09,170.21 U6521.22 ; v2(22.27,173.84) 22.12,173.69 C633.1 22.12,172.39 22.27,172.23 22.27,170.92 21.49,170.14 U6521.16
  BOTTOM w0.508: 20.75,162.62 21.9,162.62 22.4,162.12 v2(22.4,158.14)
  vias: v2(16.91,162.33) v2(17.52,161.97) v2(17.6,162.66)
+1.05V_LAN_REGOUT: length 1
  TOP w0.203: 24.52,166.14 24.45,166.21 U6521.7
  vias: v2(11.22,161.19) v2(11.86,161.54) v2(11.86,160.8) v2(25.8,166.82) v2(26.46,167.51) v2(26.46,166.85) v2(26.46,166.19)
+1.8V: length 574.4
  TOP w0.203: R68488.1 86.74,104.39 v1(86.84,104.29)
  TOP w0.254: v1(141.9,107.59) 141.57,107.59 140.48,106.5 139.93,106.5 139.72,106.29 139.72,104.93 139.46,104.67 139.46,102.99 137.54,101.06 137.54,99.26 137.97,98.83 138.35,98.83 138.48,98.7 Q6651.5
  TOP w0.508: v2(35.86,126.39) 36.04,126.21 37.33,126.21 38.15,127.03 PQ9.1 38.71,126.57 38.26,126.12 PR9227.1 ; v2(15.29,42.06) 15.29,41.17 14.91,40.79 13.63,40.79 v2(12.23,39.39) ; R68987.2 154.13,209.86 154.43,210.16 v2(154.43,211.6)
  IN1 w0.508: v2(30.17,28.06) 28.82,28.06 28.24,28.64 28.24,30.12 28.62,30.5 28.62,33.68 29.89,34.95 v2(29.89,35.71) 29.89,38.25 27.6,40.54 27.6,42.06 26.33,43.33 22.32,43.33 20.67,41.68 15.67,41.68 v2(15.29,42.06) ; v2(25.55,172.46) 26.36,173.27 30.82,173.27 32.71,175.16 34.46,175.16 37.82,178.51 40.48,178.51 43.3,181.33 43.3,185.73 44.32,186.75 50.51,186.75 54.12,190.36 56.15,190.36 58.51,192.72 63.33,192.72 66,195.39 71.13,195.39 71.93,194.59 76.88,194.59 78.68,192.79 78.68,191.43 80.6,189.51 87.68,189.51 89.07,190.9 93.64,190.9 95.6,192.86 98.8,192.86 100.29,191.37 101.18,191.37 102.38,190.17 106.75,190.17 107.51,190.93 110.59,190.93 111.63,189.89 v2(112.11,189.89) 112.42,190.19 114.4,190.19 115.36,191.16 117.65,191.16 119.81,193.32 119.81,195.48 120.57,196.24 120.57,199.41 121.05,199.89 121.05,206.17 121.97,207.08 121.97,208.45 122.78,209.27 124.43,209.27 124.76,208.94 127.43,208.94 129.15,210.66 138.91,210.66 139.47,210.11 140.91,210.11 142.08,211.27 142.87,211.27 143.58,210.56 144.17,210.56 144.29,210.69 148.36,210.69 148.89,211.22 154.05,211.22 v2(154.43,211.6)
  IN2 w0.254: 78.3,103.04 78.66,103.4 85.95,103.4 v1(86.84,104.29)
  IN2 w0.305: v2(135.96,110) 133.04,112.93 131.11,112.93 130.35,112.16 129.59,112.16 127.43,110 118.54,110 118.36,110.18 111.78,110.18 111.6,110 108.25,110 107.11,108.86 101.9,108.86 101.46,108.42 100.06,108.42 99.49,107.85 94.15,107.85 93.21,108.78 92.3,108.78 91.99,108.48 84.63,108.48 83.61,109.5 77.69,109.5 75.74,107.54 75.74,103.17 75.86,103.04
  IN2 w0.508: 78.3,103.04 72.54,103.04 69.9,100.4 69.9,98.27 68.12,96.49 46.4,96.49 45.69,97.2 37.99,97.2 36.01,99.18 36.01,107.31 35.35,107.97 29.89,107.97 28.49,106.58 v3(26.59,106.58)
  IN3 w0.305: v2(135.96,110) 136.82,110 138.09,108.73 140.76,108.73 v1(141.9,107.59)
  IN4 w0.381: v1(112.36,180.44) 112.64,180.44 114.27,182.06 114.27,185.17 114.03,185.4 114.03,189.13 113.28,189.89 v2(112.11,189.89)
  IN4 w0.508: v2(15.29,42.06) 16.91,43.68 18.82,43.68 18.97,43.84 18.97,45.11 19.98,46.12 19.98,52.73 21,53.74 21,57.17 20.05,58.12 20.05,58.63 19.1,59.59 19.1,60.86 18.26,61.69 18.26,67.54 17.67,68.12 17.67,68.45 16.3,69.82 16.3,71.93 19.1,74.72 19.1,77.87 19.86,78.64 19.86,85.24 19.98,85.37 19.98,88.36 21.03,89.4 21.03,101.27 21.95,102.19 21.95,102.96 22.42,103.43 24.07,103.43 26.59,105.94 v3(26.59,106.58) 26.59,110.26 25.57,111.27 25.57,111.78 24.81,112.54 24.81,118.01 23.79,119.02 20.75,119.02 19.76,120.01 19.76,122.48 20.75,123.47 20.75,125.75 21.83,126.83 v3(21.83,131.72) 21.25,132.29 21.25,134.52 23.41,136.67 23.41,139.33 22.65,140.09 22.65,144.8 21.46,145.99 21.46,158.17 22.73,159.43 22.73,162.49 23.77,163.54 23.77,169.29 24.56,170.08 24.56,170.93 25.55,171.92 v2(25.55,172.46)
  BOTTOM w0.254: R69078.1 112.06,186.54 111.65,186.94 111.65,187.85 112.11,188.31 v2(112.11,189.89)
  BOTTOM w0.381: QG15.2 111.95,178.96 112.36,179.37 v1(112.36,180.44)
  BOTTOM w0.508: R68839.1 28.75,40.15 30.34,38.57 30.34,36.15 v2(29.89,35.71) ; R69075.1 v2(12.23,39.39) ; v3(21.83,131.72) 21.83,133.56 22.91,134.64 23.92,134.64 24.81,135.53 29.13,135.53 30.14,136.55 33.07,136.55 35.53,134.09 35.53,128.34 35.1,127.91 35.1,126.77 35.48,126.39 v2(35.86,126.39)
+1.8V_DEEP_SUS: length 164
  TOP w0.203: R68409.1 129.74,127.78 R68379.2 129.51,126.9 129.1,126.49 R68430.1 128.47,126.49 128.41,126.54 R68428.1 126.96,126.54 v1(126.75,126.34) ; v2(117.77,111.02) 117.01,111.78 117.01,114.58 116.89,114.7 R68505.2 ; R68774.2 109.85,113.72 v1(109.95,113.81) ; R68772.2 v1(108.38,113.18) ; v1(107.44,130.58) 107.44,131.01 108.38,131.95 108.38,132.36 108.56,132.54 C96724.2 ; R68389.1 118.41,112.54 118.8,112.15 ; R68510.1 R68509.1 101.21,108.28 v1(101.77,107.72)
  TOP w0.254: U36.5 185.7,116.88 186.01,116.57 187.41,116.57 v2(187.62,116.35) 188.24,116.97 U35.5
  TOP w0.305: v2(117.77,111.02) 117.44,110.69 117.44,109.47 117.04,109.06 115.03,109.06 114.69,109.41 v1(114.69,109.62)
  TOP w0.508: v2(185.97,105.18) 186.48,105.69 186.48,106.83 187.37,107.72 190.83,107.72 191.38,108.28 191.38,112.09 190.67,112.8 v2(190.67,114.32) ; v1(119.3,119.1) 119.43,118.96 R68497.2 119.43,117.49 120.19,116.74 120.19,114.96 120.31,114.83 120.31,113.84 119.83,113.36 119.81,113.36 v1(119.81,113.35) 119.81,113.15 118.41,111.76 118.41,111.66 v2(117.77,111.02)
  IN1 w0.203: v1(109.95,113.81) 109.01,113.81 v1(108.38,113.18)
  IN1 w0.508: v2(185.97,105.18) 183.14,102.34 175.48,102.34 172.72,105.1 168.14,105.1 167.48,105.76 164.51,105.76 163.16,107.11 154.86,107.11 154.73,107.24 151.99,107.24 151.3,107.92 143.99,107.92 143.63,108.28 142.84,108.28 142.54,107.97 v2(142.54,107.72)
  IN2 w0.203: v1(107.23,113.18) v1(108.38,113.18)
  IN2 w0.305: v1(101.77,107.72) 102.36,108.3 103.86,108.3 104.49,107.67 105.71,107.67 106.27,108.23 v1(107.01,108.23) 107.36,108.23 108.58,109.45 111.88,109.45 112.06,109.62 v1(114.69,109.62)
  IN3 w0.508: v2(187.62,116.35) 188.51,115.47 189.4,115.47 190.55,114.32 v2(190.67,114.32)
  IN4 w0.508: v2(142.54,107.72) 142.54,107.85 142.16,108.23 141.47,108.23 141.17,107.92 137.13,107.92 135.3,109.75 135.3,110.89 133.4,112.8 133.4,113.94 130.73,116.61 130.73,117.29 v2(127.55,120.47)
  BOTTOM w0.203: R68391.2 117.52,112.93 117.77,112.67 119.55,112.67 119.81,112.93 v1(119.81,113.35) ; 106.39,110.02 106.95,110.02 107.15,109.82 107.15,109.82 107.29,109.67 107.3,109.67 107.39,109.58 R68794.2 ; R68778.2 v1(107.23,113.18) 107.09,113.18 106.63,112.72 106.63,112.44 106.34,112.15 106.34,110.51 106.09,110.26 106.09,109.14 v1(107.01,108.23) 107.34,108.56 R68392.1 ; R68776.2 108.12,112.92 v1(108.38,113.18) 108.15,113.41 R68859.2
  BOTTOM w0.254: U6539.CY18 115.89,130.12 115.66,130.35 v1(115.6,130.35) 115.47,130.35 U6539.CY20 114.97,129.94 v1(114.65,129.61) 114.85,129.45 U6539.DA20 U6539.DA18 ; U6539.DC18 U6539.DC20 114.85,128.8 v1(114.65,128.96) ; v1(112.17,128.31) U6539.DC26 ; v1(107.44,130.58) 107.28,130.73 U6539.CV39 ; v1(112.99,129.58) 112.97,129.59 112.9,129.53 U6539.DA26 ; U6539.DA22 v1(113.82,129.61) ; U6539.DC22 v1(113.82,128.96) ; v1(114.65,128.31) 114.85,128.15 U6539.DD20 ; U6539.DD22 v1(113.82,128.31) ; v1(112.99,130.26) U6539.CY26 ; U6539.DV22 114.17,120.88 113.96,120.67 v1(113.94,120.67) ; v1(113.82,130.26) U6539.CY24 ; U6539.DA24 113.35,129.25 v1(112.99,128.96) ; U6539.DC24 v1(113,128.31)
  vias: v2(126.79,120.47) v2(126.79,119.81)
+1.8V_S5: length 300.5
  TOP w0.254: v2(146.58,208.68) 146.58,208.33 146.98,207.92 v2(150.03,207.92) 150.16,207.79 R68988.1 ; R25317.1 147.11,107 147.24,107.12 v2(147.24,107.31) ; v1(92.54,182.39) 92.54,182.05 92.36,181.87 91.08,181.87 PC9054.1
  IN1 w0.254: v2(146.58,208.68) 146.58,208.53 146.1,208.05 144.7,208.05 144.19,208.56 142.41,208.56 141.9,208.05 140.76,208.05 140.38,207.67 139.57,207.67 138.43,208.81 133.01,208.81 131.74,207.54 125.11,207.54 124.22,206.65 123.31,206.65 122.35,205.69 122.35,199.03 122.02,198.7 122.02,189.68 121.46,189.13 118.94,189.13 116.91,187.09 115.79,187.09 115.62,187.27 114.9,187.27 114.24,186.61 112.39,186.61 112.29,186.51 109.55,186.51 108.99,185.95 106.42,185.95 v2(105.79,186.59) ; v2(91.48,186.32) v2(90.82,186.32)
  IN1 w0.381: v2(91.48,186.32) 93.64,188.49 96.95,188.49 97.51,187.93 99.79,187.93 100.76,186.97 103.04,186.97 103.68,186.33 105.53,186.33 v2(105.79,186.59)
  IN2 w0.254: 129.46,116.23 130.73,117.5 134.89,117.5 v1(135.3,117.91)
  IN2 w0.381: v2(174.47,135.41) 174.03,135.41 171.37,138.07 171.37,138.58 169.34,140.61 169.34,145.06 167.69,146.71 167.69,149.37 168.07,149.76 169.08,149.76 170.73,151.41 170.73,154.15 170.26,154.62 170.26,154.96 169.89,155.33 169.89,156.01 168.92,156.97 168.92,159.21 167.54,160.59 167.54,164.9 168.27,165.63 168.27,168.15 167.35,169.07 164.85,169.07 163.43,170.49 148.19,170.49 147.25,169.56 143.74,169.56 140.66,172.64 129.94,172.64 128.52,174.06 122.93,174.06 118.4,178.6 118.4,179.28 117.97,179.71 115.77,179.71 114.01,177.96 110.1,177.96 109.65,178.41 108.17,178.41 105.46,181.12 105.46,183.54 106.09,184.17 106.09,185.42 105.79,185.72 v2(105.79,186.59)
  IN4 w0.254: v2(128.7,116.23) 129.46,116.23 132.25,113.43 132.25,112.29 133.78,110.77 133.78,109.75 136.6,106.93 140.28,106.93 140.97,106.24 144.37,106.24 145.44,107.31 v2(147.24,107.31)
  IN4 w0.381: v2(174.47,135.41) 174.47,134.9 175.31,134.06 175.31,131.34 174.32,130.35 174.32,128.83 176.88,126.26 186.99,126.26 189.4,128.67 197.88,128.67 198.8,127.76 202.84,127.76 204.27,129.18 210.71,129.18 218.58,121.31 221.05,121.31 v2(221.68,120.67)
  BOTTOM w0.254: CN49.16 221.88,120.25 221.68,120.45 v2(221.68,120.67) ; v1(135.3,117.91) 135.65,118.26 C96880.2 136.77,118.26 R68796.2
  vias: v2(37,130.04) v2(37,129.38) v2(37,128.72) v2(37,128.06) v2(38.43,130.01) v2(38.44,129.35) v2(38.44,128.69) v2(38.45,128.01) v2(44.93,171.92) v2(45.39,172.41) v2(45.87,172.87) v2(46.37,173.31) v2(47.04,173.32) v2(128.02,116.11) v2(128.03,115.45) v2(128.7,115.57)
+1.8V_SENSOR: length 2.9
  TOP w0.254: 155.11,211.86 154.96,212.01 154.96,212.68 155.11,212.83 U6516.C1
  TOP w0.508: R68988.2 R68987.1
  vias: v2(155.11,211.25)
+1.8V_SM:
  vias: v2(212.31,99.39)
+1.35V_GFX: length 29.8
  BOTTOM w0.203: 145.08,190.65 R314.2
  BOTTOM w0.254: U8.E23 138.17,185.99 v1(138.17,186.13) ; v1(142.13,188.67) 142.13,188.59 141.7,188.16 140.95,188.16 U8.H26 ; U8.E26 v1(140.51,186.11) ; U8.H24 v1(139.72,187.79)
  BOTTOM w0.305: v1(142.13,190.29) 142.13,190.5 141.8,190.83 141.08,190.83 U8.L26 ; U8.B26 140.88,183.25 v1(140.5,182.82) ; U8.L24 v1(138.93,190.28)
  BOTTOM w0.33: v1(155.8,174.8) 155.41,174.42 VRAM1.P3 ; VRAM1.L4 157.41,174.82 v1(157.4,174.82) 157,174.42 VRAM1.M3 ; v1(155,194.82) 155.4,195.22 VRAM2.D14 ; 157.8,173.62 v1(157.4,173.22) ; v1(154.2,176.67) 154.2,176.42 154.6,176.03 VRAM1.R5 ; VRAM1.P1 155.4,172.82 v1(155,172.42) ; v1(153.4,172.42) 153.8,172.82 VRAM1.T1 ; VRAM2.B12 153.8,196.83 v1(153.4,197.22) ; VRAM2.H12 VRAM2.G13 ; VRAM1.H12 160.2,181.62 v1(160.6,182.02) ; VRAM2.L14 161.01,195.22 v1(161.4,194.82) 161.8,195.22 VRAM2.M14 ; v1(157.4,172.42) 157.01,172.82 VRAM1.M1 ; VRAM2.B14 153.8,195.22 v1(153.4,194.82) ; VRAM2.D12 155,197.21 v1(155,197.22) 155.4,197.62 VRAM2.D11 155.4,197.63 155,198.02 v1(155,198.04) 154.98,198.04 VRAM2.C10 ; v1(154.2,174.8) 153.81,174.42 VRAM1.T3 ; VRAM2.M12 VRAM2.L13 ; VRAM1.N5 156.2,176.43 v1(156,176.63) ; v1(157.4,194.82) 157.39,194.82 VRAM2.F14
  BOTTOM w0.356: v1(155.97,198.88) 156.2,198.65 VRAM2.E10 ; VRAM2.K12 160.2,196.84 v1(160.57,197.21) ; VRAM2.G11 157.8,197.62 v1(157.4,197.22) 157,196.82 VRAM2.F12 VRAM2.G13
  BOTTOM w0.381: U8.C25 140.13,184.05 v1(140.51,184.43)
  BOTTOM w0.457: 151.9,182.61 148.49,182.61 v2(148.48,182.62) v2(147.16,182.62)
  vias: v1(130.64,186.88) v1(130.64,186.05) v1(133.34,187.63) v1(134.74,186.94) v1(135.48,186.89) v1(136.34,188.46) v1(137.3,196.85) v1(137.27,195.24) v1(137.27,194.44) v1(137.28,193.65) v1(137.28,190.25) v1(137.28,189.43) v1(137.28,188.61) v1(137.35,191.08) v1(153.4,204.41) v1(154.2,206.02) v1(154.2,182.82) v1(154.2,181.22) v1(154.21,179.64) v1(155,206.02) v1(155,183.62) v1(155.8,203.63) v1(155.8,181.22) v1(156.6,204.41) v1(156.62,202.04) v1(156.6,179.64) v1(157.4,205.22) v1(157.4,204.41) v1(157.4,202.81) v1(157.4,195.57) v1(157.4,183.62) v1(157.4,182.82) v1(157.4,182.02) v1(157.4,180.42) v1(157.4,175.62) v1(158.2,204.41) v1(158.2,181.22) v1(158.2,172.42) v1(159,173.22) v1(159,172.42) v1(159.8,176.42) v1(160.6,205.22) v1(160.6,181.22) v1(160.6,175.62) v1(160.6,174.82) v1(160.6,173.22) v1(160.6,172.42) v1(161.4,205.22) v1(161.4,203.63) v1(161.4,183.62) v1(161.4,180.42) v1(161.4,172.42) v1(162.2,202.02) v1(162.2,198.82) v1(162.2,197.22) v1(162.2,182.02) v1(162.2,180.42) v1(162.2,176.42) v1(163,206.02) v1(163,195.57) v1(163,183.62) v1(163,182.02) v1(163,174.82) v1(163,172.42) v1(163.19,176.81) v1(163.8,203.62) v1(163.79,201.91) v1(163.8,198.02) v1(163.8,197.22) v1(163.8,180.42) v1(163.8,179.62) v1(164.6,206.02) v1(164.6,198.02) v1(164.6,194.82) v1(164.6,182.02) v1(164.6,181.22) v1(164.6,180.42) v1(164.6,175.62) v1(164.6,173.22) v1(164.6,172.42) v1(165.4,203.62) v1(165.4,196.42) v1(165.4,195.62) v1(165.4,183.62) v1(165.4,181.22) v1(165.4,179.62) v1(165.4,174.02) v1(166.2,175.62) v2(155.03,194.1) v2(155.7,190.75) v2(156.42,190.75) v2(157.14,190.75) v2(157.88,190.75) v2(165.5,170.59) v2(165.8,171.17) v2(166.13,171.75) v2(166.16,170.59) v2(166.47,171.18) v2(166.64,172.45) v2(166.8,171.75) v2(166.82,170.62) v2(167.16,171.18) v2(167.35,173.89) v2(167.36,173.22) v2(167.35,172.55) v2(167.5,189.28) v2(167.49,171.76) v2(167.48,170.59)
+1V8_AON: length 51.5
  TOP w0.203: R397.2 113.58,183.28 v2(113.43,183.44) 113.43,183.77 113.61,183.95 R25490.2 ; R403.2 113.58,182.17 113.46,182.04 v2(113.46,182.04)
  TOP w0.254: PR9018.1 96.15,199.56 v1(96.06,199.56)
  IN4 w0.381: v1(96.06,199.56) 96.83,198.98 97.71,198.1 97.71,197 96.82,196.11 96.82,194.69 101.9,189.6 106.93,189.6 108.73,187.8 110.03,187.8 v2(110.05,187.78)
  BOTTOM w0.203: Q13.5 134.88,175.92 ; 134.88,175.92 134.88,175.37 134.28,174.77 133.14,174.77 132.83,175.08 R365.2 132.07,175.08 131.8,175.35 Q6512.2 131.48,175.43 131.02,175.89 130.07,175.89 129.81,175.63 R25322.2 ; 134.88,175.92 134.88,176.79 134.55,177.12 v1(134.21,177.12) ; 134.88,175.92 Q13.2 136.71,175.92 136.98,175.65 R362.2 ; R347.2 113.99,187.14 114.12,187.27 114.98,187.27 115.54,187.83 R297.2 ; PR9076.2 106.57,183.46 106.85,183.18 v2(106.85,183.16) 106,182.31 106,181.21 106.23,180.99 R382.2 ; v1(110.03,185.14) 110.03,184.32 C433.2 109.55,184.27 109.28,184.54 U9.5 ; 113.23,178.79 112.69,178.79 112.5,178.59 112.5,178.26 112.26,178.03 111.86,178.03 111.68,177.84 RG77.1
  BOTTOM w0.356: v1(127.31,186.9) U8.G10 ; v1(128.19,186.9) 128.19,186.97 128.67,187.45 129.22,187.45 U8.G12
  BOTTOM w0.381: R339.1 134.8,177.95 134.21,177.36 v1(134.21,177.12)
  vias: v1(113.41,180.36) v2(97.31,182.02) v2(97.98,182.02) v2(112.95,185.52) v2(121.41,174.63) v2(126.54,186.84)
+1V8_GFX_MAIN: length 35.9
  TOP w0.203: C362.1 135,198.75 v1(135.63,199.39)
  TOP w0.254: L4.1 131.59,188.09 v1(131.59,188.31)
  TOP w0.508: v2(113.76,196.79) 114.22,197.25 L8.1 L7.1 ; v2(162.09,207.98) C392.1 163.02,208.86 PR9103.1
  IN1 w0.508: v2(162.09,207.98) 156.51,207.98 155.87,208.62 151.81,208.62 148.07,204.88 145.85,204.88 145.84,204.87 v2(145.59,205.13)
  BOTTOM w0.254: PR9085.1 99.39,195.96 v1(99.36,195.98)
  BOTTOM w0.305: U8.AB22 137.62,199.74 136.83,198.95 U8.AA21 136.79,198.95 v1(136.42,199.33) ; v1(141.33,203.48) 141.33,203.44 U8.AF27 ; U8.AD24 v1(138.9,201.87) ; U8.AC23 v1(138.05,201.02) ; U8.AF26 v1(140.52,202.65) U8.AE25
  BOTTOM w0.356: U8.AA12 v1(128.98,199.41) ; v1(128.12,199.36) 127.76,199.01 U8.AA10
  BOTTOM w0.381: U8.AA16 133.45,199.01 v1(133.93,199.49) 134.34,199.07 U8.AA18 U8.AA19 135.25,199.01 v1(135.63,199.39) 135.98,199.03 U8.AA20 ; v1(129.81,199.39) 130.18,199.02 U8.AA13
  vias: v1(125.24,188.21) v1(125.65,187.73) v2(98.67,186.63) v2(98.67,185.97) v2(116.4,191.74) v2(119.68,192.15) v2(119.67,191.39) v2(144.06,205.13) v2(144.83,205.13)
+1V8_MAIN_EN_G: length 59.1
  TOP w0.254: PR9102.2 155.75,168.94 155.91,169.1 PR9104.1 156.65,170.48 PQ9084.2 v2(162.35,170.48) 162.98,169.85 v2(162.98,169.52) ; PQ9083.3 162.56,210.3 v2(162.89,210.3)
  IN1 w0.254: v2(162.98,169.52) 163.03,169.47 167.59,169.47 168.19,170.08 168.19,189.38 166.67,190.9 166.67,207.21 166.12,207.75 165.67,207.75 165.3,208.13 165.3,208.58 163.58,210.3 v2(162.89,210.3)
+2.5V_SUS: length 73.4
  BOTTOM w1.524: 67.48,105.31 67.48,108.23 68.88,109.62 68.88,127.66 70.86,129.64 70.86,165.3 67.86,168.3 67.86,175.92 67.99,176.04
  vias: v2(50.49,104.52) v2(51.38,105) v2(51.96,105.31) v2(51.99,104.64) v2(63.5,103.5) v2(67.23,178.33) v2(67.99,178.33) v2(80.44,185.29) v2(81.2,185.32)
+3V: length 505.2
  TOP w0.203: R68469.1 127.6,128.17 128.21,128.77 128.42,128.77 128.67,129.03 128.67,129.41 128.98,129.71 131.08,129.71 132.13,128.67 132.13,121.69 131.62,121.18 128.82,121.18 127.3,122.7 127.3,122.7 v1(126.18,122.7) 125.32,123.57 R68357.1 R68359.1 ; Q6585.2 Q6585.5 77.9,118.39 ; R68940.1 86.79,171.47 86.66,171.6 85.01,171.6 82.72,173.89 82.72,175.18 82.09,175.82 82.09,177.82 v2(82.21,177.95) ; v2(113.18,188.24) 113.56,187.86 R386.2 ; v2(33.07,157.25) R25526.2 ; 67.23,96.42 67.07,96.57 R67572.1 ; R25482.1 109.39,182.14 108.5,183.03 v2(108.5,183.16) ; v1(94.2,125.24) 94.84,125.24 96.67,127.07 97.76,127.07 98.47,127.78 R68780.1 ; R25307.1 144.11,107 v1(143.81,106.7) 143.81,105 143.27,104.46 143.27,102.99 143.46,102.79 143.46,100.98 143.61,100.83 R25312.2 ; v1(75.61,120.93) 75.23,120.55 75.23,118.64 75.84,118.03 R68361.2 77.54,118.03 77.9,118.39 ; R68442.1 R68439.1 115.14,116.71 v1(115.23,116.61) ; v1(19.83,59.97) 19.86,59.97 20.01,59.82 R68602.1 ; R67606.2 v2(211.75,92.79) ; 77.9,118.39 78.02,118.26 79.7,118.26 R68363.2 ; R25271.2 66.5,190.81 66.24,190.55 63.32,190.55 63.24,190.47 v2(63.19,190.47) ; v1(112.34,182.01) 112.57,182.01 114.09,180.49 114.83,180.49 115.36,181.02 Q6652.2 ; R68356.1 127.05,115.59 126.16,114.7 124.89,114.7 124.12,115.47 v1(123.74,115.47) ; R68468.1 v1(111.17,114.2) ; U67.14 30.18,155.69 29.72,156.15 v2(29.72,156.33) 29.72,156.97 29.23,157.46 R509.1 ; v2(20.24,74.19) 20.34,74.09 R68884.2 ; v1(93.47,180.9) 93.44,180.87 93.44,180.86 93.26,180.69 PR5001.1
  TOP w0.254: v2(55.27,130.92) 55.87,130.32 R25598.1 ; PR9009.1 105.58,193.39 105.61,193.42 v1(105.66,193.42)
  TOP w0.305: PR9088.1 v2(168.07,158.87)
  TOP w0.381: R68563.1 86,108.95 v2(86,109.6) ; v2(27.35,148.36) R69051.2
  TOP w0.508: Q6612.2 19.84,73.92 20.11,74.19 v2(20.24,74.19) ; v2(27.35,146.58) 27.35,145.95 28.08,145.22 L17.1 ; R25625.2 134.16,214.53 133.9,214.27 v2(133.9,213) ; R226.1 v2(43.78,106.19) 43.78,106.53 43.17,107.13 43.17,107.74 43.66,108.23 R225.1 ; v2(43.81,127.47) 44.28,127.94 R227.1
  IN1 w0.203: v1(122.32,118.59) 122.32,119 123.62,120.29 123.62,121.21 125.12,122.7 v1(126.18,122.7)
  IN1 w0.254: v1(75.61,120.93) 77.9,120.93 84.75,127.78 92.83,127.78 v1(93.26,127.35)
  IN1 w0.508: v2(43.81,127.47) 44.05,127.47 44.62,126.89 44.62,123.85 44.11,123.34 v2(39.29,123.34)
  IN2 w0.203: v1(112.34,182.01) 112.34,186.56 112.31,186.59
  IN2 w0.254: v2(223.57,113.43) 223.57,111.4 218.36,106.19 216.71,106.19 214.04,103.53 213.41,103.53 212.9,103.02 212.9,101.88 212.01,100.99 212.01,97.43 211.88,97.3 211.88,92.92 v2(211.75,92.79)
  IN2 w0.381: 108.5,186.17 v2(108.5,183.16) ; v2(7.41,32.53) 7.41,33.68 9.69,35.96 9.69,36.92 11.63,38.86 11.63,39.67 11.98,40.03 14.93,40.03 v2(15.06,39.9) 16.17,39.9 16.81,40.54 21.87,40.54 24.16,38.25 29,38.25 29.26,38 v2(29.26,37.49) ; 116.99,187.01 116.99,183.66 119.12,181.53 124,181.53 124.74,182.27 127.2,182.27 127.91,181.55 128.98,181.55 129.1,181.68 129.74,181.68 130.35,181.07 v2(130.35,177.06) ; 106.35,188.79 106.35,191.76 105.66,192.45 v1(105.66,193.42)
  IN2 w0.508: v2(166.77,124.61) 166.77,125.35 167.43,126.01 170.23,126.01 170.86,125.37 178.86,125.37 179.75,124.48 181.12,124.48 v2(182.42,123.19) ; v2(25.74,27.21) 26.85,27.21 v2(27.22,27.58) 27.48,27.58 28.11,28.22 28.11,29.99 28.62,30.5 28.62,32.66 29.38,33.42 v2(29.64,33.42)
  IN3 w0.203: v1(93.47,180.9) 93.44,180.87 93.44,180.86 92.94,180.36 88.06,180.36 87.29,179.6 84.22,179.6 82.57,177.95 v2(82.21,177.95) ; v1(94.2,125.24) 94.2,125.96 93.26,126.9 v1(93.26,127.35) ; v2(29.84,50.14) 30.14,50.44 30.14,55.32 28.44,57.02 24.46,57.02 24.1,57.38 v1(24.1,57.48) 24.1,57.55 22.58,59.08 20.72,59.08 v1(19.83,59.97)
  IN3 w0.381: v2(165.9,134.32) 164.83,134.32 163.24,135.91 160.12,135.91 159.24,135.04 158.07,135.04 156.81,136.29 154.55,136.29 153.33,137.51 153.33,138.45 154.4,139.52 154.4,140.08 153.33,141.14 153.33,141.88 154.05,142.59 v2(154.68,142.85)
  IN3 w0.508: v2(43.81,127.47) 44.85,128.51 47.89,128.51 48.42,129.04 53.75,129.04 55.27,130.56 v2(55.27,130.92)
  IN4 w0.203: v2(93.68,190.11) 93.47,189.9 v1(93.47,180.9)
  IN4 w0.381: 166.87,154.45 169.97,151.36 169.97,150.24 168.91,149.17 v2(168.69,149.17) ; 166.29,154.45 162.35,150.52 162.35,148.36 163.88,146.83 163.88,142.01 163.37,141.5 163.37,138.66 164.76,137.26 164.76,136.8 165.9,135.67 v2(165.9,134.32) 165.9,134.27 166.16,134.01 166.16,126.64 166.77,126.03 v2(166.77,124.61) ; v2(15.06,39.9) 16.17,39.9 18.71,42.44 19.35,42.44 22.65,45.74 22.65,46.5 23.16,47.01 23.92,47.01 24.23,47.32 24.23,57.35 v1(24.1,57.48) ; v2(168.07,158.87) 168.04,158.87 166.74,157.57 166.74,154.98
  IN4 w0.508: v2(26.59,70.94) 26.46,70.81 26.46,67.71 24.81,66.06 24.81,60.6 23.77,59.56 23.77,57.81 v1(24.1,57.48) ; v2(194.24,123.34) 193.81,122.91 193.29,122.91 191.31,120.93 187.49,120.93 186.99,121.43 182.8,121.43 182.42,121.82 v2(182.42,123.19) ; v2(29.64,33.42) 30.02,33.8 30.02,34.82 30.65,35.46 30.65,36.22 29.38,37.49 v2(29.26,37.49)
  BOTTOM w0.203: v2(63.88,187.71) 64.05,187.89 64.05,188.24 64.28,188.46 R439.1 ; R378.2 130.07,176.78 v2(130.35,177.06) ; v2(29.64,33.42) 29.51,33.55 R732.2 ; R68436.1 111.3,114.07 v1(111.17,114.2) R68441.1 ; JDIM02.255 64.08,106.07 v2(63.91,105.91) ; R25372.1 v2(182.42,123.19) ; v1(111.37,110.51) 111.81,110.51 111.96,110.67 R68437.1 ; v1(94.2,125.24) 94.2,125.32 R68364.1 ; R385.2 108.98,182.55 108.5,183.03 v2(108.5,183.16) ; R68358.1 121.84,115.62 v1(122.02,115.44) ; PR6416.1 7.13,31.92 7.13,32.25 v2(7.41,32.53) ; v1(93.26,127.35) 93.26,127.53 93.54,127.81 94.05,127.81 94.25,128.01 R68377.1 ; v1(123.74,115.47) 123.62,115.59 123.62,116 123.49,116.13 R68278.1 ; R67888.1 R67865.1 30.14,49.84 v2(29.84,50.14) ; v2(168.69,149.17) 168.69,149.23 168.29,149.62 PC9099.1 167.69,149.62 167.4,149.33 PU9006.5 ; v2(154.68,142.85) 154.86,142.85 154.94,142.92 PR7040.1 ; v2(85.42,190.49) 85.42,190.95 84.67,191.7 84.32,192.05 84.31,192.05 84,192.37 R440.1 83.09,192.37 83.03,192.32 82.99,192.32 82.98,192.3 R25367.2 ; R68420.2 v1(110.41,114.2) 110.49,114.12 R68440.1 ; v1(119.69,114.45) 119.93,114.45 120.06,114.58 R68355.1 ; PR7073.1 166.03,134.46 v2(165.9,134.32) ; R576.2 166.44,124.94 v2(166.77,124.61)
  BOTTOM w0.254: JDIM1.255 52.03,106.07 v2(51.96,106)
  BOTTOM w0.381: v2(235.63,120.47) 235.63,118.89 233.94,117.2 233.94,115.3 232.96,114.32 230.16,114.32 230.02,114.17 224.35,114.17 v2(224.33,114.2) ; v2(73.05,107.74) 73.2,107.9 73.2,108.99 73.32,109.12 73.32,110.21 72.64,110.89 72.64,119.99 73.58,120.93 v1(75.61,120.93) ; v2(27.22,27.58) 27.47,27.83 R460.2
  BOTTOM w0.508: v2(29.26,37.49) 29.26,38.57 28.89,38.93 R68687.1 28.39,38.79 28.39,38.38 28.38,38.36 27.88,37.87 27.78,37.87 27.19,37.27 R455.1 ; v2(93.68,190.11) 93.8,190.23 R67855.1 ; v2(29.72,156.33) 32.4,156.33 33.07,156.99 v2(33.07,157.25) ; PR9075.1 105.47,188.18 v2(105.47,188.39)
  vias: v2(26.59,148.36) v2(26.59,147.47) v2(26.59,146.58) v2(26.59,71.6) v2(26.84,138.2) v2(27.25,71.6) v2(27.25,70.94) v2(27.35,147.47) v2(27.6,138.2) v2(36.75,147.62) v2(36.75,146.96) v2(36.75,146.3) v2(37.43,146.96) v2(37.41,146.3) v2(37.46,147.62) v2(39.15,176.4) v2(39.17,175.67) v2(39.75,176.08) v2(70.3,190.4) v2(70.99,190.4) v2(72.05,105.94) v2(72.59,107.26) v2(73.43,195.22) v2(74.09,195.22) v2(98.62,106.52) v2(99.28,106.52) v2(118.99,187.7) v2(118.99,187.02) v2(130.98,209.42) v2(195.88,118.26) v2(195.88,117.6) v2(196.64,118.26) v2(196.64,117.6) v2(209.13,130.72) v2(209.81,130.78) v2(210.52,130.88) v2(211.25,130.98) v2(211.44,130.32) v2(211.94,131.08) v2(223.57,114.2) v2(224.33,113.43) v2(235.63,121.94) v2(235.63,121.18)
+3V3_TPM: length 20.3
  TOP w0.203: R580.2 83.66,99.49 83.48,99.31 v1(83.48,98.9)
  TOP w0.508: v2(95.85,98.45) 95.93,98.52 95.93,100.61
  BOTTOM w0.381: v1(84.88,95.75) 84.86,95.78 84.83,95.78 84.07,96.54 84.07,97.99 83.48,98.57 v1(83.48,98.9)
  BOTTOM w0.508: v1(84.88,95.75) 84.88,95.58 85.47,94.99 92.22,94.99 93.52,96.29 94.91,96.29 95.85,97.23 v2(95.85,98.45)
  vias: v2(93.26,101.37)
+3V3_TPM_VSB:
  vias: v2(92.32,96.11)
+3V_CR:
  vias: v2(28.24,66.44)
+3V_DEEP_SUS: length 414.9
  TOP w0.203: R68536.1 R68388.1 118.41,115.72 v1(118.66,115.97) ; v1(121.08,115.47) 121.08,115.59 120.82,115.85 R68520.2 R68529.2 R68518.2 R68527.2 R68525.2 R68522.2 ; R69019.1 23.03,135.53 23.16,135.4 v2(23.29,135.4) 23.54,135.66 Q62.5 ; R68522.2 125.24,115.62 125.53,115.33 125.69,115.33 125.71,115.3 v1(125.74,115.3) ; R68522.2 R68516.2 ; v1(127.68,114.7) 126.16,113.18 124.89,113.18 124.48,112.77 124.48,111.68 v2(124.76,111.4) 123.52,110.16 R68378.2 ; R68348.2 73.68,96.47 74.06,96.08 74.06,95.42 74.29,95.2 74.95,95.2 75.36,94.79 v2(75.36,94.38) 75.36,94.28 75.08,94 Q6616.2 Q6616.5 72.56,94 72.21,94.36 72.21,95.02 71.8,95.42 71.8,96.03 72.05,96.29 72.31,96.29 72.56,96.54 R68349.2 ; v1(117.43,116.85) 117.14,117.14 R68347.2 R68346.2 ; R68506.2 114.91,115.16 114.9,115.15 114.55,115.15 114.55,116.02 114.47,116.1 R68367.1 ; v1(90.72,125.88) 90.98,125.63 R68247.1 R68248.1 R68419.2 93.27,125.24 v1(93.31,125.19) ; R68728.2 91.74,128.8 91.46,128.52 R68513.2 90.95,128.52 89.96,127.53 89.58,127.53 88.82,126.77 v1(88.82,125.75) 88.44,125.75 88.06,126.13 87.29,126.13 86.91,125.75 86.91,125.09 87.04,124.96 87.04,123.16 87.27,122.93 88.46,122.93 90.11,121.28 90.11,120.01 90.6,119.53 91.64,119.53 R68927.2 R36.2 ; R68463.2 115.14,113.79 114.57,114.35 114.57,114.42 v1(114.55,114.45) ; v2(27.6,136.29) 27.6,135.91 27.35,135.66 Q62.2 ; R68366.1 125.36,126.42 125.36,126.41 125.85,126.41 125.88,126.39 126.08,126.39 v1(126.13,126.34) 126.13,125.72 126,125.6 R68418.2 ; R68369.1 121.74,113.02 121.2,113.56 ; R68539.1 121.2,114.83 ; 119.18,110.45 119.25,110.51 R68380.1
  TOP w0.381: 114.55,115.15 v1(114.55,114.45)
  TOP w0.508: R68507.2 113.26,114 113.25,114.01 113.25,114.03 113.03,114.25 113.03,114.45 v1(113.03,114.45) ; R68496.2 117.68,108.35 R68789.2 118.11,108.78 118.11,109.37 119.18,110.45 119.18,111.44 121.2,113.46 121.2,115.34 v1(121.08,115.47) ; v2(53.39,102.74) 53.39,102 52.5,101.11 52.5,99.97 54.02,98.45 v2(54.02,93.62)
  IN1 w0.203: v1(117.43,116.85) 117.79,116.85 118.18,117.24 120.11,117.24 120.52,117.65 121.03,117.65 121.71,118.34 121.71,119.07 122.98,120.34 122.98,121.24 125.01,123.28 125.01,123.59 125.39,123.97 125.9,123.97 126.28,124.36 126.28,125.22 126.13,125.37 v1(126.13,126.34)
  IN2 w0.203: v1(109.47,113.18) 109.01,113.64 109.01,113.94
  IN2 w0.508: v1(121.08,115.47) 121.08,115.72 120.06,116.74 119.04,116.74 118.66,116.35 v1(118.66,115.97) 118.66,115.59 116.84,113.76 114.9,113.76 114.55,114.12 v1(114.55,114.45) v1(113.03,114.45) 112.87,114.45 112.49,114.83 109.9,114.83 109.01,113.94 107.11,113.94 106.62,113.46 106.62,113.08 104.8,111.25 103.53,111.25 103.5,111.22 v1(102.51,111.22) v1(101.9,111.22) 101.57,111.22 101.14,111.66 99.87,111.66 99.23,111.02 95.93,111.02 92.25,114.7 v1(89.33,114.7) 89.33,115.21 86.02,118.51 82.21,118.51 81.96,118.26 79.04,118.26 77.52,116.74 77.26,116.74 70.4,109.88 70.4,108.84 63.57,102 56.31,102 55.57,102.74 v2(53.39,102.74) 53.39,103.15 53.16,103.37 51.51,103.37 49.78,105.1 46.1,105.1 45.62,105.57 45.62,109.76 43.79,111.59 v2(43.79,113.03) ; v2(22.65,55.14) 24.3,55.14 24.94,54.51 v2(28.14,54.51)
  IN3 w0.381: v2(28.14,50.95) 28.24,51.05 v2(28.24,52.72) 27.86,53.1 27.86,54.25 28.11,54.51 v2(28.14,54.51)
  IN4 w0.508: v2(23.29,135.4) 22.14,134.26 22.14,132.86 23.54,131.47 23.54,128.99 24.81,127.72 24.81,122.96 25.57,122.2 25.57,113.05 26.33,112.29 26.33,111.66 27.45,110.54 27.45,105.66 25.83,104.04 25.83,103.3 24.56,102.03 22.91,102.03 21.79,100.91 21.79,89.05 20.87,88.13 20.87,86.38 21.2,86.06 21.31,86.06 21.89,85.47 21.89,82.7 21.51,82.32 21.51,78.89 22.14,78.25 24.43,78.25 25.32,77.37 25.32,70.25 24.56,69.49 24.56,67.84 23.24,66.52 23.24,61.95 22.14,60.86 22.14,59.71 22.65,59.2 22.65,57.17 23.16,56.66 23.16,55.65 v2(22.65,55.14)
  BOTTOM w0.203: v1(88.82,125.75) 88.95,125.88 v1(90.72,125.88) 90.72,126.26 93.26,128.8 R68382.1 ; 117.41,116.85 116.91,117.34 R68544.1 ; 117.41,116.85 117.01,116.46 117.01,115.85 117.39,115.47 118.16,115.47 v1(118.66,115.97) 118.66,116.1 118.79,116.23 118.79,116.46 R68531.2 R68545.1 ; 117.41,116.85 v1(117.43,116.85) 117.76,116.85 117.87,116.96 R68368.1 ; R68485.2 94.66,124.99 94.48,124.81 93.77,124.81 93.39,125.19 v1(93.31,125.19) ; 120.85,113.56 120.26,113.56 120.02,113.8 118.91,113.8 118.73,113.62 118.73,113.37 118.57,113.21 R68390.2 ; 120.85,113.56 R68365.1 ; 120.85,113.56 120.85,113.59 121.33,114.07 121.33,115.21 v1(121.08,115.47) ; R68351.2 R68350.2 128.82,113.56 v1(127.68,114.7) 127.08,115.3 v1(125.74,115.3) ; R68537.1 109.24,111.52 R69091.1 109.24,112.95 v1(109.47,113.18) 109.47,113.36 109.22,113.61 R68538.1
  BOTTOM w0.254: v1(89.33,114.7) 89.76,115.13 89.76,120.34 90.65,121.23 90.65,123.19 91.18,123.72 91.99,123.72 93.31,125.04 v1(93.31,125.19)
  BOTTOM w0.381: v2(28.14,50.95) 28.14,50.72 27.85,50.43 Q6625.2 ; Q6622.2 27.64,55.01 v2(28.14,54.51) ; v2(28.24,52.72) Q6624.2
  BOTTOM w0.508: v2(54.02,93.62) 54.02,93.24 55.44,91.82 76.09,91.82 76.63,92.35 76.63,93.11 v2(75.36,94.38) ; v2(43.79,113.03) 43.1,113.03 41.95,114.18 41.95,130.79 41.4,131.34 39.67,131.34 33.45,137.56 29.51,137.56 28.24,136.29 v2(27.6,136.29) 24.18,136.29 v2(23.29,135.4)
+3V_EC: length 8.8
  TOP w0.203: U37.11 150.94,105.54
  TOP w0.254: 150.94,105.54 150.77,105.71 150.77,106.37 150.41,106.73 150.19,106.73 149.98,106.52 C1189.1 149.57,106.79 149.35,107.01 148.31,107.01 v2(147.59,106.29) 147.1,105.8 R25317.2 R25307.2
+3V_HDMI: length 10.4
  TOP w0.178: U6537.1 27.9,129.35 28.24,129.69 ; 21.35,122.93 21.98,123.55 U6537.24
  TOP w0.203: v2(31.54,120.16) R68219.2 ; v2(30.09,119.66) 29.86,119.89 R68216.1 ; v2(23.41,119.91) 23.36,119.96 R68218.1 R68217.1 ; v2(26.84,120.04) 26.72,120.16 26.72,120.65 R68204.1 R68203.1 ; v2(27.32,132.07) R68210.1 ; C96562.2 21.52,121.17 21.35,121.34 C96563.2 v2(21.35,122.55) 21.35,122.93
  TOP w0.381: v2(21.64,120.04) 21.52,120.16 C96562.2
  vias: v2(28.62,132.86) v2(28.62,132.1)
+3V_LAN: length 23.3
  TOP w0.203: v2(13.51,165.38) 13.63,165.25 R68929.2 ; 22.91,171.73 22.91,171.05 21.89,170.04 U6521.15 ; U6521.19 20.29,169.76 20.35,169.82 20.35,172.09 ; v2(29.23,159.28) R9340.2 ; v1(13.15,162.07) 13.13,162.07 12.93,162.27 Q6620.2 ; v2(24.18,160.93) 23.79,160.93 23.64,160.78 R25445.2 ; Q6619.2 30.48,166.14 v2(30.14,166.14) 30.01,166 R67475.1 R67474.1 ; Q6531.2 24.26,159.28 v2(24.05,159.28) ; v2(14.23,165.38) R4024.2 ; v2(15.91,167.01) 16.32,167.01 16.72,166.61 U6521.29 ; Q6554.5 Q6554.2 v2(13.25,167.28) ; v2(14.39,162.18) 14.81,162.59 R67512.1 R67510.1 R67511.1 ; v2(29.13,162.96) R68924.2
  TOP w0.381: Q6618.2 29.7,159.85 29.26,160.3 v2(29.26,161.06)
  BOTTOM w0.203: v2(15.91,167.01) 16.3,166.62 R67509.1
  vias: v2(22.88,175.08) v2(24,175.09) v2(24.69,175.09) v2(25.42,165.12) v2(26.08,165.12)
+3V_LDO_EC: length 491.1
  TOP w0.203: R67871.1 171.67,105.02 171.82,105.17 171.82,109.31 172.16,109.65 172.16,110.08 171.62,110.61 v2(171.5,110.61) ; R25314.2 163.09,113.4 v2(163.37,113.69) ; v2(17.87,114.78) 18.27,114.78 18.4,114.91 PD8004.1 18.97,115.34 19.05,115.26 PQ8014.1 20.29,115.26 21.48,114.07 22.78,114.07 23.03,114.32 23.65,114.32 23.78,114.2 PQ8016.4 ; v2(167.1,113.94) 167,113.84 R25309.2 ; R67487.2 147.98,96.97 147.83,97.13 R67486.2 147.14,97.53 146.91,97.76 v2(146.91,98.24) 146.91,98.47 147.67,99.24 148.68,99.24 148.94,98.98 R67484.2 149.17,98.96 R67485.2 ; D63.1 143.8,103.41 144.19,103.02 144.83,103.02 145.16,102.68 v1(145.16,102.26) 145.11,102.2 R25300.2 ; PR8020.1 52.62,195.91 52.37,196.16 51.48,196.16 51.33,196.31 PR8010.2 50.29,196.67 v2(50.24,196.62) 50.22,196.61 50.22,196.05 48.56,194.38 47.84,194.38 43.1,189.63 43.1,187.58 42.49,186.97 42.49,179.77 39.64,176.92 34.35,176.92 33.44,177.83 v2(25.84,177.83) ; v2(161.87,113.92) 162,113.79 R361.2 R369.2 ; R67604.2 147.87,109.88 147.62,109.62 R383.2 147.32,109.52 v2(147.32,108.91) 147.32,108.91 147.32,108.73 146.89,108.3 R25304.2
  TOP w0.381: v2(170.23,130.37) 170.53,130.37 170.99,130.83 170.99,132.23 171.57,132.81 172.65,132.81 PR6017.1
  TOP w0.508: R25306.1 170.46,110.61 v2(171.5,110.61) ; v1(170.56,120.29) 170.45,120.19 170.45,118.87 169.73,118.14 R359.1 170.48,114.83 v2(170.73,114.58)
  IN2 w0.381: v1(145.16,102.26) 145.16,102.09 144.78,101.7 142.74,101.7 142.29,102.16 139.77,102.16 139.39,101.77 130.07,101.77 129.08,102.77 122.85,102.77 122.73,102.89 119.04,102.89 118.16,102 117.14,102 116.48,102.66 110.26,102.66 109.61,102.02 101.25,102.02 100.86,102.41 94.64,102.41 94.36,102.13 93.39,102.13 92.32,101.06 86.79,101.06 86.15,101.7 83.05,101.7 82.47,101.11 80.44,101.11 80.08,101.47 78.76,101.47 78.48,101.75 73.45,101.75 73.06,101.36 73.06,100.9 72,99.84 71.4,99.84 70.94,99.38 70.94,97.91 68.52,95.5 45.82,95.5 45.11,96.21 36.49,96.21 34.21,98.5 34.21,100.48 31.54,103.15 31.16,103.15 29.89,104.42 v2(28.98,104.42)
  IN3 w0.381: v2(170.73,114.58) 170.1,114.58 169.46,113.94 v2(167.1,113.94) 167.1,113.74 166.44,113.08 163.6,113.08 163.37,113.31 v2(163.37,113.69) 162.78,113.69 162.56,113.92 v2(161.87,113.92) 161.87,113.08 160.73,111.93 155.04,111.93 153.36,110.26 150.03,110.26 148.89,109.12 148.89,108.68 148.44,108.23 147.32,108.23 ; v2(143.24,107.65) 143.81,108.23 147.32,108.23 ; 147.32,108.23 v2(147.32,108.91)
  IN3 w0.508: v2(170.73,114.58) 170.73,111.38 v2(171.5,110.61)
  IN4 w0.203: v2(17.87,114.78) 17.87,114.83 17.84,114.86 17.84,117.35 16.28,118.92 16.28,129.03 16.94,129.69 17.32,129.69 17.7,130.07 17.7,134.56 21.23,138.09 21.23,143.83 17.32,147.74 17.32,154.28 17.91,154.87 17.91,156.31 22.12,160.52 22.12,162.75 22.93,163.56 22.93,171.32 25.32,173.71 25.32,177.32 v2(25.84,177.83)
  IN4 w0.381: 29,104.42 29.23,104.64 29.23,109.78 27.48,111.53 27.48,115.02 v2(26.77,115.74) ; 29,104.42 v2(28.98,104.42) ; 29,104.42 29.95,103.46 31.1,103.46 32.18,102.38 32.18,98.57 30.91,97.3 28.27,97.3 24.56,93.6 24.56,88.54 26.97,86.13 26.97,81.3 25.95,80.29 25.95,78.51 26.39,78.08 26.39,76.93 27.99,75.33 27.99,70.38 27.22,69.62 27.22,65.94 26.84,65.55 26.84,64.03 27.07,63.8 27.07,58.37 24.86,56.16 24.86,45.61 24.04,44.79 22.69,44.79 19.58,41.68 19.1,41.68 17.32,39.9 v1(17.32,39.87) ; v2(170.23,130.37) 169.59,129.74 169.59,123.21 170.56,122.25 v1(170.56,120.29)
  BOTTOM w0.203: D13148.1 141.9,123.85 141.52,124.23 R68802.1 R68803.1 R68804.1 ; R68813.2 139.24,128.29 138.93,128.6 Q6606.2 Q6606.5 135.99,128.6 135.05,127.66 v1(134.79,127.66) ; v1(17.32,39.87) 16.83,39.87 16.68,40.03 Q6628.2 17.29,40.38 17.32,40.41 18.21,40.41 18.76,40.96 Q6627.2 18.91,41.29 19.13,41.51 Q6626.2 ; v1(134.79,128.93) 134.82,128.93 134.95,129.05 R68814.2 ; v2(138.22,120.8) 137.66,120.24 137.66,119.61 R69012.2 ; R68799.2 v2(141.52,120.8)
  BOTTOM w0.254: v1(134.79,128.93) 134.54,128.93 134.13,128.52 C96879.2 134.13,127.12 133.94,126.93 R68795.1
  BOTTOM w0.381: D13148.1 143.18,123.85 143.56,124.23 v2(143.56,124.36) ; v2(17.87,114.78) 17.87,114.83 18.35,115.32 25.66,115.32 26.08,115.74 v2(26.77,115.74) ; v2(146.91,98.24) 146.91,98.9 145.16,100.65 v1(145.16,102.26) 145.16,102.68 144.7,103.15 144.7,106.83 144.19,107.34 143.56,107.34 v2(143.24,107.65) 143.24,108.04 142.95,108.33 141.17,108.33 140.63,108.86 140.63,109.47 140.25,109.85 137.94,109.85 136.52,111.27 135.71,111.27 135.22,111.76 135.22,114.8 135.89,115.47 135.89,115.8 136.44,116.35 138.17,116.35 139.14,117.32 139.14,118.11 141.52,120.49 v2(141.52,120.8) v2(142.29,120.8)
+3V_RTC: length 125.7
  TOP w0.203: R68500.2 106.85,109.62 107.08,109.4 R68401.1
  TOP w0.305: v1(105.46,108.23) 106.48,109.25 R68500.2 ; R971.1 77.39,103.86 77.52,103.73 v2(77.52,103.68)
  TOP w0.508: 77.52,102.13 v2(77.52,103.68)
  IN1 w0.305: v2(69.51,177.82) 69.51,176.93 70.91,175.54 72.63,175.54 v2(73.2,174.96)
  IN3 w0.305: v2(77.52,103.68) 78.05,103.68 78.56,104.19 84.65,104.19 85.26,104.8 88.31,104.8 88.44,104.92 91.99,104.92 92.43,104.49 97.66,104.49 98.98,105.81 99.97,105.81 101.29,107.13 104.49,107.13 105.46,108.1 v1(105.46,108.23)
  BOTTOM w0.305: R25310.1 68.78,180.77 68.63,180.62 68.63,178.2 69.01,177.82 v2(69.51,177.82)
  BOTTOM w0.508: v2(73.2,174.96) 75.55,174.96 76.12,174.39 76.12,169.44 73.96,167.28 73.96,128.06 71.93,126.03 71.93,109.09 72.44,108.58 72.44,108.12 71.9,107.59 71.9,106.98 72.31,106.58 75.69,106.58 75.93,106.33 75.93,104.22 76.47,103.68 v2(77.52,103.68)
  vias: v2(79.93,101.11)
