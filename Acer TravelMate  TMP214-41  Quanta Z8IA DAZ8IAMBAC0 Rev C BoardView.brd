# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_RTC_0: length 149.1
  TOP w0.508: Q28.1 4.12,12.24 3.82,12.55 v2(3.29,12.55) ; 77.52,95.4 v2(77.52,94.64) 77.52,94.13 76.45,93.06 76.45,91.16 v2(76.37,91.08)
  IN2 w0.508: v2(35.48,73.43) 34.97,72.92 34.97,64.41 34.79,64.23 34.79,29.44 31.97,26.61 29.14,26.61 16.65,14.12 12.62,14.12 12.11,13.61 11.35,13.61 10.7,12.96 6.03,12.96 5.61,12.55 v2(3.29,12.55)
  BOTTOM w0.508: v2(76.37,91.08) 75.76,90.47 37.87,90.47 36.57,89.18 36.57,88.54 35.73,87.7 35.73,85.87 35.2,85.34 35.2,82.34 35.56,81.99 36.44,81.99 36.84,81.59 36.84,77.84 36.47,77.47 36.47,74.42 v2(35.48,73.43) ; v2(3.29,12.55) 3.29,11.57 CN1.1
+3V_RTC_1:
  vias: v2(76.47,97.23)
+3V_RTC_2: length 2
  TOP w0.508: D72.2 77.25,97.4 v2(77.72,96.92) 78.29,96.92 R978.2
+3V_S5: length 637.1
  TOP w0.203: v1(93.9,127.35) 93.9,127.66 93.52,128.04 92.18,128.04 92.02,127.89 R68744.2 91.54,127.58 90.24,126.29 90.24,125.02 89.74,124.51 R68460.2 ; R567.2 128.66,96.19 127.99,96.87 R574.2 127.25,97.1 126.76,97.59 126.76,97.92 v2(126.74,97.94) ; R69048.1 211.35,105.02 v2(211.75,105.43) ; R68251.1 84.78,171.06 83.74,172.11 R68250.1 83.46,172.49 82.21,173.73 v2(82.21,174.96) ; R69094.1 27.22,82.19 v2(27.73,81.68) ; v2(68.09,103.93) 67.45,103.29 R68741.2 67.45,102.86 67.38,102.79 R68740.2 ; v2(138.57,101.11) R101.2 ; v1(112.29,108.89) 112.26,108.91 112.26,111.07 111.62,111.72 111.62,112.23 111.4,112.45 R68461.1 111.4,112.95 111.3,113.05 R68743.2 111.68,113.31 111.93,113.56 111.93,114.07 112.06,114.2 R68742.2 ; PR9255.1 36.25,145.56 35.83,145.15 35.83,144.65 35.94,144.55 35.94,144.01 36.43,143.52 PC572.1 ; R69034.1 116.12,113.18 116,113.05 116,112.54 115.64,112.19 115.64,111.17 115.23,110.77 115.23,109.69 v1(115.3,109.62) ; v1(27.25,77.97) 26.73,77.46 U6565.5 ; v1(91.61,105.48) 91.61,105.28 91.87,105.03 R68490.2 ; v2(134.67,98.17) 134.67,97.81 134.82,97.66 R566.2 ; R69044.1 230.52,127.91 230.27,128.17 228.39,128.17 228.26,128.29 226.61,128.29 v2(225.6,127.28) 225.6,126.64 225.75,126.49 R69065.1
  TOP w0.254: PU9005.5 32.57,139.86 33.02,140.31 33.02,141.3 v2(33.32,141.6)
  TOP w0.381: v2(168.83,116.28) 168.83,115.85 168.46,115.47 R25330.1 ; v2(132.05,97.94) 132.05,99.63 R69054.1 ; R68562.1 85.61,106.92 85.36,106.68 v2(85.36,106.27) ; v2(103.45,107.72) 103.45,108.95 R68501.2
  TOP w0.508: R25622.1 134.28,216.18 134.04,216.42 v2(134.04,217.2) ; v2(22.21,178.19) R25618.2 ; PR5020.1 69.99,185.66 69.64,185.32 v1(69.64,184.55)
  TOP w1.016: v2(76.61,105.8) 76.35,105.53 76.35,102.41 76.04,102.1 76.04,99.89 75.48,99.34 75.48,97.81
  IN1 w0.254: v2(82.21,174.96) 82.21,175.28 82.04,175.46 79.03,175.46 v2(78.53,174.96) ; v2(74.34,120.04) 74.34,120.67 75.1,121.43 77.64,121.43 84.63,128.42 93.01,128.42 93.9,127.53 v1(93.9,127.35)
  IN1 w0.508: v2(78.53,174.96) 78.53,175.16 78.1,175.59 74.54,175.59 73.2,176.93 72.05,176.93 71.55,177.44 71.55,178.46 71.04,178.97 71.04,180.87 70.53,181.38 70.53,183.66 v1(69.64,184.55)
  IN2 w0.508: v2(22.21,178.19) 21.17,177.15 18.72,177.15 12.11,170.54 12.11,167.79 9.18,164.86 9.18,160.07 10.97,158.29 10.97,149.25 18.8,141.41 18.8,136.31 16.5,134 16.5,132.02 15.81,131.33 15.81,118.94 v2(18.69,116.06) ; v2(27.73,81.68) 29.26,81.68 29.38,81.56
  IN2 w1.016: 4.36,33.55 4.68,33.87 4.68,36.9 5.91,38.12 8.02,38.12 12.19,42.29 12.19,43.98 12.64,44.44 12.64,45.01 14.52,46.88 15.29,46.88 21,52.6 21,56.79 21.53,57.32 23.01,57.32 23.72,56.61 26.54,56.61 28.87,58.95 28.87,62.76 29.26,63.14 29.26,65.43 30.14,66.32 30.14,80.79 29.38,81.56 29.38,87.4 27.1,89.68 27.1,92.99 29.13,95.02 32.3,95.02 34.59,92.73 70.91,92.73 73.2,95.02 74.09,95.02 74.59,95.53
  IN3 w0.381: v2(225.6,127.28) 225.6,126.77 224.45,125.63 223.06,125.63 222.42,124.99 213.41,124.99 211.85,126.54 v2(209.85,126.54) ; v2(138.57,101.11) 137.05,99.59 136.1,99.59 134.68,98.17 v2(134.67,98.17)
  IN3 w0.508: v2(134.67,98.17) 134.67,98.18 134.25,98.6 132.46,98.6 132.05,98.19 v2(132.05,97.94)
  IN4 w0.203: v1(27.25,77.97) 27.25,78.23 26.84,78.64 26.84,80.16 27.73,81.05 v2(27.73,81.68) ; v2(197.94,110) 198.29,110 198.93,109.37 201.72,109.37 201.98,109.62 202.74,109.62 204.01,108.35 204.01,107.08 205.66,105.43 v2(211.75,105.43) ; v1(122.82,113.03) 123.06,113.03 v1(123.87,112.21) 124.94,111.15 125.78,111.15 127.68,109.24 v1(127.81,109.24)
  IN4 w0.381: v2(68.09,103.93) 69.46,105.31 76.14,105.31 76.61,105.77 v2(76.61,105.8)
  IN4 w0.508: v2(169.75,119.36) 167.22,119.36 166.92,119.66 166.92,122.58 165.98,123.52 165.98,125.29 165.27,126.01 165.27,132.99 164.51,133.75 164.51,134.9 163.49,135.91 160.57,135.91 159.02,137.46 v1(159.02,138.33) ; v2(134.04,217.2) 134.04,216.7 133.61,216.28 132.96,216.28 132.22,215.54 129.2,215.54 126.03,212.37 121.97,212.37 120.95,211.35 120.95,209.83 116.12,205 116.12,199.03 114.85,197.76 114.85,195.48 114.47,195.09 114.47,191.41 113.84,190.78 101.82,190.78 97.77,194.83 97.77,195.92 98.47,196.62 98.47,198.52 96.69,200.3 94.28,200.3 92.12,198.14 92.12,195.48 89.33,192.68 87.8,192.68 86.79,193.7 85.01,193.7 83.87,192.55 83.87,190.01 83.1,189.25 79.67,189.25 78.91,188.49 78.91,187.6 78.4,187.09 72.05,187.09 69.64,184.68 v1(69.64,184.55)
  BOTTOM w0.102: 104.72,111.36 R68408.1
  BOTTOM w0.203: Q6638.5 126.41,114.58 126.18,114.8 125.37,114.8 124.99,114.42 R69016.2 124.4,114.42 123.01,113.03 v1(122.82,113.03) ; R68511.1 102.29,108.86 101.52,108.86 101.01,109.37 R68410.1 ; R68737.2 R68747.2 114.42,111.48 112.31,109.37 112.31,108.91 v1(112.29,108.89) ; v1(93.9,127.35) 93.98,127.28 R68745.2 ; PR5000.1 69.54,184.66 v1(69.64,184.55) ; Q6638.2 126.41,111.91 126.11,111.6 124.43,111.6 123.87,112.16 v1(123.87,112.21) 123.87,112.29 124.28,112.7 R69017.2 ; R68920.2 97.58,105.18 v2(97.96,105.56) ; C96773.2 104.19,109.65 104.34,109.8 104.34,110.79 104.72,111.18 104.72,111.36 ; R608.1 115.24,110.77 115.64,111.17 115.64,112.19 116,112.54 R68738.2 R68739.2 ; v1(159.02,138.33) 159.37,138.33 PR7063.1 ; v2(202.36,115.15) 202.39,115.11 R68757.1 ; v2(82.21,174.96) 82.21,174.52 82.6,174.14 83.99,174.14 84.4,174.55 84.4,175.05 85.14,175.79 87.17,175.79 87.42,176.04 87.93,176.04 88.44,175.54 88.44,174.39 88.88,173.95 89.26,173.95 90.22,173 90.22,168.81 90.6,168.42 93.64,168.42 94.15,167.92 94.15,167.15 93.9,166.9 93.14,166.9 92.63,166.39 92.63,165 93.42,164.2 R68314.2
  BOTTOM w0.381: v2(132.05,97.94) 132.05,97.61 131.74,97.3 127.05,97.3 126.74,97.61 v2(126.74,97.94) ; v2(209.85,125.88) 210.61,125.12 210.61,121.54 210.87,121.28 210.87,119.74 210.48,119.36 R68916.1 ; Q6600.1 v2(202.36,115.15)
  BOTTOM w0.457: R608.1 115.3,110.2 v1(115.3,109.62)
  BOTTOM w0.508: 76.63,119.91 76.63,121.18 77.39,121.94 77.39,123.06 77.11,123.34 77.11,164.72 77.77,165.38 77.77,173.63 78.53,174.39 v2(78.53,174.96) ; v2(138.57,101.11) 138.57,102.92 138.06,103.43 v2(138.06,104.44)
  vias: v2(3.47,33.8) v2(3.47,33.04) v2(27.94,68.22) v2(28.6,68.22) v2(30.02,68.22) v2(33.32,143.58) v2(33.32,142.92) v2(33.32,142.26) v2(33.98,143.58) v2(34.03,142.92) v2(34.69,143.58) v2(34.69,142.92) v2(39.25,130.06) v2(39.25,129.4) v2(39.29,128.67) v2(39.29,127.91) v2(39.29,126.16) v2(39.29,125.5) v2(39.29,124.84) v2(39.29,124.18) v2(73.32,119.02) v2(73.63,117.67) v2(73.83,119.53) v2(74.21,118.13) v2(74.26,117.45) v2(74.72,118.64) v2(75.79,95.91) v2(76.37,107.22) v2(76.45,95.91) v2(76.86,107.69) v2(77.08,106.27) v2(77.33,108.15) v2(77.58,106.77) v2(78.05,107.24) v2(102.79,107.72) v2(193.75,118.31) v2(193.75,117.62) v2(194.43,118.31) v2(194.43,117.62) v2(207.87,126.54) v2(207.87,125.88) v2(208.53,126.54) v2(208.53,125.88) v2(209.19,126.54) v2(209.19,125.88)
+3V_SM: length 28.8
  TOP w0.203: v2(209.76,96.69) R25555.1 210.77,97.08 211.22,97.53 C20043.1 212.01,97.94 212.25,98.18 U6509.18 ; U6509.10 222.42,97.53 222.46,97.56 223.85,97.56 223.98,97.69 C20041.1 223.03,98.07 v2(223.03,98.07)
  TOP w0.508: v2(218.66,98.07) 218.66,100.14 220.64,102.12 C20049.2
  IN4 w0.508: v2(209.76,96.69) 211.13,98.07 v2(218.66,98.07) 218.67,98.07 v2(223.03,98.07)
  vias: v2(222.17,101.11)
+3V_SPI: length 77.1
  TOP w0.203: v1(83.43,97.81) 83.1,97.81 82.95,97.66 R583.2 R586.2
  TOP w0.508: v2(119.68,108.73) 119.68,108.61 118.32,107.25 R68789.1
  TOP w0.762: 104.69,98.19 104.69,101.22 105.48,102 108.5,102 109.44,102.94 109.44,104.47 110.03,105.05 111.55,105.05 v2(112.38,105.88) 113.75,107.25 R68789.1
  IN2 w0.254: v2(94.41,98.45) 93.8,97.84 85.9,97.84 85.36,97.3 83.87,97.3 83.43,97.74 v1(83.43,97.81)
  IN2 w0.762: 103.42,96.92 102.03,96.92 101.8,96.69 100.57,96.69 99.83,97.43 95.93,97.43
  BOTTOM w0.203: v2(119.68,108.73) 119.68,108.61 119.27,108.2 R68592.2 ; U6548.8 121.05,108.87 120.95,108.76 C96793.2 119.71,108.76 ; v1(104.85,96.72) 104.9,96.67 112.44,96.67 112.57,96.54 118.66,96.54 119.32,97.2 122.04,97.2 123.79,98.96 123.79,99.62 126.64,102.46 129.41,102.46 130.83,103.88 C96794.1 131.46,103.88 131.77,104.19 R68591.1
  BOTTOM w0.254: 119.71,108.76 v2(119.68,108.73)
  vias: v1(104.21,96.72) v2(95.17,98.45)
+3V_SSD: length 1.2
  TOP w0.381: R69092.2 24.43,77.75 v2(24.43,77.11)
  vias: v2(13.05,77.03)
+3V_TCSS: length 102.7
  TOP w0.203: v2(168.55,148.01) 168.09,148.01 C96894.1 168.01,147.65 168.32,147.34 168.7,147.34 168.72,147.33 U6561.5 ; R68845.2 v2(172.64,149.37) ; v2(209.47,115.59) 209.34,115.46 209.34,114.32 209.24,114.22 C96890.1 209.24,113.37 209.21,113.34 209.21,113.31 209.07,113.16 U6559.5 ; v2(170.48,141.55) 170.48,141.5 170.23,141.25 C96897.1 169.94,141.78 169.86,141.87 U6562.5 ; v2(207.06,114.41) 206.96,114.31 C96889.1 206.96,113.34 206.79,113.16 U6558.5
  IN2 w0.381: v2(170.48,141.55) 169.97,142.06 169.97,144.04 170.35,144.42 v2(170.86,144.42) 170.99,144.55 170.99,146.2 169.92,147.27 168.91,147.27 168.57,147.6 168.57,148.01 ; 168.57,148.01 v2(168.55,148.01) ; 168.57,148.01 169.39,148.01 169.87,148.49 171.75,148.49 v2(172.64,149.37)
  IN3 w0.381: v2(207.06,114.41) 208.29,114.41 v2(209.47,115.59)
  IN4 w0.381: v2(212.01,122.2) 212.39,122.2 212.64,122.45 212.64,126.34 210.69,128.29 208.2,128.29 207.06,127.15 203.63,127.15 202.99,126.51 198.8,126.51 197.28,128.04 189.91,128.04 187.5,125.63 176.6,125.63 173.68,128.55 173.68,130.68 174.67,131.67 174.67,133.75 172.89,135.53 172.89,136.29 169.84,139.34 169.84,140.92 v2(170.48,141.55)
  BOTTOM w0.203: v2(170.86,144.42) 170.89,144.42 171.01,144.55 C96898.1 170.64,144.96 170.36,144.68 U6563.5 ; R68843.2 172.79,149.22 v2(172.64,149.37)
  BOTTOM w0.381: v2(212.01,122.2) 212.01,121.69 v2(211.63,121.31) 211.63,119.53 211.37,119.28 211.37,118.72 211.49,118.6 R68917.2 ; R68917.2 211.49,117.41 211.21,117.13 211.01,117.13 v2(209.47,115.59) ; R68917.2 210.49,118.01 R68916.2
+3V_THM: length 181.5
  TOP w0.203: v1(94.1,180.92) 94.05,180.87 94.05,180.43 R69026.1
  IN1 w0.254: v1(94.1,180.92) 94.23,181.05 99.66,181.05 101.37,179.35 103.96,179.35 104.54,178.76 109.67,178.76 109.98,178.46 115.13,178.46 115.74,177.85 118.03,177.85 119.9,175.97 119.9,174.81 121.33,173.38 121.33,170.33 122.54,169.12 122.54,168.61 123.55,167.6 124.06,167.6 125.07,166.6 130.27,166.6 133.65,163.22 133.65,155.47 134.67,154.45 137.08,154.45 138.35,153.18 138.35,146.07 140.13,144.29 140.13,140.87 139.75,140.48 139.75,138.71 142.97,135.48 151.23,135.48 154.6,132.1 154.6,130.88 159.1,126.39 161.84,126.39 163.24,124.99 163.24,124.61 163.75,124.1 165.22,124.1 166.96,122.36 166.96,122.06 168.19,120.82 176.73,120.82 177.52,120.04 183.69,120.04 184.45,119.28 188.26,119.28 189.15,120.16 191.16,120.16 193.59,122.6 193.59,123.54 194.18,124.13 197.25,124.13 198.04,123.34 198.04,122.58 198.85,121.76 202.69,121.76 203.44,122.51 v2(203.44,122.64)
  IN4 w0.203: v1(91.26,178.74) 92.12,179.6 93.11,179.6 94.1,180.59 v1(94.1,180.92)
  BOTTOM w0.203: v1(94.1,180.92) 94.41,180.61 R67857.1 ; R69027.2 89.93,177.92 90.72,178.71 91.16,178.71 91.18,178.74 v1(91.26,178.74)
  BOTTOM w0.254: 92.76,185.06 93.39,185.06 93.62,184.84 R67858.1 93.62,184.17 93.77,184.02 Q6564.5 Q6564.2 93.77,181.25 v1(94.1,180.92) ; v2(203.44,122.64) 203.44,123.76 202.94,124.25 202.94,124.41 202.61,124.74
  BOTTOM w0.305: R67855.2 94.06,189.03 v2(93.7,188.67) 94.01,188.35 C96269.1 93.61,187.99 93.14,187.51 U2.1 90.25,187.51 89.58,186.84 89.58,186.1 89.99,185.7 91.1,185.7 91.74,185.06 92.76,185.06
+3V_USB: length 59
  TOP w0.203: v1(81.9,106.87) 81.55,107.21 C96780.2 C96783.2 81.55,109.21 81.83,109.49 U6544.5 ; U6544.28 78.28,111.17 77.59,110.48 C96781.2 C96786.2 76.3,110.48 75.76,111.02 75.76,111.73 75.98,111.95 76.17,111.95 76.45,112.23 R68552.2 R68553.2 75.92,113.05 75.64,113.33 v2(75.64,113.94) R68556.2 75.64,115.59 75.89,115.85 R68550.2 76.36,116.59 76.92,117.15 C96776.2 77.49,117.15 78.05,117.7 R68554.2 78.66,117.7 78.84,117.88 79.47,117.88 v2(79.8,117.55) ; C96785.2 85.55,115.05 C96782.2 85.55,114.3 85.42,114.17 U6544.14 ; 85.29,109.6 85.04,109.86 C96784.2 85.04,110.48 84.68,110.84 84.68,111.48 84.48,111.67 U6544.9 ; v2(79.8,117.55) 80.06,117.55 80.51,118.01 82.85,118.01 83.13,118.28 83.66,118.28 83.99,117.95 83.99,117.5 83.87,117.37 R68551.2 ; v2(79.8,117.55) 79.8,117.06 R69002.2
  TOP w0.254: v1(88.06,114.7) 88.06,114.96 87,116.02 85.43,116.02 85.25,115.84 C96785.2
  TOP w0.381: v2(85.32,109.6) 85.29,109.6 85.13,109.44 R68563.2 84.41,108.14 R68562.2 84.41,106.57 v2(84.7,106.27)
  IN2 w0.381: v1(88.06,114.7) 88.06,114.88 86.84,116.1 81.25,116.1 v2(79.8,117.55)
  IN4 w0.254: v2(84.7,106.27) 84.11,106.87 v1(81.9,106.87)
  BOTTOM w0.381: v2(85.32,109.6) 85.32,110.33 85.11,110.54 85.11,113.46 87.12,115.47 87.68,115.47 88.06,115.08 v1(88.06,114.7)
+3V_USB_D: length 3.5
  TOP w0.203: U6544.21 79.83,115.7 79.67,115.85 79.12,115.85 v2(79.01,115.74) 78.76,115.49 78.18,115.49 77.82,115.85 R68550.1
+3V_WLAN: length 3.3
  BOTTOM w0.381: Q6600.3 199.58,116.9 v2(199.11,117.37) 199.11,117.73 199.94,118.55 R68756.1
+3V_WLAN_P: length 30.1
  TOP w0.203: Q63.2 186.09,110.63 186.28,110.82 Q33.2 185.35,111.41 184.73,110.8 R651.2 R652.2
  TOP w0.254: 185.59,111.41 185.59,112.42 183.89,114.12 183.89,118.21 184.2,118.51 184.2,121.56 185.08,122.45 186.99,122.45 187.71,123.17 192.05,123.17 v2(193.46,121.76)
  BOTTOM w0.203: C96871.2 194.48,104.92 R672.2 ; R671.2 194.2,108.26 193.47,108.99 v2(193.47,109.24)
  vias: v2(193.21,105.18) v2(193.21,104.52) v2(193.49,111.5) v2(193.89,105.18) v2(193.87,104.49) v2(194.13,121.76) v2(194.86,121.76) v2(195.56,121.76) v2(196.24,121.76)
+3VLCD_CON: length 44.5
  TOP w0.508: v2(52.83,178.69) 52.42,178.28 52.42,176.26 54.54,174.14 R69073.1
  IN1 w0.508: v1(76.2,191.69) 75.03,190.52 72.69,190.52 72.05,191.16 61.39,191.16 60.12,189.89 60.12,185.32 61.84,183.59 61.84,181.84 59.94,179.93 59.13,179.93 56.33,177.14 53.72,177.14 52.83,178.03 v2(52.83,178.69)
  vias: v2(76.98,191.97)
+3VLCD_CON_R:
  vias: v2(73.32,192.1) v2(73.88,190.98) v2(74.04,191.74)
+3VLCD_CON_R_C: length 2.4
  TOP w0.305: R25456.2 75.86,192.44 v2(75.24,191.83)
  BOTTOM w0.305: CN29.37 74.65,192.17 74.99,191.83 v2(75.24,191.83)
+3VPCU: length 484.6
  TOP w0.203: v2(172.13,130.71) 172.26,130.83 173.02,130.83 173.3,130.55 PR6003.1 ; Q6642.1 232.4,124.53 231.85,125.07 C96918.1 R69043.1 ; R68459.2 90.37,122.51 v1(89.96,122.92)
  TOP w0.254: v1(83.02,121.6) 82.32,122.3 80.79,122.3 80.31,121.82 74.59,121.82 72.31,119.53 72.31,116.86 73.71,115.47 73.71,110.82 75.08,109.45 75.08,106.73 74.65,106.3 74.65,103.32 73.31,101.99 v2(73.31,99.72) ; PR8058.1 19.86,114 v2(19.68,114.18) 18.86,113.36 PR8037.2 ; PR8048.2 26.23,115.14 26.33,115.14 v2(26.73,114.73) ; PR8038.1 32.05,116.33 32.25,116.54 32.25,117.19 v2(32.43,117.37)
  TOP w0.305: v2(134.87,100.73) 134.87,101.06 137.24,103.43 137.24,105.13 137.89,105.79 137.89,107 139.22,108.32 139.71,108.32 141.9,110.51 147.34,110.51 147.52,110.69 R25323.2
  TOP w0.381: PR8011.1 53.73,196.91 v2(53.94,196.69) 54.07,196.69 PR8019.1 ; v2(16.17,76.98) 17.19,78 R69093.1 C96929.1 18.19,78.56 Q6655.1 ; R68503.2 104.95,111.03 104.95,109.62 104.19,108.86 104.19,107.46 103.8,107.08 103.17,107.08 102.61,106.52 102.61,103.22 101.39,102 100.96,102 v1(100.58,101.62) ; v2(51.92,195.54) 50.9,194.53 49.48,194.53 44.37,189.42 44.37,187.86 43.96,187.45 v2(43.96,185.33)
  TOP w0.508: Q6642.1 232.4,123.6 231.88,123.09 v2(230.3,123.09) ; v2(113.2,108.02) 113.2,109.62 113.11,109.72 R68495.2 113.11,110.8 113.96,111.66 113.96,112.42 113.71,112.67 R68508.2 ; R25519.1 149.91,209.32 149.19,208.61 v2(149.02,208.61) ; v2(25.47,26.5) R736.1 ; R25295.1 114.46,104.17 v2(114.47,104.16)
  IN1 w0.254: v1(89.96,122.92) 85.9,122.92 85.81,122.83 83.74,122.83 83.02,122.11 v1(83.02,121.6)
  IN1 w0.381: v1(156.23,115.49) 156.23,115.82 156.68,116.27 157.67,116.27 158.26,115.67 161.51,115.67 162.35,114.83 163.62,114.83 164.26,115.47 v2(164.26,115.47)
  IN1 w0.508: v2(32.3,172.62) 32.3,173.12 33.57,174.39 34.59,174.39 35.1,174.9 36.37,174.9 38.65,177.19 40.03,177.19 43.96,181.12 v2(43.96,185.33) 44.77,186.14 50.76,186.14 54.37,189.75 56.4,189.75 57.93,191.28 59.8,191.28 60.62,192.11 63.79,192.11 66.46,194.78 70.85,194.78 71.67,193.95 76.5,193.95 77.93,192.52 77.93,191.31 80.37,188.87 87.41,188.87 87.66,188.63 v2(88.7,188.63) 88.73,188.65 88.73,189.24 89.57,190.09 92.43,190.09 93.32,189.2 97.38,189.2 97.94,188.64 100.22,188.64 101.19,187.68 105.89,187.68 106.8,186.76 108.9,186.76 109.28,187.14 111.96,187.14 112.06,187.25 113.96,187.25 114.63,187.91 115.87,187.91 115.92,187.86 116.73,187.86 118.89,190.01 120.19,190.01 121.33,191.16 121.33,199.03 121.71,199.41 121.71,205.97 123.03,207.29 123.95,207.29 124.84,208.18 131.24,208.18 133.09,210.03 138.53,210.03 139.07,209.49 142.14,209.49 142.31,209.32 144.06,209.32 144.19,209.45 148.64,209.45 149.02,209.06 v2(149.02,208.61) ; v2(13.15,43.2) 12.57,43.79 12.57,45.79 10.26,48.1 10.26,49.88 8.94,51.2 v1(3.27,51.2) ; v2(12.87,59.2) 12.87,57.81 14.78,55.9 14.78,54.12 19.73,49.17 19.73,47.77 20.85,46.66 21.92,46.66 22.22,46.96 24.76,46.96 26.08,48.28 v2(28.24,48.28)
  IN2 w0.381: v2(53.94,196.69) 52.79,195.54 v2(51.92,195.54)
  IN2 w0.508: v2(230.3,123.09) 226.23,123.09 225.72,123.59 223.18,123.59 222.49,122.89 222.49,122.26 221.98,121.75 220.96,121.75 220.39,121.18 218.1,121.18 217.09,120.16 215.31,120.16 ; v2(170.23,131.09) 171.11,131.09 171.5,130.71 v2(172.13,130.71) 172.38,130.96 174.92,130.96 176.96,132.99 178.86,132.99 180.64,134.77 184.2,134.77 185.59,133.37 187.12,133.37 192.33,128.16 196.22,128.16 ; v1(3.27,51.2) 4.11,51.2 5.76,52.85 6.65,52.85 9.13,55.33 10.14,55.33 12.87,58.06 v2(12.87,59.2) 12.87,59.27 14.65,61.05 14.65,64.67 14.04,65.27 14.04,72.39 12.49,73.94
  IN3 w0.508: v2(25.47,26.5) 27.41,26.5 28.11,27.2 31.29,27.2 32.3,28.22 32.3,34.19 32.56,34.44 32.56,36.98 32.3,37.23 32.3,43.08 28.24,47.14 v2(28.24,48.28)
  IN4 w0.508: v2(169.21,122.25) 169.21,122.45 168.83,122.83 168.83,130.32 169.59,131.09 v2(170.23,131.09)
  BOTTOM w0.203: v1(3.27,51.2) 3.63,50.85 R69010.1 ; R68752.1 R68751.1 206.78,116.13 207.06,116.4 207.06,117.1 206.93,117.23 v2(206.87,117.23) ; v2(88.7,188.63) 88.73,188.63 88.92,188.81 R25368.2 R25370.1
  BOTTOM w0.254: v1(97.89,101.62) 97.89,102.84 97.34,103.39 R68919.2 ; v2(230.3,123.09) 229.87,123.09 229.75,122.96 CN55.5 ; CN52.2 210.35,101.74 210.61,102 v2(210.61,103.27)
  BOTTOM w0.305: CN48.6 209.95,114.04 210.61,114.7 v2(210.61,115.59)
  BOTTOM w0.381: v2(12.87,59.2) 13.38,59.2 13.77,59.59 Q6602.2 ; R68917.1 v2(212.27,119.4) ; PR204.2 156.03,115.51 156.21,115.51 v1(156.23,115.49) ; Q6603.2 28.16,48.2 v2(28.24,48.28)
  BOTTOM w0.508: PR9.2 PR18.2 163.37,114.77 PR15.2 163.99,114.95 164.26,115.21 v2(164.26,115.47) 164.26,115.47 165.91,115.47 166.6,116.16 166.6,117.17 167.33,117.9 167.33,118.54 168.45,119.66 168.45,121.49 v2(169.21,122.25) ; v2(112.44,97.56) 114.85,99.97 114.85,103.78 v2(114.47,104.16) 114.47,105.51 113.56,106.42 113.56,107.67 v2(113.2,108.02) ; R69056.1 12.62,44.12 13.15,43.58 v2(13.15,43.2)
  vias: v2(16.43,116.1) v2(16.38,115.41) v2(27.94,68.93) v2(28.6,68.93) v2(33.04,172.84) v2(39.11,167.61) v2(39.11,166.93) v2(42.62,117.67) v2(42.64,117.01) v2(42.64,116.35) v2(53.89,100.3) v2(54.55,100.3) v2(55.21,100.3) v2(73.32,98.96) v2(74.01,100.76) v2(79.17,98.57) v2(195.97,127.37) v2(196.66,127.38) v2(197.45,130.14) v2(198.13,130.16)
+3VPCU_EC: length 170.6
  TOP w0.203: U37.92 168.42,107.94 168.7,108.23 ; v1(159.89,113.61) 159.87,113.61 159.74,113.48 C6575.1 159.41,112.65 159.06,112.3 U37.114 ; v2(170.48,96.29) 170.38,96.19 C6570.1 ; v2(160.37,96.69) 160.26,96.58 U37.50 ; v1(153.84,112.88) 154.43,112.88 C6574.1 154.48,112.54 154.76,112.26 156.03,112.26 156.26,112.03 U37.121 ; v2(147.62,98.24) 147.62,98.45 147.92,98.75 148.51,98.75 148.84,98.42 C6577.1 C6578.1 149.98,98.42 150.54,98.98 150.54,99.11 150.97,99.54 U37.26
  TOP w0.254: L29.1 173.53,100.86 174.24,100.15 176.22,100.15 176.65,99.72 176.65,97.61 v2(176.63,97.58) ; v1(149.37,112.39) 149.4,112.39 149.89,111.9 L30.2
  IN1 w0.508: v1(159.89,113.61) 159.89,113 159.43,112.54 154.18,112.54 v1(153.84,112.88)
  IN2 w0.508: v2(173.55,112.24) 173.38,112.06 173.38,111.02 173.53,110.87 173.53,110.31 172.28,109.06 v2(169.34,109.06) ; v2(205.61,102.05) 205.61,100.15 205.91,99.84 205.91,97.56 204.52,96.16 203.35,96.16 202.84,96.67 196.78,96.67 195.51,97.94 193.97,97.94 193.09,97.05 190.42,97.05 190.16,97.3 184.27,97.3 183.59,97.99 182.34,97.99 181.27,96.92 176.5,96.92 ; v2(160.37,96.69) 161.97,95.09 169.29,95.09 v2(170.48,96.29) 170.48,96.42 170.99,96.92 176.5,96.92 ; 176.5,96.92 176.63,97.05 v2(176.63,97.58)
  IN3 w0.508: v1(159.89,113.61) 159.91,113.64 159.91,114.42 160.19,114.7 162.81,114.7 163.12,114.39 165.34,114.39 165.78,114.83 169.36,114.83 169.87,115.34 171.24,115.34 171.7,114.88 171.7,112.14 172.33,111.5 172.82,111.5 v2(173.55,112.24) 174.75,113.43 178.53,113.43 179.9,114.8 184.22,114.8 186.36,112.67 188.26,112.67 188.77,112.16 191.66,112.16 194.74,109.09 195.47,109.09 196.21,108.35 198.42,108.35 199.44,109.37 202.23,109.37 202.48,109.12 v2(202.48,108.86)
  IN4 w0.508: v2(202.48,108.86) 203.14,108.2 203.14,105.66 205.61,103.2 v2(205.61,102.05)
  BOTTOM w0.305: v1(153.84,112.88) 151.64,112.88 151.15,112.39 v1(149.37,112.39)
  BOTTOM w0.508: v2(160.37,96.69) 160.37,96.36 160.03,96.02 156.27,96.02 154.35,97.94 149.91,97.94 149.14,97.18 148.25,97.18 147.62,97.81 v2(147.62,98.24)
  vias: v2(168.83,108.35)
+3VPCU_ECPLL: length 5.4
  TOP w0.203: U37.127 153.86,112.02
  TOP w0.254: L30.1 150.33,112.85 C6573.1 151.51,112.85 151.79,112.57 151.79,112.14 v2(152.01,111.91) 152.29,112.19 153.69,112.19 153.86,112.02
+3VPCU_GMR: length 226.5
  TOP w0.203: C96343.1 137.71,211.73 137.93,211.95 U6525.3
  TOP w0.381: 137.84,211.86 137.84,210.59 138.93,209.49 v2(138.93,208.94) 138.93,207.75 137.74,206.55 136.56,206.55 135.94,205.94 v2(135.94,204.76)
  TOP w0.508: v1(80.69,101.75) 81.58,100.86 v1(81.58,100.48) 81.58,100.35 81.11,99.89 R68986.2 R68985.2
  IN1 w0.305: v2(76.2,188.24) 76.25,188.19 76.25,187.6 76.88,186.97 78.53,186.97 78.89,186.61 82.44,186.61 82.85,186.2 83.36,186.2 86.91,182.65 88.06,182.65 89.25,181.45 89.78,181.45 90.09,181.76 90.09,182.39 91.07,183.38 91.07,183.88 93.77,186.59 97.33,186.59 98.47,185.44 100.38,185.44 101.39,184.43 v2(101.9,184.43) ; v2(109.16,183.16) 109.52,183.51 110.82,183.51 111.09,183.79 113.05,183.79 113.23,183.97 114.24,183.97 114.45,184.17 118.54,184.17 119.22,184.86 122.65,184.86 123.49,185.7 123.49,186.59 124.38,187.47 124.38,189.38 124.76,189.76 124.76,194.08 125.39,194.71 125.39,195.48 125.14,195.73 125.14,196.87 127.3,199.03 127.3,201.7 127.93,202.33 127.93,203.68 128.37,204.11 135.29,204.11 v2(135.94,204.76)
  IN4 w0.305: v2(101.9,184.43) 103.68,184.43 104.57,185.32 107.28,185.32 109.16,183.44 v2(109.16,183.16)
  IN4 w0.508: v2(81.54,174.96) 80.08,176.43 72.82,176.43 71.8,177.44 71.8,178.71 69.77,180.74 69.77,181.89 68.24,183.41 66.47,183.41 66.06,183.82 66.06,186.05 66.59,186.59 68.75,186.59 69.26,187.09 69.26,188.36 69.51,188.62 70.78,188.62 71.17,189 71.17,189.51 71.55,189.89 74.59,189.89 76.2,188.29 v2(76.2,188.24)
  BOTTOM w0.305: v1(81.58,100.48) 81.86,100.2 83.33,100.2 83.74,100.61 85.52,100.61 85.65,100.47 CN4.4
  BOTTOM w0.508: v1(80.69,101.75) 79.93,102.51 79.93,103.65 78.91,104.67 78.91,105.43 79.93,106.45 79.93,107.97 79.38,108.52 79.38,109.55 79.55,109.72 79.55,110.51 79.17,110.89 79.17,113.31 77.77,114.7 77.77,116.35 78.79,117.37 78.79,120.16 79.42,120.8 81.28,120.8 82.21,121.74 82.21,124.1 83.23,125.12 86.53,125.12 87.29,125.88 87.29,126.77 82.21,131.85 82.21,173.12 81.54,173.8 v2(81.54,174.96)
+4.6V_PD_C1: length 18.5
  TOP w0.114: PU8001.5 36.35,108.46 36.06,108.18 v2(34.97,108.18)
  TOP w0.381: PR8063.2 24.61,109.89 v2(24.27,110.22)
  TOP w0.508: PU8001.5 36.35,109.51 34.89,110.98 33.84,110.98 33.54,111.27 PC8009.1 33.16,111.27 32.61,111.27 32.59,111.29 PC8010.1 31.84,110.61 PR8053.1 30.13,110.31 PQ8017.3 29.31,110.57 v2(28.51,111.37)
  BOTTOM w0.381: v2(24.27,110.22) 25.42,111.37 v2(28.51,111.37)
+5V: length 119.1
  TOP w0.203: R68792.1 230.55,94.51 230.36,94.7 Q6604.1 ; v2(12.75,156.99) 12.78,157.03 12.96,157.03 12.97,157.02 R25528.1 ; R25529.1 10.08,161.49 v2(9.85,161.72)
  TOP w0.254: v2(207.44,94.38) 207.06,94 206.53,94 206.4,94.13 CN66.6
  TOP w0.381: v2(229.39,95.64) Q6604.1
  TOP w0.508: R67565.1 57.73,94.7 v2(57.73,93.62)
  IN1 w0.381: v2(22.15,150.74) 21.39,150.74 17.67,154.47 15.27,154.47 v2(12.75,156.99) 11.98,157.76 11.98,159.03 9.85,161.16 v2(9.85,161.72)
  IN4 w0.508: v2(222.42,108.1) 223.44,108.1 225.47,106.07 225.47,103.4 227.63,101.24 227.63,97.4 v2(229.39,95.64)
  IN4 w1.016: 20.02,135.37 19.23,134.59 19.23,124.11 18.33,123.21 18.33,119.48 19.82,117.99 19.82,115.88 20.9,114.79 20.9,112.53 18.94,110.57 18.94,108.56 18.74,108.35 18.74,98.85 17.95,98.07 17.95,93.24 18.44,92.76 18.44,88.59 18.11,88.26 18.11,78.91 17.06,77.87 14.78,77.87 13.32,76.41 v2(13.32,76.21) v2(13.32,75.33)
  BOTTOM w0.203: v2(214.55,122.35) 214.55,122.07 214.34,121.86 R579.1
  BOTTOM w0.381: Q30.1 215.12,123.27 214.8,122.96 C734.2 213.92,123.35 214.17,123.59 v2(214.55,123.59) ; R25373.1 169.31,123.24 169.9,122.65 169.9,121.74 169.08,120.93 169.08,119.28 167.98,118.17 v2(167.98,116.66)
  vias: v1(73.66,189.28) v2(3.3,45.87) v2(3.3,45.11) v2(10.46,33.18) v2(11.09,33.6) v2(21.25,136.79) v2(21.25,136.13) v2(21.25,135.47) v2(21.51,150.14) v2(21.91,136.79) v2(21.91,136.13) v2(22.77,151.15) v2(22.79,150.46) v2(24.46,40.71) v2(25.13,40.74) v2(30.25,160.8) v2(30.38,176.95) v2(30.95,176.58) v2(30.86,161.06) v2(30.91,160.32) v2(30.91,159.28) v2(31.42,177.07) v2(31.54,161.24) v2(31.54,160.58) v2(31.54,159.92) v2(32.2,159.92) v2(37.13,192.81) v2(37.89,192.81) v2(62.25,195.87) v2(62.58,195.28) v2(62.94,195.86) v2(167.31,116.66) v2(222.93,109.37) v2(223.31,110) v2(223.9,110.39)
+5V_FAN:
  vias: v2(173.48,111.12)
+5V_HDD: length 6.7
  TOP w0.381: R69046.2 219.38,106.57 219.87,106.08 222.82,106.08 223.57,106.83 225.6,106.83
  vias: v2(225.83,105.99) v2(226.26,104.82) v2(226.61,104.21) v2(227.07,104.82) v2(227.38,104.21)
+5V_HDMIC:
  vias: v2(13.14,132.84) v2(13.58,132.21) v2(13.91,132.86) v2(14.27,132.2) v2(14.85,133.19) v2(17.83,131.47)
+5V_KB:
  vias: v2(218.13,121.41)
+5V_PD: length 6.8
  TOP w0.381: 27.73,110.63 27.24,111.12 PQ8018.4
  TOP w0.508: 27.73,110.63 28.59,109.77 29.29,109.77 29.64,109.43 PD8005.1 29.65,107.42 PR8051.2
+5V_PVDD: length 4.7
  BOTTOM w0.203: 19.71,38.3 19.34,37.93 19.34,36.63 19.51,36.46 U20.41 ; 22.27,36.85 21.51,36.09 U20.46
  vias: v2(22.3,37.46)
+5V_S5: length 318.1
  TOP w0.203: R68489.1 90.29,104.55 v1(90.52,104.32) ; PR5016.2 91.13,179.6 91.01,179.73 90.9,179.73 90.47,180.16 90.47,180.62 PR5011.1 ; PR9091.2 168.95,157.37 169.35,157.77 v3(169.69,157.77)
  TOP w0.381: PR5011.1 90.1,181.65 89.73,182.01 v2(89.45,182.01) ; v2(77.13,188.24) 77.13,188.62 77.39,188.87 78.4,188.87 79.65,190.12 v2(79.65,190.4) 79.62,190.42 79.62,192.12 v2(80.16,192.66)
  TOP w0.508: PR9001.1 105.42,200.74 v2(106.16,200.74) ; v2(159.68,151.23) 159.68,150.52 160.32,149.88 160.32,149.37 PR7008.2 160.05,148.96 PR7002.2 ; v2(158.54,168.06) 158.54,168.16 158.92,168.55 PR9100.1
  IN1 w0.381: v2(89.45,182.01) 88.31,183.16 87.04,183.16 83.48,186.71 82.98,186.71 82.62,187.07 79.19,187.07 78.79,187.47 77.26,187.47 77.13,187.6 v2(77.13,188.24)
  IN1 w0.508: v2(80.16,192.66) 80.16,192.71 76.59,196.27 63.84,196.27 63.55,196.56 55.46,196.56 54.63,197.38 49.19,197.38 48.76,196.95 v2(48.76,195.52)
  IN2 w0.508: v2(80.16,192.66) 80.13,192.68 80.13,193.34 80.49,193.7 81.39,193.7 83.42,195.73 83.52,195.83 90.01,195.83 94.41,200.23 97.26,200.23 98.72,201.7 102.53,201.7 103.49,200.74 v2(106.16,200.74) 106.16,200.23 106.73,199.67 107.23,199.67 107.61,199.29 107.61,198.65 107.34,198.37 106.32,198.37 105.84,197.89 105.84,196.87 104.19,195.22 104.19,194.43 104.57,194.05 104.57,192.83 v2(104.31,192.58) ; v2(119.93,179.35) 119.93,179.6 120.82,180.49 124.76,180.49 125.12,180.84 128.82,180.84 129.61,180.06 129.61,176.15 130.37,175.38 131.39,175.38 132.76,174.01 137.97,174.01 138.35,174.39 v2(138.35,174.77)
  IN3 w0.254: v2(217.16,110.17) 217.16,110.31 213.41,114.07 213.41,115.97 210.99,118.39 206.55,118.39 206.04,118.89 v2(206.04,119.4)
  IN3 w0.508: v2(104.31,192.58) 104.47,192.43 108.25,192.43 108.63,192.81 114.57,192.81 117.93,189.46 117.93,186.08 118.28,185.72 118.28,181 v2(119.93,179.35) ; v2(48.76,195.52) 46.14,192.91 46.14,190.27 44.24,188.36 44.24,186.97 44.6,186.61 44.6,185.06 43.1,183.56 43.1,180.2 40.73,177.83 40.73,176.14 34.34,169.74 34.34,165.88 34.46,165.76 34.46,164.08 33.76,163.38 33.76,162.14 36.05,159.85 v2(36.05,159.29) ; v2(158.54,168.06) 158.54,168.09 158.54,168.09 158.54,168.81 158.16,169.19 156.13,169.19 155.24,168.3 152.06,168.3 150.97,169.39 142.97,169.39 138.48,173.89 138.48,174.65 v2(138.35,174.77)
  IN4 w0.508: v2(162.58,130.04) 162.58,132.51 161.46,133.63 161.46,134.64 161.06,135.05 v2(160.32,135.05) 158.16,137.21 158.16,138.22 157.96,138.43 157.96,139.39 158.39,139.82 160.17,139.82 161.84,141.5 161.84,144.17 162.48,144.8 162.48,147.09 161.59,147.98 161.59,150.9 160.83,151.66 160.12,151.66 v2(159.68,151.23) 159.43,151.48 159.43,152.42 160.57,153.57 160.57,155.85 161.34,156.61 164.76,156.61 165.78,157.63 165.78,159.53 166.86,160.61 ; v2(158.54,168.06) 158.54,168.06 165.1,168.06 166.86,166.31 166.86,160.61 ; v3(169.69,157.77) 168.89,158.58 168.89,159.47 168.58,159.78 167.68,159.78 166.86,160.61
  BOTTOM w0.203: v2(162.58,130.04) 162.47,130.15 162.44,130.15 PR7086.1
  BOTTOM w0.254: v2(206.04,119.4) 205.79,119.66 204.9,119.66 204.64,119.91 R68915.1
  BOTTOM w0.508: v3(169.69,157.77) 169.65,157.82 169,157.82 PR9087.1 ; PR7072.2 159.85,135.05 v2(160.32,135.05) ; PR9013.1 104.84,193.1 v2(104.31,192.58) 104.94,191.95 PR9074.1
  vias: v2(22.58,93.65) v2(22.58,92.99) v2(23.26,93.65) v2(23.26,92.99) v2(27.1,100.81) v2(27.1,100.12) v2(27.83,100.83) v2(27.81,100.12) v2(33,112.59) v2(32.98,111.93) v2(33.64,111.95) v2(33.66,112.62) v2(33.87,110.29) v2(34.73,159.29) v2(34.73,158.63) v2(34.73,157.97) v2(35.39,159.29) v2(35.39,158.63) v2(35.39,157.97) v2(35.41,109.37) v2(36.05,158.63) v2(36.05,157.97) v2(43.18,100.58) v2(43.23,99.41) v2(43.84,100.58) v2(43.9,99.41) v2(44.56,99.41) v2(45.28,99.44) v2(217.59,109.5) v2(217.82,110.12) v2(218.13,109.11) v2(218.49,110.17) v2(219.15,110.3) v2(219.78,110.53)
+5V_SMARTCARD: length 23.1
  TOP w0.203: C20045.2 223.98,100.26 C20044.1 223.98,101.61 v2(223.81,101.77) ; U6509.4 222.41,93.63 222.55,93.49 223.72,93.49 C20039.1 223.72,92.99 v2(223.18,92.99)
  TOP w0.381: R68791.2 226.49,98.83 v2(226.23,99.08) ; U6509.13 222.11,99.48 222.61,99.98
  TOP w0.508: C20045.2 222.73,100.1 222.61,99.98
  IN4 w0.508: v2(223.18,92.99) 223.69,93.49 225.72,93.49 226.74,94.51 226.74,98.57 v2(226.23,99.08) 226.23,99.69 225.57,100.35 224.62,100.35 223.81,101.16 v2(223.81,101.77)
+5V_SMARTCARD_R: length 9
  TOP w0.114: C96788.2 224.53,91.33 224.62,91.24 C96789.2 225.62,91.24 225.65,91.21 C96790.2 226.27,93.28 226.74,93.75 Q6604.3 227.39,94.75 v2(226.68,95.46) 226.49,95.65 R68791.1
+5V_TCSS: length 77.5
  TOP w0.203: R68835.1 203.85,118.8 203.63,119.02 v2(203.63,119.38) ; v2(167.05,140.74) 167.05,139.6 167.46,139.19 v2(167.46,138.17) ; v2(167.05,140.74) R68854.1 ; v2(167.05,140.74) 167.3,140.74 167.81,141.25 C96891.1 168.48,140.89 168.43,140.85 U6560.5 ; v2(204.85,114.75) 204.85,114.72 204.49,114.36 C96883.1 204.49,113.32 204.5,113.31 U6557.5
  IN1 w0.254: v2(203.5,124.49) 203.49,124.48 202.48,124.48 201.72,125.24 200.07,125.24 198.42,126.9 197.4,126.9 196.9,126.39 194.23,126.39 193.59,127.02 190.04,127.02 189.28,126.26 189.28,126.03 187.85,124.61 179.5,124.61 178.86,125.24 177.97,125.24 177.67,125.55 171.83,125.55 169.34,128.04 169.08,128.04 166.8,130.32 166.8,135.79 165.91,136.67 165.91,138.2 166.03,138.33 166.92,138.33 167.05,138.2 167.43,138.2 v2(167.46,138.17)
  IN3 w0.254: v2(204.85,114.75) 204.85,114.72 204.19,114.07 203.47,114.07 202.99,114.55 202.99,116.48 203.63,117.12 v2(203.63,119.38)
  IN4 w0.254: v2(203.5,124.49) 204.13,123.86 204.13,122.2 203.63,121.69 v2(203.63,119.38)
  BOTTOM w0.254: v2(203.63,119.38) 203.6,119.38 203.53,119.3 202.59,119.3 202.35,119.54 R68915.2 201.35,119.91 R68914.2
+5V_TP: length 6
  TOP w0.381: Q6591.3 72.94,186.59 72.84,186.48 71.78,186.48 71.24,187.02 v2(71.24,188.24) 71.24,189.49 R25462.1
+5VA:
  vias: v2(14.4,28.09)
+5VPCU: length 256.5
  TOP w0.203: R417.1 15.95,97.68 15.95,98.56 16.1,98.71 16.1,98.98 R418.1 16.13,99.63 16.68,100.18 16.68,101.37 17.9,102.59 18.64,102.59 18.71,102.51 v2(20.11,102.51) ; v2(37.32,169.47) 36.01,169.47 PR6023.2 ; R69047.1 C96920.1 216.83,104.67 v2(217.09,104.92) ; PR9069.1 88.88,185.1 v2(89.33,184.65)
  TOP w0.381: v2(217.09,104.92) 217.15,104.99 Q6644.1 ; PR6013.2 207.06,129.56 v2(208.15,130.66) ; v2(28.37,107.59) PR8049.1
  IN1 w0.508: v1(26.59,41.17) 26.59,35.2 24.18,32.79 24.18,29.99 26.46,27.71 26.46,23.88 16.62,14.04 12.7,14.04 12.39,13.74 12.11,13.74 9.93,11.55 v2(9.93,11.33)
  IN1 w1.524: 197.31,128.66 189.65,128.66 188.13,127.15 188.13,126.51 187.42,125.8 179.96,125.8 179.34,126.42 178.45,126.42 177.21,127.66 174.67,127.66 173.15,129.18 169.72,129.18 168.7,130.2
  IN2 w1.524: 102.53,181.76 102.74,181.56 102.74,179.17 104.34,177.57 104.34,176.73 105.86,175.21 106.77,175.21 106.97,175 109.05,175 109.15,174.9 116.84,174.9 116.99,174.75 118.13,174.75 120.04,172.84 127.2,172.84 128.62,171.42 140.15,171.42 143.21,168.35 147.75,168.35 148.69,169.29 152.56,169.29 153.65,168.2 155.57,168.2 156.74,167.03 157.58,167.03 158.41,166.19 158.41,158.52 160.07,156.87 160.07,153.18 161.72,151.53 161.72,147.34 163.11,145.95 163.88,145.95 165.43,144.4 167.33,144.4 168.07,143.66 168.07,140.1 168.83,139.34 168.83,137.21 167.3,135.68 167.3,131.85 v2(167.56,131.59)
  IN4 w0.381: v2(224.09,126.28) 228.03,126.28 229.41,127.66 229.92,127.66 230.42,127.15 230.42,124.23 229.03,122.83 229.03,119.53 231.82,116.74 231.82,112.54 228.09,108.81 222.12,108.81 218.99,105.69 217.85,105.69 v2(217.09,104.92)
  BOTTOM w0.203: R68694.1 23.42,43.58 22.65,43.58 22.4,43.84 R68697.1
  BOTTOM w0.381: v2(24.02,100.57) 24.02,101.2 23.62,101.59 21.03,101.59 v2(20.11,102.51) ; v2(206.8,124.86) 205.79,123.85 204.64,123.85 204.39,123.59 204.39,122.58 202.49,120.68 R68914.1
  vias: v1(25.95,41.81) v2(5.33,47.27) v2(6.01,47.27) v2(6.78,47.27) v2(7.54,47.27) v2(7.79,48.03) v2(23.36,99.84) v2(24.02,99.87) v2(24.43,99.21) v2(24.68,100.56) v2(24.68,99.87) v2(28.37,113.59) v2(28.37,112.93) v2(33.04,164.89) v2(33.04,164.23) v2(33.7,164.89) v2(33.7,164.23) v2(37.2,164.92) v2(37.2,164.24) v2(37.83,165.17) v2(37.83,164.45) v2(39.84,180.74) v2(40.29,181.24) v2(40.38,180.31) v2(40.79,181.69) v2(40.85,180.79) v2(41.83,176.43) v2(42.34,176.93) v2(42.84,177.44) v2(90.22,188.62) v2(103.89,186.93) v2(104.55,186.93) v2(167.56,130.83) v2(168.32,131.59) v2(168.32,130.83) v2(223.4,126.36) v2(223.81,126.88)
+A3VPCU: length 5.2
  TOP w0.203: v2(169.87,101.01) 169.54,101.01 169.27,100.74 U37.74
  TOP w0.254: v2(169.87,101.01) 170.12,101.01 170.15,100.99 C96797.1 C6566.1 172,100.99 172.13,100.86 L29.2
+V3.3DX_RT_TCP0:
  vias: v2(29.84,66.9)
+V3A_LX: length 1.2
  BOTTOM w0.114: PC6001.2 181.79,134.74 v2(182.19,134.74)
+V3A_LX_R: length 2.5
  BOTTOM w0.508: PR6001.2 181.21,124.39 181.18,124.36 v2(180.75,124.36) 180.05,125.06 PC6006.1
+V3A_OUT: length 0.9
  BOTTOM w0.203: PR6008.2 193.65,127.23 193.14,127.74 193.14,127.85
  vias: v2(188.56,127.45)
+V5P5A_LX: length 0.9
  TOP w0.508: v1(51.66,179.47) 51.52,179.34 PR6019.1
  vias: v2(54.3,180.31)
+V5P5A_LX_R: length 2
  TOP w0.508: PC6038.1 50.35,179.61 v2(50.34,179.6) 50.32,179.58 PR6019.2
+V5P5A_OUT: length 0.9
  BOTTOM w0.203: 45,179.2 44.89,179.1 PR6026.2
  vias: v2(43.58,185.95)
+VCC0P9_LC_TCP0: length 1.6
  TOP w0.203: U6549.J3 v5(22.27,64.86)
  BOTTOM w0.114: v5(22.27,64.86) 22.93,64.19 C96824.2
+VCC0P9_LVR_TCP0: length 4.2
  TOP w0.203: v5(20.3,65.52) 20.44,65.52 U6549.L6 U6549.M6
  BOTTOM w0.114: v5(20.3,65.52) 20.3,66.25 20.5,66.45 C96825.2 20.5,67.21 20.62,67.32 20.62,67.72 C96826.2
+VCC0V9_SVR_TCP0: length 22.8
  TOP w0.203: U6549.F6 v5(20.32,64.21) U6549.G6 ; U6549.E3 22.27,62.91 v5(22.27,62.89) ; v5(19.03,64.9) 19.03,64.85 U6549.G9 ; v5(22.27,64.2) 22.27,64.21 U6549.G3 ; U6549.E9 v5(19.02,62.91)
  TOP w0.508: v2(27.48,74.7) 27.11,74.33 L4001.2
  IN2 w0.508: v5(19.03,64.9) 18.7,64.9 18.33,64.54 18.33,64.03 18.84,63.52 19.86,63.52 20.32,63.98 v5(20.32,64.21)
  IN4 w0.508: v2(23.54,74.95) 23.54,74.19 22.02,72.67 22.02,70.51 22.52,70 22.52,68.98 21.13,67.59 21.13,67.08
  BOTTOM w0.203: C96834.2 C96831.2
  BOTTOM w0.381: C96831.2 18.47,64.9 ; C96833.2 C96832.2 18.68,63.26 v5(19.02,62.91)
  BOTTOM w0.508: 18.47,64.9 v5(19.03,64.9) ; C96830.2 22.53,62.89 v5(22.27,62.89)
+VCC0V9_SVR_TCP0_PHASE: length 3.1
  TOP w0.508: 25.83,69.49 L4001.1
  vias: v2(26.33,68.22)
+VCC1.05_OUT_FET: length 143.2
  IN2 w0.508: 169.34,129.69 169.34,132.1 171.24,134.01 171.24,135.66 171.88,136.29 v2(172,136.29) ; 169.34,129.69 168.45,128.8 159.68,128.8 157.4,131.09 157.4,132.61 155.62,134.39 152.95,134.39 151.33,136.01 145.74,136.01 145.46,136.29 v2(145.46,138.66) ; 169.34,129.69 173.15,129.69 175.94,126.9 179.62,126.9 180.51,126.01 187.63,126.01 188.77,127.15 193.47,127.15 195.37,125.24 197.53,125.24 198.67,126.39 206.29,126.39 208.2,128.29 210.87,128.29 211.4,127.76 211.4,127.02 210.74,126.36 210.74,124.99 v2(209.85,124.1)
  IN4 w0.508: 133.65,140.61 132.25,142.01 130.98,142.01 128.57,144.42 126.03,144.42 125.27,143.66 124.63,143.66 123.61,142.63 v2(123.61,141.22) 123.61,141.22 v2(124.28,141.22) ; 133.65,140.61 v2(133.65,140.59) ; 133.65,140.61 134.16,141.12 138.6,141.12 139.11,140.61 141.4,140.61 142.59,139.42 145.13,139.42 145.46,139.09 v2(145.46,138.66)
  BOTTOM w0.102: v2(123.61,141.22) 123.56,141.18 U6539.BR3
  BOTTOM w0.203: R68400.2 128.81,126.37 128.81,126.75 128.95,126.9 129.33,126.9 129.84,127.4 129.84,128.55 130.47,129.18 130.73,129.18 131.49,129.94 131.49,134.39 131.85,134.74 131.85,135.48 131.54,135.79 130.86,135.79 130.55,136.09 130.55,137.92 132.34,139.71 132.77,139.71 v2(133.65,140.59)
  BOTTOM w0.508: Q6607.3 209.21,122.96 208.93,123.25 C96882.1 209.47,123.72 v2(209.85,124.1) ; v2(172,136.29) 172,136.93 171.62,137.31 C96892.1 v2(170.7,138.74) 170.27,139.17 Q6609.3
+VCC1.05_OUT_PCH: length 2.6
  TOP w0.102: 109.23,130.45 TP13429.1
  TOP w0.114: 109.23,130.45 109.26,130.42 109.26,129.4 v1(109.7,128.96)
  BOTTOM w0.102: v1(109.7,128.96) 109.57,128.96
+VCC3P3_ANA_TCP0: length 2.5
  TOP w0.203: U6549.L2 22.27,65.51 v5(22.27,65.43)
  BOTTOM w0.114: v2(23.03,66.75) C96819.2
  BOTTOM w0.203: v5(22.27,65.43) 22.78,65.94 C96819.2
+VCC3P3_LC_TCP0: length 20.7
  TOP w0.203: v1(25.47,59.56) 25.73,59.81 26.61,59.81 27.02,60.22 27.2,60.22 27.32,60.35 R68621.2 27.32,60.83 27.68,61.19 27.68,61.82 28.37,62.51 30.91,62.51 31.92,61.49 31.92,60.73 31.03,59.84 30.01,59.84 29.74,60.12 R68623.2
  TOP w0.254: v5(20.97,62.91) U6549.E5
  BOTTOM w0.203: v1(25.47,59.56) 24.46,59.56 24,59.11 R68622.2 23.26,59.11 v2(22.52,59.84) 22.06,60.31 22.06,60.39 21.79,60.65 R68624.2 21.79,61.08 21.46,61.41 21.46,62.42 v5(20.97,62.91) 20.97,63.12 C96820.1
+VCC3V3_SX_TCP0: length 21.6
  TOP w0.178: U6549.M4 21.79,66.82 21.74,66.87 v5(21.74,66.93) 21.69,66.93 21.33,66.57 U6549.M5
  TOP w0.203: R68609.2 16.97,59.87 17.57,60.47 v1(17.8,60.47) ; R68614.2 R68631.2 28.25,60.7 28.11,60.56 28.11,59.84 27.4,59.13 v1(26.17,59.13) ; R68616.2 20.55,58.77 20.87,58.44 v2(21.23,58.44) ; v1(24.54,58.95) 24.42,58.82 24.1,58.82 23.97,58.95 R68617.2 ; R68625.2 16.43,69.75 16.1,69.41 v1(16.1,68.86) ; v5(20.34,62.93) U6549.E6
  IN1 w0.381: v1(17.8,60.47) 17.8,59.99 17.95,59.84 19.1,59.84 19.6,59.33 20.34,59.33 v2(21.23,58.44)
  BOTTOM w0.203: v5(20.34,62.93) 20.37,62.96 C96816.1
  BOTTOM w0.381: v5(21.74,66.93) 21.69,66.93 21.48,67.13 C96818.1 22.46,67.53 22.68,67.75 C96817.1 23.37,67.75 R68879.2 ; v1(16.1,68.86) 15.79,68.86 v2(15.41,68.48) 15.41,67.85 15.67,67.59 R68633.2
  vias: v2(27.91,67.43) v2(28.58,67.43)
+VCC3V3_SX_TCP0_DBRONLY: length 8.1
  TOP w0.203: U6549.J5 21.05,64.94 21.05,64.91 v5(21.02,64.89)
  IN1 w0.089: v5(21.02,64.89) 21,64.91 20.88,64.91 20.67,65.12 20.67,65.66 21.2,66.19 22.12,66.19 22.75,66.82 22.75,67.43 v1(23.74,68.42)
  BOTTOM w0.114: R68879.1 24.82,67.96 v2(24.56,68.22) 23.95,68.22 v1(23.74,68.42)
+VCC3V3A_SX_TCP0: length 5
  TOP w0.203: v5(19.65,65.52) U6549.J7
  BOTTOM w0.381: v5(19.65,65.52) 19.65,65.89 18.97,66.57 C96823.2 18.46,66.57 18.22,66.82 C96821.2 C96822.2 R68633.1
+VCC_V3A: length 1.7
  BOTTOM w0.203: PC6022.1 174.35,130.53 175.11,130.53 175.21,130.43 PU6000.9
+VCC_V5P5A: length 3.9
  BOTTOM w0.203: PU6003.11 57.72,182.41 57.91,182.22 57.91,181.89 v2(58.26,181.53) 58.26,180.32 58.62,179.96 PC6058.1
+VCC_XD: length 27
  IN1 w0.762: 32.31,65.38 29.36,62.43 29.36,56.56 30.55,55.37 30.55,52.19 31.54,51.2 31.54,44.73 32.58,43.68 32.58,42.49
  BOTTOM w0.305: 30.59,64.75 30.26,64.41 U40.5
  vias: v2(31.92,42.95) v2(33.84,42.12) v2(33.94,42.78) v2(34.07,43.44) v2(34.32,66.35) v2(34.32,65.69) v2(34.32,65.03)
+VCCDPHY_1P24: length 4.3
  BOTTOM w0.203: C96767.1 v2(111.42,118.27) 111.5,118.34 111.5,121.58 U6539.DV28
+VCCDSW_1P05: length 3.3
  TOP w0.203: v1(106.84,128.42) 106.84,128.47 107.22,128.85 107.79,128.85 108,129.05 108,129.82 107.95,129.87 C96768.2
  BOTTOM w0.254: U6539.DD38 106.86,128.24 106.86,128.35 106.84,128.37 v1(106.84,128.42)
+VCCFPGM: length 23.4
  TOP w0.203: R68281.1 134.97,153.36 134.36,152.75 C96625.2 134.11,152.98 134.16,153.03 v2(134.16,153.41) 133.8,153.41 133.7,153.31 131.62,153.31 131.36,153.06 131.36,152.43 131.24,152.31 130.46,152.31 130.35,152.42 124.76,152.42 124.11,153.07 122.75,153.07 122.42,153.39 119.25,153.39 v1(118.55,154.1)
  IN2 w0.381: v1(120.21,151.99) 119.17,153.03 119.17,153.69 118.76,154.1 v1(118.55,154.1)
  BOTTOM w0.305: v1(120.21,151.99) 120.19,151.99 119.94,151.75 U6539.AM9 119.49,151.08 U6539.AN10
+VCCIN: length 52.5
  TOP w0.203: v3(143.68,155.22) 143.56,155.34 v2(142.41,155.34) 140.76,155.34 140.63,155.22 PR7052.1
  BOTTOM w0.102: 106.74,140.49 U6539.BT39 ; U6539.BT39 106.74,141.1 ; U6539.BT39 106.43,140.8 ; 111.97,157.15 U6539.W28 ; U6539.W28 111.31,157.15 ; U6539.W28 111.64,156.82 ; U6539.W28 111.64,157.46 ; 118.71,138.73 U6539.BY12 ; U6539.BY12 119.02,138.42 ; U6539.BY12 119.32,138.73 ; U6539.BY12 119.02,139.03 ; U6539.BV12 119.32,139.64 ; U6539.BV12 119.02,139.34 ; U6539.BV12 118.71,139.64 ; U6539.BV12 119.02,139.95 ; 119.94,146.66 U6539.BB9 ; U6539.BB9 119.94,147.27 ; U6539.BB9 120.25,146.96 ; U6539.BB9 119.64,146.96 ; U6539.BA10 119.79,147.42 ; U6539.BA10 119.17,147.42 ; U6539.BA10 119.48,147.11 ; 119.02,144.52 U6539.BH12 ; U6539.BH12 119.32,144.22 ; U6539.BH12 119.02,143.91 ; U6539.BH12 118.71,144.22 ; U6539.BJ40 106.58,144 ; U6539.BJ40 106.27,144.31 ; U6539.BJ40 106.27,143.69 ; 106.74,143.85 U6539.BK39 ; U6539.BK39 106.74,143.24 ; U6539.BK39 106.43,143.54 ; U6539.BT12 119.02,140.86 119.02,140.86 ; U6539.BT12 118.71,140.56 ; U6539.BT12 119.02,140.25 ; U6539.BT12 119.32,140.56 ; 106.43,141.71 U6539.BP39 ; U6539.BP39 106.74,141.41 ; U6539.BP39 107.04,141.71 ; U6539.BP39 106.74,142.02 ; 106.43,144.46 U6539.BH39 ; U6539.BH39 106.74,144.15 ; U6539.BH39 107.04,144.46 ; U6539.BH39 106.74,144.76 ; 113.8,157.15 U6539.W24 ; U6539.W24 113.14,157.15 ; U6539.W24 113.47,156.82 ; U6539.CA10 119.48,138.58 ; U6539.CA10 119.48,137.96 ; U6539.CA10 119.17,138.27 ; 114.05,157.15 U6539.W22 ; U6539.W22 114.71,157.15 ; U6539.W22 114.38,156.82 ; U6539.W22 114.38,157.48 ; 119.79,145.59 U6539.BE10 ; U6539.BE10 119.17,145.59 ; U6539.BE10 119.48,145.9 ; U6539.BE10 119.48,145.28 ; 119.48,141.32 U6539.BR10 ; U6539.BR10 119.17,141.01 ; U6539.BR10 119.48,140.71 ; U6539.BR10 119.79,141.01 ; 119.94,144.83 U6539.BF9 ; U6539.BF9 120.25,145.13 ; U6539.BF9 119.94,145.44 ; U6539.BF9 119.64,145.13 ; U6539.V29 111.18,157.93 ; U6539.V29 110.85,157.61 ; U6539.V29 111.18,157.28 ; 119.64,146.05 U6539.BD9 ; U6539.BD9 120.25,146.05 ; U6539.BD9 119.94,145.74 ; U6539.BD9 119.94,146.35 ; 110.6,157.61 U6539.V31 ; U6539.V31 110.26,157.95 ; U6539.V31 109.93,157.61 ; U6539.V31 110.26,157.28 ; U6539.BC10 119.79,146.51 ; U6539.BC10 119.48,146.81 ; U6539.BC10 119.48,146.2 ; U6539.BC10 119.17,146.51 ; 119.64,144.22 U6539.BH9 ; U6539.BH9 119.94,144.52 ; U6539.BH9 120.25,144.22 ; 106.27,144.61 U6539.BG40 106.58,144.92 ; U6539.BC40 106.58,146.75 ; U6539.BC40 106.27,147.05 ; U6539.BC40 106.27,146.44 ; U6539.BM39 106.74,142.32 ; U6539.BM39 107.04,142.63 ; U6539.BM39 106.43,142.63 ; U6539.BM39 106.74,142.93 ; 119.17,140.1 U6539.BU10 ; U6539.BU10 119.48,139.79 ; U6539.BU10 119.79,140.1 ; U6539.BU10 119.48,140.41 ; U6539.V23 114.26,157.61 ; U6539.V23 113.93,157.28 ; U6539.V23 113.93,157.92 ; 119.02,138.12 U6539.CB12 119.32,137.81 ; 119.48,143.15 U6539.BL10 ; U6539.BL10 119.48,142.54 ; U6539.BL10 119.88,142.85 ; U6539.BL10 119.17,142.85 ; U6539.BL40 106.27,143.39 ; U6539.BL40 106.27,142.78 ; U6539.BL40 106.58,143.09 ; 106.74,146.9 U6539.BB39 ; U6539.BB39 106.43,147.2 ; U6539.BB39 106.74,147.51 ; U6539.V27 112.1,157.93 ; U6539.V27 112.42,157.61 ; U6539.V27 112.1,157.28 ; 106.58,147.66 U6539.BA40 106.27,147.35 ; U6539.W32 109.81,156.82 ; U6539.W32 109.81,157.48 ; U6539.W32 110.14,157.15 ; U6539.BP12 119.32,141.47 ; U6539.BP12 118.71,141.47 ; U6539.BP12 119.02,141.17 ; U6539.BP12 119.02,141.78 ; 106.27,141.56 U6539.BR40 ; U6539.BR40 106.27,140.95 ; U6539.BR40 106.58,141.25 ; 119.48,143.45 U6539.BJ10 ; U6539.BJ10 119.17,143.76 ; U6539.BJ10 119.48,144.07 ; U6539.BJ10 119.79,143.76 ; U6539.BD39 106.74,145.98 ; U6539.BD39 106.43,146.29 ; U6539.BD39 106.74,146.59 ; U6539.BD39 107.04,146.29 ; 106.58,145.83 U6539.BE40 106.27,146.14 ; 106.27,141.86 U6539.BN40 ; U6539.BN40 106.27,142.48 ; U6539.BN40 106.58,142.17 ; 112.68,157.61 U6539.V25 113.01,157.28 ; 119.17,144.68 U6539.BG10 ; U6539.BG10 119.48,144.98 ; U6539.BG10 119.79,144.68 ; U6539.BG10 119.48,144.37 ; 106.8,147.82 U6539.AY39 106.49,147.95 ; 106.58,140.34 U6539.BU40 106.27,140.65 ; 109.35,157.94 U6539.V33 109.68,157.61
  BOTTOM w0.254: U6539.K1 U6539.K2 ; U6539.J1 U6539.J2 U6539.G2
  vias: v1(107.22,146.34) v1(107.22,145.75) v1(107.22,145.17) v1(107.22,144.58) v1(107.26,142.83) v1(107.26,142.25) v1(107.27,141.66) v1(109.82,158.61) v1(109.81,157.99) v1(110.25,162.53) v1(110.25,161.88) v1(110.25,161.23) v1(110.25,160.58) v1(110.25,159.93) v1(110.26,156.72) v1(110.72,158.61) v1(110.72,157.99) v1(111.16,162.53) v1(111.16,161.88) v1(111.16,161.24) v1(111.16,160.6) v1(111.16,159.93) v1(111.18,156.79) v1(111.64,157.94) v1(111.96,168.75) v1(111.96,168.12) v1(111.96,167.47) v1(111.96,166.84) v1(112.09,156.79) v1(112.55,158.59) v1(112.55,157.94) v1(112.98,162.53) v1(112.98,161.88) v1(112.98,161.23) v1(112.98,160.58) v1(112.98,159.93) v1(113.01,156.79) v1(113.13,168.73) v1(113.13,168.11) v1(113.13,167.48) v1(113.13,166.83) v1(113.15,166.2) v1(113.47,158.59) v1(113.88,162.53) v1(113.88,161.89) v1(113.88,161.23) v1(113.88,160.58) v1(113.88,159.93) v1(118.46,147.57) v1(118.48,146.4) v1(118.52,144.19) v1(118.5,142.62) v1(118.5,141.93) v1(118.5,141.17) v1(118.5,140.57) v1(118.5,139.99) v1(118.48,139.4) v1(122.77,161.14) v1(122.98,163.14) v2(132.89,166.14) v2(132.89,165.48) v2(132.89,164.74) v2(133.14,156.11) v2(133.78,166.14) v2(133.78,165.48) v2(133.78,164.74) v2(134.16,155.85) v2(134.28,163.73) v2(134.28,162.96) v2(134.28,162.2) v2(134.28,161.44) v2(134.95,163.73) v2(134.95,162.96) v2(134.95,162.2) v2(134.95,161.44) v2(134.95,155.85) v2(135.61,163.73) v2(135.61,162.96) v2(135.61,162.2) v2(135.61,161.44) v2(135.61,155.85) v2(136.27,163.73) v2(136.27,162.96) v2(136.27,162.2) v2(136.27,161.44) v2(136.27,155.85) v2(136.93,163.73) v2(136.93,162.96) v2(136.93,162.2) v2(136.93,161.44) v2(136.93,155.85) v2(137.59,163.73) v2(137.59,162.96) v2(137.59,162.2) v2(137.59,161.44) v2(137.59,155.85) v3(143.68,162.58) v3(143.68,161.69) v3(143.68,160.8) v3(143.68,159.92) v3(143.68,157.81) v3(143.68,156.92) v3(143.68,155.98) v3(144.44,161.92) v3(144.44,161.06) v3(144.44,160.17) v3(144.44,158.39) v3(144.44,157.5) v3(144.44,156.61) v3(144.44,155.72) v3(144.44,154.84) v3(144.44,153.95)
+VCCIN_AUX: length 27.4
  BOTTOM w0.102: 119.48,148.94 U6539.AU10 ; U6539.AU10 119.17,149.25 ; U6539.AU10 119.48,149.56 ; 106.43,139.88 U6539.BV39 ; U6539.BV39 107.04,139.88 ; U6539.BV39 106.74,139.58 ; U6539.AT12 118.71,149.71 ; U6539.AT12 119.32,149.71 ; U6539.AT12 119.02,150.01 ; U6539.AT12 119.02,149.4 ; 119.48,149.86 U6539.AR10 ; U6539.AR10 119.48,150.47 ; U6539.AR10 119.17,150.17 ; U6539.CF10 119.17,136.44 ; U6539.CF10 119.48,136.75 ; U6539.CF10 119.48,136.13 ; 119.02,132.02 U6539.CR12 ; U6539.CR12 118.71,132.32 ; U6539.CR12 119.32,132.32 ; U6539.CR12 119.02,132.63 ; 118.71,131.41 U6539.CU12 119.02,131.71 ; 118.71,134.15 U6539.CL12 ; U6539.CL12 119.32,134.15 ; U6539.CL12 119.02,133.85 ; U6539.CL12 119.02,134.46 ; 119.17,131.87 U6539.CT10 119.48,132.17 ; 107.04,138.97 U6539.BY39 106.74,139.27 ; 119.63,148.63 U6539.AW10 119.34,148.64 ; U6539.AB12 119.32,156.11 ; U6539.AB12 119.02,155.81 ; U6539.AB12 118.71,156.11 ; 119.17,133.7 U6539.CM10 119.48,134 ; U6539.CK10 119.48,134.92 ; U6539.CK10 119.48,134.3 ; U6539.CK10 119.17,134.61 ; 119.48,132.47 U6539.CP10 119.17,132.78 ; 119.32,136.9 U6539.CD12 119.02,136.59 ; 119.63,155.02 U6539.AE10 119.38,155.05 ; U6539.CH10 119.17,135.53 ; U6539.CH10 119.48,135.22 ; U6539.CH10 119.48,135.83 ; U6539.AC10 119.48,155.96 ; U6539.AC10 119.48,155.35 ; U6539.AC10 119.17,155.66 ; 118.71,135.98 U6539.CG12 ; U6539.CG12 119.02,135.68 ; U6539.CG12 119.32,135.98 ; U6539.CG12 119.02,136.29 ; U6539.CJ12 119.32,135.07 ; U6539.CJ12 119.02,134.76 ; U6539.CJ12 119.02,135.37 ; U6539.CJ12 118.71,135.07 ; 106.27,139.73 U6539.BW40 106.58,139.43
  BOTTOM w0.2: v1(124.12,139.85) 124.04,139.94 U6539.BV1
  BOTTOM w0.203: v1(124.76,132.48) 124.73,132.52 U6539.CP1 ; U6539.CC1 124.91,137.46 v1(125.01,137.56) ; v1(124.79,151.91) 124.37,152.33 U6539.AK1 U6539.AK2 ; U6539.CJ1 124.52,134.99 v1(124.89,135.35) ; v1(124.58,130.2) 124.56,130.17 124.56,130.17 124.43,130.04 U6539.CY1 ; v2(129.46,148.36) 129.97,148.87 PR7085.2
  vias: v1(107.21,139.76) v1(107.21,139.18) v1(118.53,150.11) v1(118.53,149.52) v1(118.53,148.94) v1(118.53,136.04) v1(118.53,135.4) v1(118.53,134.77) v1(118.53,134.13) v1(118.53,133.51) v1(118.53,132.9) v1(118.53,132.29) v1(118.53,131.67) v1(118.59,155.65) v1(119.55,156.57) v2(131.06,137.59) v2(131.06,136.93) v2(131.72,137.59) v2(131.72,136.93) v2(131.9,136.28) v2(132.38,138.76) v2(132.38,137.59) v2(132.38,136.93) v2(132.43,132.51) v2(132.56,136.27) v2(133.65,137.59) v2(133.65,136.93) v2(133.65,135.91) v2(133.65,135.25) v2(133.65,132.61) v2(134.79,150.52) v2(134.84,149.37) v2(135.55,151.41) v2(135.55,150.52) v2(135.55,149.25) v2(135.73,138.6) v2(135.73,137.94) v2(135.73,136.72) v2(135.73,136.06) v2(135.89,132.51) v2(135.89,131.85) v2(136.32,149.25) v2(136.32,148.49) v2(136.44,150.52) v2(137.08,149.25) v2(137.08,148.49) v2(137.08,147.72) v2(137.33,151.41) v2(137.33,150.52) v2(137.66,138.6) v2(137.66,137.94) v2(137.66,136.72) v2(137.66,136.06) v2(137.66,132.51) v2(137.66,131.85) v2(141.14,139.72) v2(141.14,138.96) v2(141.14,135.15) v2(141.14,134.39) v2(141.27,137.56)
