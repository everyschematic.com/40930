# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_BRI_RSP_L: length 3.8
  BOTTOM w0.114: R665.1 193.37,116.83 v2(193.1,117.1) 192.83,117.37 192.83,118.13 192.56,118.4 CN17.22
CNV_MFUART2_RXD: length 2.6
  BOTTOM w0.114: R68948.1 194.36,111.63 v2(193.59,111.63) 193.37,111.63 193.1,111.9 CN17.48
CNV_MFUART2_TXD: length 5.4
  BOTTOM w0.114: CN17.46 193.1,112.4 193.34,112.16 195.53,112.16 R68947.1 196.04,111.52 v2(196.67,110.89)
CNV_PA_BLANKING: length 2.4
  BOTTOM w0.114: R68946.2 193.85,112.67 193.62,112.9 v2(193.59,112.9) 193.18,112.9 CN17.44
CNV_RF_RESET#: length 134.1
  TOP w0.089: v1(102.59,127.07) 101.95,127.07
  TOP w0.114: R68477.1 93.49,125.78 93.77,125.5 93.77,125 94.03,124.74 94.79,124.74 96.79,126.74 98.7,126.74 99.03,127.07 101.95,127.07 ; U35.1 188.24,114.74 188.13,114.63 v2(188.13,114.3) 188.49,114.3 188.61,114.42 R68872.2 U35.2 188.89,116.61 v2(189.02,116.74)
  IN2 w0.102: v2(189.02,116.74) 189.02,117.04 187.32,118.74 182.32,118.74 181.63,119.43 178.79,119.43 176.68,121.54 170.58,121.54 169.18,120.14 169.18,119.94 166.29,117.04 166.29,115.72 164.94,114.37 163.09,114.37 161.56,112.85 158.19,112.85 157.35,112.01 154.81,112.01 154.58,111.78 152.65,111.78 150.62,109.75 141.73,109.75 141.07,109.09 138.37,109.09 135.05,112.42 135.05,116.61 135.99,117.55 135.99,118.23 135.07,119.15 123.36,119.15 122.73,119.78 118.82,119.78 118.3,120.3 118.3,120.53 115.87,122.96 115.87,128.55 115.11,129.31 115.11,130.83 114.96,130.98 107.26,130.98 106.98,130.71 106.6,130.71 106.34,130.45 106.34,130.07 106.09,129.82 105.2,129.82 104.95,129.56 104.95,129.18 105.46,128.67 105.46,128.42 104.95,127.91 103.68,127.91 102.84,127.07 v1(102.59,127.07)
  BOTTOM w0.102: U6539.DG51 101.49,126.43 101.95,126.43 v1(102.59,127.07)
CNV_RF_RESET#_L: length 11.5
  TOP w0.114: R68872.1 189.12,113.97 189.28,113.81 189.78,113.81 190.01,114.04 190.01,116.25 189.54,116.72 U35.4 190.32,117.65 190.9,118.23 R676.1 190.9,118.99 191.1,119.2 191.1,119.61 190.72,119.99 v2(190.72,120.8) v1(190.72,121.56)
  BOTTOM w0.114: v1(190.72,121.56) 190.88,121.4 CN17.10
CNV_RGI_DT: length 87.4
  TOP w0.114: R68385.1 R68429.2 R68379.1 130.19,127.37 v1(130.35,127.53)
  IN2 w0.102: v1(130.35,127.53) 130.86,127.02 131.87,127.02 133.65,125.24 133.65,123.87 139.01,118.51 139.01,112.93 140.2,111.73 149.7,111.73 152.34,114.37 154.72,114.37 155.03,114.69 157.14,114.69 157.98,115.53 157.98,116.51 158.97,117.5 160.19,117.5 161.46,118.77 162.86,118.77 163.37,119.28 163.37,120.04 164.26,120.93 164.76,120.93 165.65,121.82 166.42,121.82 167.8,123.2 168.44,123.2 168.83,123.59 178.35,123.59 178.61,123.34 180.54,123.34 181.83,122.04 186.63,122.04 187.62,121.05 191.05,121.05 192.32,119.78 192.32,117.24 v2(193.21,116.35)
  BOTTOM w0.114: v2(193.21,116.35) 192.76,115.9 CN17.32
CNV_RGI_DT_R: length 17.1
  TOP w0.114: v1(131.21,127.53) R68429.1
  IN2 w0.102: v1(118.11,126.91) 117.65,127.38 117.65,128.34 117.98,128.67 121.08,128.67 121.58,128.17 121.97,128.17 122.09,128.29 122.6,128.29 122.93,127.96 130.78,127.96 v1(131.21,127.53)
  BOTTOM w0.102: U6539.DG13 118.34,126.91 v1(118.11,126.91)
CNV_RGI_RSP: length 107.5
  TOP w0.114: v1(129.59,126.13) 129.49,126.04 R68430.2
  IN2 w0.102: v2(195.37,115.59) 195.07,115.29 193.14,115.29 191.56,116.86 191.56,117.88 191.18,118.26 190.17,118.26 188.26,120.16 186.74,120.16 186.48,120.42 186.48,120.93 186.1,121.31 181.53,121.31 180.26,122.58 178.35,122.58 178,122.93 169.18,122.93 168.75,122.5 168.75,122.25 166.44,119.94 165.43,119.94 164.51,119.02 164.51,118.51 164.26,118.26 163.37,118.26 162.32,117.21 162.32,116.17 161.85,115.69 160.8,115.69 159.8,114.69 158.08,114.69 156.74,113.36 154.49,113.36 154.13,113.71 152.65,113.71 150.01,111.07 141.12,111.07 140.51,110.46 139.49,110.46 139.31,110.64 139.31,111.58 138.22,112.67 138.22,118.34 132.38,124.18 132.38,124.99 131.24,126.13 v1(129.59,126.13) 129.08,126.13 128.47,126.74 124.61,126.74 123.74,125.88 123.74,124.36 123.11,123.72 122.22,123.72 120.82,122.32 118.92,122.32 117.65,123.59 117.65,125.86 v1(118.11,126.33)
  BOTTOM w0.102: v1(118.11,126.33) 118.28,126.33 U6539.DJ13
  BOTTOM w0.114: R667.2 v2(195.37,115.59)
CNV_RGI_RSP_L: length 2.5
  BOTTOM w0.114: CN17.34 v2(193.67,115.4) 193.78,115.4 193.97,115.59 R667.1
CNV_WR_CLK_DN: length 134.7
  IN4 w0.089: v2(190.22,106.58) 190.13,106.49 190.13,105.99 189.9,105.76 188.82,105.76 185.62,102.56 185.62,101.01 184.58,99.97 184.58,99.46 185.1,98.94 185.99,98.94 186.79,98.14 186.79,97.48 186.35,97.05 184.82,97.05 184.7,96.92 184.7,96.61 184.47,96.38 183.74,96.38 183.51,96.61 183.51,96.99 183.38,97.11 182.73,97.11 182,96.38 174.84,96.38 174.23,96.99 166.65,96.99 165.99,96.33 161.57,96.33 160.72,97.18 158.52,97.18 157.67,96.33 155.6,96.33 154.19,97.74 152.41,97.74 152.32,97.65 146.01,97.65 145.21,98.45 144.19,98.45 143.68,97.94 137.59,97.94 137.2,98.33 136.81,98.33 136.57,98.57 126.41,98.57 121.19,103.79 115.68,103.79 114.81,104.67 110.54,104.67 107.49,107.72 107.49,108.35 105.53,110.31 105.53,112.24 106.68,113.38 106.68,115.34 106.55,115.47 104.19,115.47 103.68,115.98 103.68,117.25 103.41,117.52 v1(103.41,119.15)
  BOTTOM w0.089: U6539.DW44 104.23,121.31 104.1,121.18 104.1,120.72 103.96,120.57 103.96,119.81 103.8,119.66 103.8,119.55 v1(103.41,119.15)
  BOTTOM w0.114: v2(190.22,106.58) 190.21,106.58 190.01,106.77 190.01,107.24 189.4,107.85 188.21,107.85 187.22,108.84 187.22,110.66 186.48,111.4 186.48,115.47 186.33,115.62 186.33,117.9 185.8,118.44 185.54,118.44 185.33,118.65 CN17.21
CNV_WR_CLK_DP: length 134.8
  IN4 w0.089: v1(103.43,119.76) 103.43,119.76 103.8,119.39 103.8,119.02 103.59,118.8 103.59,117.59 103.86,117.32 103.86,116.05 104.26,115.64 106.62,115.64 106.85,115.41 106.85,113.31 105.71,112.17 105.71,110.38 107.67,108.43 107.67,107.79 110.61,104.85 114.88,104.85 115.76,103.97 121.27,103.97 126.49,98.75 136.65,98.75 136.89,98.51 137.27,98.51 137.66,98.12 143.61,98.12 144.11,98.62 145.28,98.62 146.08,97.82 152.25,97.82 152.33,97.91 154.26,97.91 155.67,96.5 157.59,96.5 158.45,97.35 160.8,97.35 161.65,96.5 165.92,96.5 166.58,97.16 174.3,97.16 174.91,96.55 181.92,96.55 182.66,97.29 183.46,97.29 183.69,97.06 183.69,96.68 183.81,96.55 184.39,96.55 184.52,96.68 184.52,97 184.75,97.23 186.28,97.23 186.61,97.56 186.61,98.07 185.91,98.76 185.02,98.76 184.4,99.39 184.4,100.04 185.44,101.09 185.44,102.64 188.74,105.94 189.82,105.94 189.95,106.07 189.95,106.16 v2(189.53,106.58)
  BOTTOM w0.089: v1(103.43,119.76) 103.66,119.76 103.79,119.89 103.79,120.64 103.93,120.78 103.93,121.26 103.93,121.26 103.93,121.32 104.35,121.74 U6539.DV44
  BOTTOM w0.114: v2(189.53,106.58) 189.78,106.83 189.78,107.14 189.31,107.62 188.11,107.62 186.99,108.74 186.99,110.57 186.25,111.31 186.25,115.37 186.1,115.52 186.1,117.81 185.7,118.21 185.4,118.21 185.34,118.15 CN17.23
CNV_WR_LANE0_DN: length 134.6
  IN4 w0.089: v1(104.44,119.76) 104.8,119.4 104.8,118.16 106.86,116.1 107.39,116.1 107.55,115.94 107.55,115.49 107.61,115.42 107.61,112.92 106.7,112.01 106.7,110.03 108.12,108.61 108.12,108.23 110.92,105.43 115.06,105.43 116.11,104.39 121.49,104.39 126.52,99.36 137.42,99.36 137.51,99.27 137.51,98.84 137.78,98.57 138.22,98.57 138.49,98.84 138.49,99.27 138.58,99.36 139.02,99.36 139.11,99.27 139.11,98.78 139.34,98.55 139.85,98.55 140.09,98.79 140.09,99.17 140.27,99.36 145.19,99.36 145.77,98.78 149.12,98.78 149.56,98.33 154.4,98.33 155.73,97 157.48,97 158.22,97.75 161.02,97.75 161.87,96.9 165.5,96.9 165.83,97.23 165.83,98.37 165.96,98.5 166.47,98.5 166.56,98.41 166.56,97.88 166.88,97.56 170.22,97.56 170.73,98.07 177.47,98.07 177.8,97.74 177.8,97.35 178.15,97 181.61,97 182.21,97.61 182.21,98.02 181.72,98.52 181.72,98.77 181.91,98.96 182.17,98.96 183.23,97.89 183.76,97.89 184.12,98.25 184.12,98.78 183.56,99.34 183.56,99.85 185.03,101.32 185.03,102.84 186.91,104.72 186.91,107.01 187.76,107.86 188.65,107.86 188.88,108.09 188.88,108.37 v2(189.07,108.56)
  BOTTOM w0.089: U6539.DT43 104.86,122.79 104.73,122.36 104.73,122.21 104.77,122.08 104.77,121.99 104.77,121.99 104.77,121.82 104.74,121.69 104.74,121.54 104.86,121.19 104.86,121.14 104.86,120.72 104.8,120.66 104.8,120.11 v1(104.44,119.76)
  BOTTOM w0.114: CN17.15 185.73,120.15 187.12,118.77 187.12,116.1 188.13,115.08 188.13,113.81 188.62,113.33 188.62,109.84 188.89,109.56 188.89,108.73 v2(189.07,108.56)
CNV_WR_LANE0_DP: length 134.5
  IN4 w0.089: v1(104.44,120.37) 104.87,119.94 104.87,119.58 104.97,119.48 104.97,118.23 106.93,116.28 107.46,116.28 107.72,116.02 107.72,115.56 107.79,115.49 107.79,112.85 106.88,111.93 106.88,110.1 108.3,108.68 108.3,108.3 110.99,105.61 115.14,105.61 116.18,104.57 121.56,104.57 126.59,99.53 137.49,99.53 137.69,99.34 137.69,98.92 137.85,98.75 138.14,98.75 138.31,98.92 138.31,99.34 138.5,99.53 139.09,99.53 139.29,99.34 139.29,98.85 139.41,98.73 139.77,98.73 139.91,98.86 139.91,99.24 140.2,99.53 145.26,99.53 145.84,98.96 149.19,98.96 149.63,98.51 154.47,98.51 155.81,97.18 157.4,97.18 158.15,97.93 161.09,97.93 161.95,97.08 165.43,97.08 165.65,97.3 165.65,98.44 165.89,98.68 166.54,98.68 166.73,98.48 166.73,97.95 166.95,97.74 170.15,97.74 170.66,98.24 177.55,98.24 177.97,97.82 177.97,97.43 178.22,97.18 181.53,97.18 182.04,97.68 182.04,97.95 181.54,98.44 181.54,98.84 181.84,99.13 182.24,99.13 183.31,98.07 183.69,98.07 183.94,98.32 183.94,98.7 183.38,99.26 183.38,99.92 184.86,101.39 184.86,102.92 186.74,104.8 186.74,107.08 187.69,108.04 188.57,108.04 188.7,108.16 188.7,108.4 188.54,108.56 v2(188.27,108.56)
  BOTTOM w0.089: v1(104.44,120.37) 104.44,120.54 104.69,120.79 104.69,121.14 104.57,121.48 104.56,121.49 104.56,121.72 104.6,121.87 104.6,122.05 104.56,122.18 104.56,122.38 104.62,122.56 104.62,122.8 104.6,122.81 104.6,123 U6539.DR44
  BOTTOM w0.114: CN17.17 185.21,119.65 185.48,119.92 185.64,119.92 186.89,118.67 186.89,116.01 187.9,114.99 187.9,113.72 188.39,113.24 188.39,109.74 188.67,109.46 188.67,108.79 188.43,108.56 v2(188.27,108.56)
CNV_WR_LANE1_DN: length 134.5
  IN4 w0.089: v1(105.41,119.76) 105.49,119.85 105.67,119.85 105.77,119.75 105.77,118.84 107.41,117.19 107.92,117.19 108.2,116.92 108.2,116.25 108.58,115.87 108.58,113.54 108.76,113.36 108.76,112.8 107.82,111.86 107.82,109.8 110.67,106.96 111.17,106.96 112.06,106.07 115.24,106.07 116.33,104.97 121.79,104.97 126.74,100.02 137.71,100.02 137.8,99.94 145.62,99.94 146,99.56 154.25,99.56 155.93,97.89 157.47,97.89 158.03,98.45 161.34,98.45 161.97,97.81 162.73,97.81 162.99,98.07 162.99,98.96 163.11,99.08 163.95,99.08 164.08,98.96 164.08,98.55 164.31,98.32 164.91,98.32 165.14,98.55 165.14,99.07 165.23,99.16 167.09,99.16 167.22,99.03 167.22,98.39 167.41,98.19 168,98.19 168.19,98.39 168.19,99.07 168.28,99.16 169.58,99.16 170.04,98.7 180.51,98.7 181.15,99.34 181.15,99.84 181.48,100.17 182.88,100.17 184.45,101.75 184.45,103.07 185.47,104.09 185.47,105.43 186.3,106.27 186.3,107.34 187.55,108.58 187.55,109.35 187.82,109.62 191.06,109.62 191.26,109.42 191.26,108.3 191,108.04 190.26,108.04 190.13,108.17 190.13,108.44 190.26,108.56 v2(190.55,108.56)
  BOTTOM w0.089: U6539.DV43 105.16,121.47 105.16,120.63 105.02,120.49 105.02,120.14 v1(105.41,119.76)
  BOTTOM w0.114: v2(190.55,108.56) 190.06,109.05 190.06,113.03 188.89,114.2 188.89,116.15 188.11,116.94 188.11,118.84 186.46,120.49 186.46,121.02 186.1,121.38 185.65,121.38 185.38,121.65 CN17.9
CNV_WR_LANE1_DP: length 134.5
  IN4 w0.089: v2(189.75,108.56) 189.95,108.36 189.95,108.1 190.18,107.86 191.07,107.86 191.43,108.23 191.43,109.5 191.13,109.8 187.75,109.8 187.37,109.42 187.37,108.66 186.13,107.41 186.13,106.34 185.29,105.51 185.29,104.16 184.27,103.15 184.27,101.82 182.8,100.35 181.4,100.35 180.97,99.92 180.97,99.41 180.44,98.88 170.11,98.88 169.65,99.34 168.21,99.34 168.02,99.14 168.02,98.46 167.93,98.37 167.48,98.37 167.39,98.46 167.39,99.1 167.16,99.34 165.15,99.34 164.96,99.14 164.96,98.62 164.83,98.5 164.38,98.5 164.26,98.62 164.26,99.03 164.03,99.26 163.04,99.26 162.81,99.03 162.81,98.14 162.66,97.99 162.05,97.99 161.41,98.62 157.96,98.62 157.4,98.07 156,98.07 154.33,99.74 146.07,99.74 145.7,100.12 137.87,100.12 137.79,100.2 126.81,100.2 121.86,105.15 116.4,105.15 115.31,106.24 112.13,106.24 111.24,107.13 110.74,107.13 108,109.88 108,111.78 108.94,112.72 108.94,113.43 108.76,113.61 108.76,115.95 108.38,116.33 108.38,116.99 108,117.37 107.49,117.37 105.94,118.91 105.94,119.83 v1(105.41,120.37)
  BOTTOM w0.089: v1(105.41,120.37) 105.41,120.47 105.33,120.55 105.33,121.73 105,122.05 U6539.DU43
  BOTTOM w0.114: v2(189.75,108.56) 189.83,108.65 189.83,112.94 188.67,114.1 188.67,116.06 187.88,116.84 187.88,118.74 186.23,120.39 186.23,120.92 186,121.15 CN17.11
CNV_WT_CLK_DN: length 134.4
  IN4 w0.089: v2(187.41,102.38) 187.24,102.22 187.24,101.5 187.59,101.15 189.34,101.15 189.53,100.95 189.53,100.36 189.34,100.17 187.26,100.17 187.17,100.08 187.17,99.16 187.32,99.01 189.22,99.01 189.58,98.65 189.58,97.36 187.83,95.6 174.34,95.6 173.78,96.16 172.77,96.16 172.21,95.6 170.28,95.6 169.67,96.21 168.88,96.21 168.79,96.12 168.79,95.77 168.56,95.54 168.06,95.54 167.81,95.78 167.81,96.12 167.72,96.21 166.97,96.21 166.31,95.55 154.58,95.55 153.97,96.16 152.45,96.16 151.73,96.87 151.25,96.87 151.05,96.67 151.05,95.91 150.74,95.6 149.58,95.6 149.27,95.91 149.27,96.42 148.81,96.87 137.51,96.87 136.88,97.51 136.01,97.51 135.81,97.3 125.19,97.3 124.76,97.74 124.76,98.88 122.58,101.06 121.26,101.06 119.3,103.02 115.36,103.02 114.88,103.5 109.93,103.5 108.31,105.12 107.8,105.12 105.84,107.08 105.84,108.48 104.19,110.13 104.19,111.91 103.86,112.24 102.33,112.24 102.1,112.47 102.1,116.3 102.61,116.81 102.61,118.82 102.23,119.2 102.23,120.62 102.79,121.18 104.78,121.18 104.91,121.31 104.91,121.6 104.57,121.94 104.16,121.94 103.93,122.17 103.93,123.24 103.75,123.42 103.75,123.56 v1(103.54,123.77)
  BOTTOM w0.102: v1(103.54,123.77) 103.43,123.77 U6539.DN47
  BOTTOM w0.114: CN17.71 185.26,106.15 185.42,105.99 186.18,105.99 187.47,104.7 187.47,102.76 187.4,102.69 187.4,102.39 v2(187.41,102.38)
CNV_WT_CLK_DP: length 134.4
  IN4 w0.089: v2(186.73,102.38) 187.07,102.05 187.07,101.42 187.52,100.97 189.26,100.97 189.35,100.88 189.35,100.44 189.26,100.35 187.18,100.35 186.99,100.15 186.99,99.08 187.25,98.83 189.15,98.83 189.4,98.57 189.4,97.43 187.75,95.78 174.42,95.78 173.86,96.34 172.69,96.34 172.13,95.78 170.35,95.78 169.74,96.39 168.81,96.39 168.61,96.2 168.61,95.84 168.49,95.72 168.13,95.72 167.99,95.86 167.99,96.2 167.8,96.39 166.9,96.39 166.24,95.73 154.66,95.73 154.05,96.34 152.52,96.34 151.81,97.05 151.18,97.05 150.87,96.75 150.87,95.98 150.67,95.78 149.65,95.78 149.45,95.98 149.45,96.49 148.89,97.05 137.58,97.05 136.95,97.69 135.94,97.69 135.74,97.48 125.27,97.48 124.94,97.81 124.94,98.95 122.65,101.24 121.33,101.24 119.38,103.2 115.44,103.2 114.95,103.68 110,103.68 108.39,105.29 107.88,105.29 106.01,107.16 106.01,108.55 104.36,110.2 104.36,111.98 103.93,112.42 102.41,112.42 102.28,112.54 102.28,116.23 102.79,116.74 102.79,118.89 102.41,119.28 102.41,120.55 102.86,121 104.85,121 105.09,121.23 105.09,121.68 104.64,122.12 104.24,122.12 104.11,122.25 104.11,123.31 103.93,123.49 103.93,124 v1(103.55,124.38)
  BOTTOM w0.102: U6539.DN45 103.84,124.09 v1(103.55,124.38)
  BOTTOM w0.114: CN17.73 185.21,105.65 185.32,105.76 186.08,105.76 187.24,104.6 187.24,102.89 186.74,102.38 v2(186.73,102.38)
CNV_WT_LANE0_DN: length 134.6
  IN4 w0.089: v1(101.9,123.03) 101.9,123.2 101.7,123.4 101.61,123.4 101.49,123.28 101.49,122.45 101.62,122.32 102.39,122.32 102.62,122.09 102.62,121.57 102.36,121.31 101.82,121.31 101.7,121.18 101.7,120.21 101.52,120.04 101.52,118.77 101,118.25 101,117.99 101.09,117.9 101.96,117.9 102.15,117.71 102.15,117.11 101.96,116.92 101.09,116.92 101,116.83 101,116.41 101.57,115.84 101.57,112.11 101.9,111.78 102.91,111.78 103.17,111.53 103.17,110.89 102.86,110.59 102.1,110.59 101.95,110.44 101.95,109.75 102.08,109.62 103.55,109.62 104.19,108.99 104.19,107.85 107.36,104.67 108.04,104.67 109.62,103.1 114.72,103.1 115.8,102.02 118.65,102.02 120.09,100.58 122.37,100.58 123.24,99.72 123.24,98.57 124.91,96.9 136.16,96.9 136.42,96.64 137.15,96.64 137.38,96.42 144.62,96.42 145.21,95.83 146.66,95.83 146.91,96.08 148.46,96.08 149.33,95.21 151.11,95.21 151.48,95.58 153.28,95.58 153.71,95.15 188.01,95.15 190.06,97.2 190.06,100.5 190.55,100.98 190.55,102.77 190.37,102.94 189.2,102.94 189.08,102.82 189.08,102.58 189.28,102.38 v2(189.4,102.38)
  BOTTOM w0.102: v1(101.9,123.03) 102.07,122.85 102.43,122.85 102.53,122.96 102.53,123.1 102.44,123.2 U6539.DR49
  BOTTOM w0.114: v2(189.4,102.38) 189.39,102.38 188.96,102.81 188.96,103.21 188.21,103.96 188.21,104.97 186.35,106.83 186.35,106.96 185.93,107.38 185.55,107.38 185.28,107.65 CN17.65
CNV_WT_LANE0_DP: length 134.7
  IN4 w0.089: v1(102.01,123.62) 101.97,123.58 101.54,123.58 101.32,123.35 101.32,122.38 101.55,122.15 102.32,122.15 102.44,122.02 102.44,121.64 102.29,121.48 101.75,121.48 101.52,121.25 101.52,120.29 101.34,120.11 101.34,118.84 100.82,118.32 100.82,117.91 101.01,117.72 101.89,117.72 101.98,117.63 101.98,117.19 101.89,117.1 101.01,117.1 100.82,116.91 100.82,116.34 101.39,115.77 101.39,112.04 101.83,111.6 102.84,111.6 102.99,111.45 102.99,110.97 102.79,110.76 102.03,110.76 101.77,110.51 101.77,109.68 102,109.45 103.47,109.45 104.01,108.91 104.01,107.77 107.29,104.49 107.97,104.49 109.55,102.92 114.65,102.92 115.73,101.84 118.58,101.84 120.01,100.4 122.3,100.4 123.06,99.64 123.06,98.5 124.84,96.72 136.09,96.72 136.34,96.47 137.08,96.47 137.31,96.24 144.55,96.24 145.13,95.65 146.73,95.65 146.98,95.91 148.38,95.91 149.26,95.03 151.19,95.03 151.55,95.4 153.21,95.4 153.64,94.97 188.08,94.97 190.24,97.13 190.24,100.43 190.72,100.91 190.72,102.84 190.44,103.12 189.13,103.12 188.9,102.89 188.9,102.55 v2(188.73,102.38)
  BOTTOM w0.102: U6539.DN49 102.28,123.89 v1(102.01,123.62)
  BOTTOM w0.114: v2(188.73,102.38) 188.73,103.12 187.98,103.86 187.98,104.88 186.13,106.73 186.13,106.86 185.84,107.15 CN17.67
CNV_WT_LANE1_DN: length 134.5
  IN4 w0.089: v2(188.18,106.58) 188.06,106.58 187.91,106.73 187.91,106.91 188.08,107.08 190.55,107.08 191.18,106.45 191.18,97.3 188.44,94.56 145.66,94.56 144.39,95.83 137.16,95.83 136.93,96.06 136.14,96.06 135.89,96.31 124.1,96.31 120.59,99.82 119.83,99.82 118.21,101.44 115.56,101.44 114.5,102.51 107.87,102.51 105.53,104.85 105.02,104.85 102.38,107.49 102.38,108.25 100.99,109.65 100.99,115.61 100.43,116.17 100.43,120.6 100.99,121.16 100.99,124.08 101.87,124.96 102.15,124.96 102.28,124.83 102.28,124.51 102.41,124.38 v1(102.72,124.38)
  BOTTOM w0.102: v1(102.72,124.38) 102.72,124.69 102.85,124.82 103.03,124.82 U6539.DM47
  BOTTOM w0.114: CN17.59 185.26,109.15 185.43,108.99 185.85,108.99 187.37,107.46 187.37,107.21 187.53,107.06 187.7,107.06 v2(188.18,106.58)
CNV_WT_LANE1_DP: length 134.5
  IN4 w0.089: v1(102.62,125.14) 101.79,125.14 100.81,124.15 100.81,121.23 100.25,120.67 100.25,116.1 100.81,115.54 100.81,109.57 102.2,108.18 102.2,107.42 104.95,104.67 105.46,104.67 107.8,102.33 114.42,102.33 115.49,101.27 118.13,101.27 119.76,99.64 120.52,99.64 124.03,96.14 135.81,96.14 136.07,95.88 136.85,95.88 137.08,95.65 144.32,95.65 145.59,94.38 188.51,94.38 191.36,97.23 191.36,106.52 190.62,107.26 188.01,107.26 187.73,106.98 187.73,106.78 v2(187.52,106.58)
  BOTTOM w0.102: U6539.DK47 102.86,125.14 v1(102.62,125.14)
  BOTTOM w0.114: CN17.61 185.25,108.65 185.36,108.76 185.75,108.76 187.15,107.37 187.15,107.12 187.52,106.74 v2(187.52,106.58)
CNV_WT_RCOMP: length 10.5
  TOP w0.254: v1(101.78,124.19) 101.18,124.19 100.73,124.63 97.73,124.63 96.82,123.72 93.14,123.72 92.88,123.97 R68427.1
  BOTTOM w0.254: v1(101.78,124.19) 101.71,124.26 U6539.DN51
CNVI_EN: length 205.5
  IN1 w0.089: v1(88.44,101.62) 88.82,101.24 89.45,101.24 89.71,100.99 90.47,100.99 90.85,100.61 94.91,100.61 96.57,102.26 102.92,102.26 103.17,102.51 108.12,102.51 109.15,101.49 118.15,101.49 118.66,102 127.68,102 128.57,101.11 132.63,101.11 133.42,100.33 135.05,100.33 135.4,100.68 138.09,100.68 138.27,100.5 139.59,100.5 140.46,101.37 141.93,101.37 142.51,100.78 146.63,100.78 147.32,100.1 153.72,100.1 153.97,99.84 161.97,99.84 162.73,99.08 169.34,99.08 169.72,98.7 177.97,98.7 178.3,98.37 194.18,98.37 194.71,97.84 195.98,97.84 196.51,97.3 197.53,97.3 198.19,97.96 200.45,97.96 200.68,97.74 204.34,97.74 204.67,97.41 205.63,97.41 207.18,98.96 208.83,98.96 209.95,100.07 212.49,100.07 213.28,100.86 v2(213.28,100.94)
  BOTTOM w0.102: 90.22,124.05 90.37,124.05 91.44,125.12 91.99,125.12 93.75,126.87 96.87,126.87 97.18,127.18 97.33,127.18 98.67,128.52 100.06,128.52 U6539.DC53
  BOTTOM w0.114: v2(213.28,100.94) 213.28,101.24 213.91,101.88 213.91,103.91 212.9,104.92 201.98,104.92 201.47,105.43 201.47,106.45 199.94,107.97 199.18,107.97 198.67,108.48 198.67,112.67 200.58,114.58 200.58,118.51 201.09,119.02 201.98,119.02 202.23,118.77 R68941.1 ; 90.22,124.05 89.91,124.05 89.23,123.36 89.23,121.33 88.67,120.77 88.67,117.98 84.44,113.75 84.44,110.25 84.58,110.11 84.58,109.27 85.49,108.35 87.17,108.35 87.93,107.59 87.93,103.27 87.47,102.82 87.47,102.46 88.31,101.62 v1(88.44,101.62)
CODEC_VREF: length 2.7
  BOTTOM w0.114: C563.2 15.03,31.4 15.31,31.11 15.67,31.11 15.79,31.24 16.29,31.24 16.45,31.41 U20.28
CPU_C10_GATE#: length 238.1
  TOP w0.089: v1(111.75,123.75) 111.91,123.59 111.91,122.6 111.5,122.2 111.3,122.2 111.17,122.07
  TOP w0.114: R68952.1 205.71,106.65 205.62,106.65 204.27,105.31 202.05,105.31 200.1,107.26 200.1,107.92 200.35,108.18 200.35,110.51 199.84,111.02 v2(199.84,114.2) 199.84,115.32 199.56,115.6 199.56,122.32 v2(199.69,122.45) ; R68468.2 111.17,115.72 111.04,115.85 111.04,116.1 111.42,116.48 111.42,117.34 111.55,117.47 R68935.2 111.81,117.75 111.68,117.88 111.68,119.15 111.42,119.4 110.79,119.4 110.38,119.81 110.38,121.28 111.17,122.07
  IN1 w0.089: v1(106.73,181.28) 107.1,181.65 111.13,181.65 111.35,181.43 113.76,181.43 114.14,181.81 117.77,181.81 118.84,180.74 121.2,180.74 122.22,179.73 122.22,178.71 123.92,177.01 123.92,174.44 124.48,173.89 124.48,171.5 125.78,170.2 126.92,170.2 127.17,170.46 127.17,170.58 127.45,170.86 133.48,170.86 137.76,166.57 139.62,166.57 141.02,165.17 141.02,147.22 142.84,145.39 142.84,139.67 144.57,137.94 152.34,137.94 155.77,134.52 156.38,134.52 159.18,131.72 159.18,130.45 160.19,129.44 163.76,129.44 164.15,129.05 165.86,129.05 169.51,125.4 169.51,124.28 170.56,123.24 177.72,123.24 178.02,122.93 181.27,122.93 181.63,122.58 184.27,122.58 184.5,122.35 190.62,122.35 191.69,123.42 191.69,124.48 192.07,124.86 196.64,124.86 196.77,124.74 197.91,124.74 198.8,123.85 198.8,122.96 199.31,122.45 v2(199.69,122.45)
  IN3 w0.089: v1(111.75,123.75) 111.3,124.2 111.3,125.12 111.6,125.42 111.98,125.42 112.11,125.55 112.11,127.4 ; 114.22,159.59 114.24,159.61 114.24,162.86 114.22,162.89
  IN3 w0.102: 114.22,162.89 114.22,163.47 115.03,164.28 115.03,166.27 114.4,166.9 114.4,169.31 113.96,169.74 113.96,172.96 110.18,176.75 110.18,177.59 106.73,181.05 v1(106.73,181.28) ; 112.11,127.4 112.11,127.73 111.73,128.11 111.73,130.63 112.57,131.47 112.57,154.07 113.46,154.96 113.46,157.25 113.89,157.68 113.89,159.26 114.22,159.59
  BOTTOM w0.102: v1(111.75,123.75) 111.86,123.75 U6539.DN27
CPU_EAR: length 8.2
  BOTTOM w0.102: 124.88,163.72 124.41,163.25 124.41,163.06 U6539.G1
  BOTTOM w0.114: 124.88,163.72 125.9,164.74 125.9,166.77 126.03,166.9 127.55,166.9 127.71,167.06 R68279.2 R68277.1
CPU_POPI_RCOMP: length 2.4
  TOP w0.203: R68262.2 107.95,131.95 107.2,131.21 v1(106.95,131.21)
  BOTTOM w0.203: v1(106.95,131.21) 106.95,131.23 106.74,131.45 U6539.CT39
CPU_PRDY#: length 7.2
  BOTTOM w0.102: TP13250.1 119.3,170.05 119.3,168.3 120.06,167.54 120.06,166.7 119.49,166.12 119.49,164.92 119.74,164.67 119.74,164.45 119.41,164.12 U6539.D11
CPU_PREQ#: length 8.9
  BOTTOM w0.102: U6539.C11 119.27,164.7 119.27,166.29 118.59,166.98 118.59,167.59 119.04,168.04 119.04,169.59 118.44,170.2 118.44,171.07 118.71,171.35 118.82,171.35 TP13249.1
  BOTTOM w0.114: TP13249.1 119.3,171.83 R68270.1
CPU_SVID_CLK: length 12.6
  TOP w0.114: R68286.1 120.83,170.87 v1(120.8,170.84)
  IN3 w0.102: v1(119.79,161.14) 119.79,161.33 119.17,161.95 119.17,162.58 119.04,162.71 119.04,163.19 119.81,163.95 119.81,164.74 120.19,165.12 120.44,165.12 121.2,165.88 121.2,168.04 120.82,168.42 120.82,170.81 v1(120.8,170.84)
  BOTTOM w0.102: U6539.M11 119.75,161.14 v1(119.79,161.14)
CPU_SVID_DAT: length 13.2
  TOP w0.114: v1(118.82,170.84) 118.79,170.84 118.54,171.09 R68287.1
  IN3 w0.102: v1(119.01,161.14) 119.01,161.22 118.66,161.57 118.16,161.57 118.03,161.69 118.03,162.58 118.28,162.84 118.28,163.73 118.79,164.23 118.79,165.5 120.19,166.9 120.19,167.41 119.68,167.92 119.68,169.14 118.79,170.02 118.79,170.76 118.82,170.79 v1(118.82,170.84)
  BOTTOM w0.102: U6539.M12 118.65,160.69 119.01,161.04 v1(119.01,161.14)
CPU_VIDALERT#: length 13.7
  TOP w0.114: R68285.1 120.06,170.96 119.93,170.84 v1(119.78,170.84)
  IN3 w0.102: v1(119.78,170.84) 119.78,170.81 119.81,170.79 119.81,169.85 120.19,169.47 120.19,168.17 120.7,167.66 120.7,166.77 119.3,165.38 119.3,163.98 118.66,163.34 118.66,162.58 118.92,162.33 118.92,161.79 119.41,161.31 119.41,160.55 119.08,160.23 v1(118.97,160.23)
  BOTTOM w0.102: v1(118.97,160.23) 118.97,160.1 U6539.P12
CPVDD_CODEC: length 18.7
  IN3 w0.508: v2(25.32,39.65) 25.32,36.09 23.62,34.39 18,34.39 v2(17.19,35.2)
  BOTTOM w0.114: R68839.2 27.55,39.99 27.55,41.23 v2(27.74,41.42)
  BOTTOM w0.203: U20.36 17.01,35.02 v2(17.19,35.2)
  BOTTOM w0.508: R68687.2 27.44,39.04 R68839.2 27.07,40.15 26.83,39.91 C565.1 25.58,39.91 v2(25.32,39.65)
CRT_11: length 2.3
  BOTTOM w0.114: CN21.11 9.39,152.09 TP9063.1
CRT_B: length 11.8
  TOP w0.114: L31.1 18.63,156.46 C858.2 v4(21.04,156.46) 23.19,154.31 R850.1 23.48,154.21 23.91,153.78 24.73,153.78 25.37,153.14 26.22,153.14 26.88,152.48 U67.21
CRT_B1: length 14.1
  TOP w0.114: CN21.3 7.57,157.09 7.57,155.21 8.07,154.71 8.72,154.71 9.03,155.02 9.03,155.17 v2(9.55,155.69) ESD3.7 ESD3.4 12.27,155.69 12.62,156.04 15.36,156.04 15.77,156.46 C859.2 17.81,156.46 L31.2
CRT_G: length 11.9
  TOP w0.114: L27.1 18.14,154.68 C857.2 v4(21.57,154.68) 23.1,153.15 23.53,153.15 23.8,152.88 R849.1 24.27,152.88 24.77,152.39 25.62,152.39 26.2,151.81 26.75,151.81 27.01,152.08 U67.22
CRT_G1: length 11.8
  TOP w0.114: CN21.2 8.28,154.09 8.97,154.09 v2(9.18,154.29) 9.58,154.69 ESD3.9 ESD3.2 12.21,154.69 12.47,154.95 12.89,154.95 13.31,155.37 15.08,155.37 15.71,154.74 C860.2 17.31,154.74 L27.2
CRT_R: length 12.2
  TOP w0.114: U67.23 27.58,151.68 26.76,150.86 25.7,150.86 R803.1 25.46,151.26 25.12,151.61 23.67,151.61 23.05,152.22 v4(22.42,152.22) 19.8,152.22 19.32,152.71 C856.2 18.19,152.71 L22.1
CRT_R1: length 12.7
  TOP w0.114: CN21.1 7.71,152.37 8.68,152.37 v2(9.32,153.02) 9.32,153.56 9.96,154.19 ESD3.10 ESD3.1 12.19,154.19 12.42,153.96 12.85,153.96 13.59,154.69 14.8,154.69 16.05,153.45 C861.2 16.7,153.41 L22.2
CRT_VCC_R: length 28.5
  TOP w0.254: v2(9.9,156.55) 10.26,156.19 ESD3.6 ESD3.5
  IN1 w0.762: 14.79,149.25 13.64,149.25 11.35,151.53 11.35,155.41 10.56,156.2 ; 27.1,156.28 26.39,155.57 25.27,155.57 24.27,154.57 24.27,153.5 24.81,152.96 24.81,150.9 23.47,149.56 20.94,149.56 19.22,151.28 18.21,151.28 16.94,150.01
  vias: v2(9.63,157.99) v2(10.22,157.61) v2(15.84,149.95) v2(15.84,149.29) v2(27.1,157.63) v2(27.1,156.87) v2(27.88,155.67)
CRTHSYNC: length 9
  TOP w0.114: R25532.1 15.57,158.62 15.29,158.9 v2(14.78,158.9) 14.65,159.03 C20008.2 13.99,158.74 13.77,158.53 ESD4.2 ESD4.9 10.58,158.53 10.21,158.9 9.06,158.9 8.3,158.14 CN21.13
CRTHSYNC_R: length 15.1
  TOP w0.114: U67.19 28.02,153.28 27.39,153.9 27.39,154.48 26.47,155.4 23.55,155.4 21.07,157.88 17.55,157.88 v2(17.32,158.11) 17.17,158.26 R25532.2
CRTVSYNC: length 13
  TOP w0.114: R25535.1 17.93,158.39 17.67,158.65 16.42,158.65 15.54,159.53 13.89,159.53 13.54,159.89 C20003.2 13.25,160.17 12.61,159.53 ESD4.4 ESD4.7 10.34,159.53 10.13,159.74 v2(9.27,159.74) 8.61,159.74 CN21.14
CRTVSYNC_R: length 10.6
  TOP w0.114: U67.18 28.14,153.68 27.76,154.05 27.76,154.63 26.62,155.77 23.9,155.77 v2(23.79,155.88) 23.6,155.88 21.09,158.39 R25535.2
CSCL: length 2.3
  TOP w0.114: R68217.2 24.22,120.97 24.4,121.15 24.4,121.46 25.1,122.15 U6537.29
CSDA: length 2.7
  TOP w0.114: U6537.28 24.7,122.16 24.18,121.64 v2(23.97,121.64) 23.65,121.64 23.36,121.35 R68218.2
CSI_RCOMP: length 5.4
  TOP w0.254: v1(117.54,161.97) 117.54,165.07 117.17,165.45 R68432.2
  BOTTOM w0.254: U6539.K14 117.95,161.56 v1(117.54,161.97)
CTL2: length 3.4
  TOP w0.114: R418.2 16.58,98.27 v2(16.53,98.22) 16.53,97.19 16.99,96.72 U14.7
CTL3: length 3.5
  TOP w0.114: R417.2 16.19,97.08 16.72,96.55 16.72,95.92 v2(17.27,95.37) 17.27,95.98 17.51,96.22 U14.8
DB_GSENSOR_INT: length 137.8
  TOP w0.114: v2(145.33,217.19) 145.08,216.94 v2(145.08,216.43) R68995.2 ; v2(153.59,215.54) 153.99,215.14 U6516.A5
  IN1 w0.089: v2(49.45,199.03) 50.21,199.79 51.86,199.79 52.62,199.03 56.69,199.03 57.63,198.09 60.45,198.09 61.26,198.9 70.4,198.9 71.42,199.92 75.48,199.92 76.37,199.03 77.26,199.03 80.69,195.6 83.48,195.6 84.12,196.24 89.33,196.24 90.85,197.76 96.57,197.76 97.71,198.9 100.25,198.9 100.76,198.4 102.92,198.4 105.1,196.21 112.21,196.21 112.85,195.58 113.76,195.58 115.74,197.56 115.74,206.02 115.11,206.65 115.11,207.29 115.49,207.67 116.89,207.67 117.65,208.43 117.65,209.29 121.48,213.13 126.03,213.13 129.08,216.18 130.35,216.18 130.5,216.02 139.21,216.02 139.49,216.3 142.54,216.3 143.02,216.79 143.78,216.79 144.19,217.19 v2(145.33,217.19)
  IN3 w0.102: v2(153.59,215.54) 153.21,215.92 153.21,216.81 152.83,217.19 148.89,217.19 148.38,216.68 145.84,216.68 v2(145.33,217.19)
  BOTTOM w0.114: v2(49.45,199.03) 49.3,198.88 CN67.2 49.3,197.65 49.76,197.2 49.89,197.2 50.28,196.81 Q6653.1 50.28,193.38 50.47,193.19 50.96,193.19 R69082.2
DBG_PMODE: length 8.4
  BOTTOM w0.102: 125.68,125.24 125.27,125.66 125.27,126.01 125.01,126.26 124.22,126.26 124.09,126.39 123.36,126.39 122.75,127 U6539.DF4
  BOTTOM w0.114: R68400.1 128.82,125.63 128.32,125.12 v2(128.32,125.09) 127.83,124.61 127.46,124.61 127.2,124.86 R68405.1 126.92,125.12 126.82,125.02 125.91,125.02 125.68,125.24
DC-DET: length 6.6
  BOTTOM w0.114: R25495.2 28.23,32.91 28.65,33.33 R732.1 28.62,33.58 25.47,33.58 25.31,33.41 U20.4
DCIN_ENB: length 2.2
  TOP w0.114: U6537.3 27.1,129.31 27.54,129.75 27.54,129.88 27.89,130.23 R68199.1
DCPRTC: length 11.5
  BOTTOM w0.102: C96931.2 107.21,111.6 107.39,111.78 107.39,112.08 107.6,112.29 108.28,112.29 108.76,112.77 108.76,113.34 108.66,113.44 108.66,114.89 108.69,114.93 108.69,115.55 108.68,115.57 108.68,116.03 108.88,116.23 108.88,118.16 108.86,118.18 108.86,121.56 U6539.DV34
DDPC_CLK: length 24.4
  TOP w0.114: R68910.2 83.61,123.75 v1(83.74,123.87)
  IN3 w0.102: v1(83.74,123.87) 84.73,124.86 90.22,124.86 90.52,125.17 92.32,125.17 93.39,124.1 96.57,124.1 97.33,124.86 99.11,124.86 102.15,127.91 103.3,127.91 103.54,127.67 103.54,127.15 103.64,127.05 v1(103.64,127)
  BOTTOM w0.102: v1(103.64,127) 103.33,126.69 U6539.DG47
DDPC_DATA: length 24.5
  TOP w0.114: R68911.2 v1(84.5,123.85)
  IN3 w0.102: v1(103.64,126.36) 103.04,126.96 103.04,127.28 102.81,127.5 102.38,127.5 99.23,124.36 97.71,124.36 96.95,123.59 93.26,123.59 92.12,124.74 90.85,124.74 90.47,124.36 86.05,124.36 85.94,124.25 85.94,123.82 85.84,123.72 85.64,123.72 85.54,123.82 85.54,124.25 85.44,124.36 85.01,124.36 v1(84.5,123.85)
  BOTTOM w0.102: U6539.DJ47 103.44,126.36 v1(103.64,126.36)
DDR4_DRAMRST#: length 88
  TOP w0.114: v2(46.49,144.86) 46.37,144.98 C249.2 ; v2(78.79,125.83) 84.32,125.83 85.79,124.36 85.79,122.56 86.69,121.66 87.83,121.66 88.82,120.67 88.82,119.4 90.85,117.37 C96574.2 R68253.2 ; v2(55.8,144.88) 55.24,144.32 C20103.1
  IN1 w0.089: v2(78.79,125.83) 78.79,125.5 77.77,124.48 76.25,124.48 71.93,120.16 69.77,120.16 65.96,116.35 58.85,116.35 57.37,117.83 57.37,120.98 57.83,121.43 57.83,137.94 57.07,138.71 57.07,143.79 55.99,144.86 55.81,144.86 v2(55.8,144.88) 55.11,144.88 54.53,144.29 48.56,144.29 47.92,144.93 46.56,144.93 v2(46.49,144.86)
  BOTTOM w0.114: JDIM02.108 55.85,144.82 v2(55.8,144.88) ; v2(46.49,144.86) 46.45,144.82 JDIM1.108
DDR4_SUSON_2V5: length 278.5
  TOP w0.114: U37.122 155.86,110.17 157.4,108.63 v2(157.4,108.35) ; v1(181.99,112.44) 181.86,112.57 v2(181.86,118.13) 182.57,118.85 v1(182.57,119.17)
  TOP w0.203: v2(91.61,169.06) 91.69,169.14 PR5003.1
  IN2 w0.102: v1(118.41,168.81) 118.92,168.3 122.22,168.3 122.85,168.93 126.54,168.93 v2(126.92,168.55)
  IN3 w0.102: v2(126.92,168.55) 126.28,167.92 126.28,165.76 126.54,165.5 127.93,165.5 129.08,164.36 129.71,164.36 131.29,162.79 131.29,155.29 132.13,154.45 136.82,154.45 138.15,153.13 138.15,147.44 138.65,146.94 138.65,129.13 139.62,128.17 139.62,124.23 138.35,122.96 138.35,121.94 137.71,121.31 137.71,119.28 138.35,118.64 138.35,113.05 140.13,111.27 147.66,111.27 150.79,114.4 153.67,114.4 155.62,116.35 156.76,116.35 157.53,117.12 161.08,117.12 161.46,117.5 162.22,117.5 162.73,118.01 164.26,118.01 165.91,119.66 166.27,119.66 167.41,120.8 169.59,120.8 170.48,121.69 176.12,121.69 178.43,119.38 181.97,119.38 182.17,119.17 v1(182.57,119.17) 182.57,119.15 182.93,118.79 192.09,118.79 193.13,119.83 209.65,119.83 210.33,120.52 214.78,120.52 v2(216.45,122.2) ; v1(181.99,112.44) 180.9,111.36 176.05,111.36 172.03,107.34 170.15,107.34 169.67,106.85 167.66,106.85 167.18,107.34 166.92,107.59 166.92,108.61 165.27,110.26 159.3,110.26 v2(157.4,108.35)
  IN4 w0.089: v1(118.41,168.81) 117.84,168.81 117.33,169.31 112.57,169.31 111.17,170.71 104.06,170.71 101.9,168.55 92.12,168.55 v2(91.61,169.06) 91.61,171.85 89.61,173.86 87.78,173.86 86.28,175.36 86.28,176.43 85.57,177.14 74.14,177.14 73.07,178.2 73.07,178.84 70.66,181.25 70.66,182.27 68.75,184.17 68.75,185.95 70.72,187.92 71.8,187.92 72.44,188.55 v1(72.44,189.25)
  BOTTOM w0.114: v2(216.45,122.2) 216.45,122.58 218.13,124.25 220.54,124.25 221.54,125.25 CN49.6 ; PR5025.2 72.59,189.12 72.46,189.25 v1(72.44,189.25)
DDR_RCOMP0: length 1.7
  TOP w0.254: v1(102.81,164.05) 102.88,163.98 103.12,163.98 103.25,163.85 R68249.1
  BOTTOM w0.15: v1(102.81,164.05) 102.81,164.21 102.31,164.72 U6539.C49
DDR_VTT_CTRL: length 18.7
  TOP w0.114: v1(93.44,167.41) 93.44,167.2 93.19,166.95 91.56,166.95 91.2,167.31 R68254.1
  BOTTOM w0.102: 98.6,163.45 100.67,163.45 U6539.E52
  BOTTOM w0.114: 98.6,163.45 95.91,163.45 95.17,162.71 v2(93.37,162.71) 92.76,162.71 91.87,163.6 91.87,167.28 92.5,167.92 93.14,167.92 93.44,167.61 v1(93.44,167.41)
DDR_VTTT_PG_CTRL: length 6
  TOP w0.114: v2(85.26,170.46) 85.42,170.61 R68251.2 R68940.2 87.04,170.61 87.17,170.49 Q6583.3 87.75,169.75 88.09,169.41 R68255.2 88.92,169.41 89.08,169.57 PR5015.1
DDSP_HPD1: length 17.7
  TOP w0.089: v1(104.52,126.98) 104.52,126.85 104.14,126.46 104.14,125.7 103.93,125.5 103.93,123.64 103.68,123.39 103.27,123.39 102.54,122.65 101.72,122.65
  TOP w0.114: TP13366.1 96.92,123.21 97.89,124.18 100.2,124.18 101.72,122.65
  BOTTOM w0.102: U6539.DF45 104.16,127.34 v1(104.52,126.98)
DE1: length 3.3
  TOP w0.114: R503.1 225.39,114.92 225.74,115.27 226.59,115.27 226.65,115.2 226.92,114.94 R1235.2 227.33,115.22 U42.9
DE2: length 3.2
  TOP w0.114: U42.8 226.94,115.72 R504.2 226.92,115.88 226.65,116.14 226.59,116.21 225.74,116.21 225.39,115.86 R505.1
DEVSLP0: length 124.2
  TOP w0.089: v1(119.94,126.34) 119.85,126.25 119.85,125.62 119.86,125.61 119.86,125.6 120.31,125.14 120.31,123.59 120.62,123.29 121.41,123.29 121.58,123.11
  TOP w0.114: v2(215.82,110.51) 215.44,110.13 215.44,108.35 215.82,107.97 217.85,107.97 218.36,107.46 218.36,107.08 218.1,106.83 218.1,106.02 v2(218.41,105.72) 218.87,105.72 219.05,105.54 220.56,105.54 221.34,104.76 R67358.2 ; 121.58,123.11 121.71,122.98 121.71,122.83 122.09,122.45 122.35,122.45 122.88,121.92 123.13,121.92 124.25,120.8 124.76,120.8 v1(124.81,120.85)
  IN4 w0.089: v1(124.81,120.85) 125.09,120.85 127.17,118.77 127.55,118.77 132.76,113.56 132.76,112.54 134.54,110.77 134.54,109.6 136.77,107.36 141.5,107.36 141.73,107.13 143.99,107.13 144.7,107.85 148.33,107.85 149.14,107.03 166.92,107.03 167.05,106.91 173.48,106.91 176.45,109.88 178.86,109.88 180.77,111.78 180.77,112.57 181.5,113.31 183.18,113.31 183.76,113.89 194.28,113.89 194.99,113.18 196.26,113.18 198.04,111.4 204.39,111.4 204.64,111.15 210.61,111.15 211.25,111.78 214.55,111.78 v2(215.82,110.51)
  BOTTOM w0.102: U6539.DG8 120.05,126.34 v1(119.94,126.34)
DEVSLP0_R: length 5.6
  TOP w0.114: R67358.1 222.85,104.75 v2(223.01,104.59) 223.01,104.39 v2(222.58,103.97)
  BOTTOM w0.114: CN11.1 225.14,104.24 224.96,104.42 223.03,104.42 v2(222.58,103.97)
DEVSLP1: length 1.2
  TOP w0.114: v1(120.88,123.85) 121.51,123.85 TP13367.1
  BOTTOM w0.102: v1(120.88,123.85) 121.08,123.85 U6539.DN6
DEVSLP#: length 2.1
  BOTTOM w0.114: CN16.38 25.1,71.87 25.7,71.27 TP13375.1
DEW1: length 4.6
  TOP w0.114: U42.16 232.49,114.72 232.94,114.27 R499.2 233.63,113.79 233.93,113.48 v2(234.67,113.48) 235.15,113.97 R500.1
DEW2: length 4.2
  TOP w0.114: R1237.1 225.39,117.8 225.65,118.06 225.65,118.18 v2(225.98,118.51) 226.42,118.07 226.72,118.07 226.92,117.88 R506.2 227.33,117.26 227.33,116.86 227.47,116.72 U42.6
DGPU_EDIDCLK: length 6.4
  BOTTOM w0.102: U8.A9 126.92,182.43 126.92,181.27 126.21,180.57 125.59,180.57 124.63,179.6
  BOTTOM w0.114: R363.1 123.16,179.27 123.49,179.6 124.63,179.6
DGPU_EDIDDATA: length 7.9
  BOTTOM w0.102: U8.B9 126.9,183.01 126.53,182.64 126.53,182.29 126.69,182.14 126.69,181.34 126.14,180.8 125.5,180.8 124.51,179.81 123.07,179.81 122.73,179.47 122.73,179.38
  BOTTOM w0.114: 122.73,179.38 122.73,178.84 122.57,178.68 R366.1
DGPU_HOLD_RST#: length 88.6
  TOP w0.102: v1(120.88,125.09) 120.88,125.12 121.01,125.24 R68352.2
  IN3 w0.089: v1(120.88,125.09) 120.35,125.63 119.93,125.63 119.58,125.98 119.58,128.6 119.43,128.75 118.31,128.75 117.9,129.16 117.9,130.58 118,130.68 118,131.24
  IN3 w0.102: v1(109.8,183.03) 109.8,183 111.22,181.58 111.3,181.58 111.48,181.4 111.48,179.98 111.98,179.47 111.98,178.91 114.47,176.43 114.47,175.48 115.66,174.29 116.61,174.29 118.54,172.36 121.36,172.36 122.37,171.35 122.37,170.61 125.52,167.46 125.52,165.63 126.41,164.74 127.68,164.74 128.7,163.73 129.59,163.73 130.75,162.56 130.75,158.54 128.63,156.42 124.44,156.42 123.24,155.22 118.28,155.22 118,154.94 118,131.24
  BOTTOM w0.102: v1(120.88,125.09) 121.02,125.09 U6539.DK6
  BOTTOM w0.114: v1(109.8,183.03) 109.8,183.42 109.56,183.66 108.12,183.66 108.01,183.55 v2(107.5,183.55) 107.5,184.42 107.39,184.54 U9.1
DGPU_OPP#: length 204.8
  TOP w0.114: v2(209.26,127.65) 209.26,127.75 208.77,128.23 v2(208.2,128.23) 207.63,128.23 206.93,127.53 202.1,127.53 201.2,126.62 200.05,126.62 198.06,124.63 198.06,116.48 197.53,115.95 197.53,111.07 198.42,110.18 198.42,106.85 199.56,105.71 199.56,104.34 198.78,103.55 198.78,97.87 196.48,95.58 175.52,95.58 174.12,96.98 172.51,96.98 172.18,97.3 172.18,97.78 171.91,98.05 171.63,98.05 171.36,98.32 170.33,98.32 170.02,98.62 170.02,98.9 169.52,99.41 168.55,99.41 168.42,99.54 U37.71
  IN3 w0.102: v2(209.26,127.65) 208.09,128.81 200.33,128.81 198.42,126.9 197.28,126.9 196.03,125.65 189.09,125.65 188.81,125.37 179.63,125.37 178.64,126.36 176.6,126.36 175.56,127.4 175.56,131.47 174.42,132.61 172.26,132.61 170.99,133.88 170.99,137.18 169.11,139.06 169.11,144.62 169.34,144.85 169.34,145.74 171.11,147.52 171.11,151.28 170.48,151.91 170.48,153.57 171.27,154.35 171.27,155.06 171,155.33 171,155.97 170.61,156.36 170.61,157.25 170.29,157.57 170.29,157.95 169.59,158.65 169.59,159.18 167.74,161.03 167.74,165.38 168.19,165.83 168.19,166.9 164.82,170.27 159.63,170.27 159.08,170.83 155.99,170.83 155,171.82 151.06,171.82 150.49,172.39 150.49,174.82 147.37,177.95 133.27,177.95 133.01,177.7 133.01,176.68 132.89,176.55 v2(132.79,176.55)
  BOTTOM w0.114: v2(132.79,176.55) 132.76,176.55 132.38,176.17 131.55,176.17 Q6512.3 130.68,176.73 130.28,176.33 R378.1
DGPU_OVT#_EC: length 1.7
  BOTTOM w0.114: Q15.3 107.82,182.22 TP13169.1 R385.1
DGPU_PROCHOT_EC#: length 15.9
  IN4 w0.089: v1(125.67,185.27) 126.07,184.87 126.86,184.87 126.93,184.8 126.93,183.87 128.07,182.72 128.07,181.54 129.2,180.41 129.2,179.6 130.99,177.82 v2(130.99,174.73)
  BOTTOM w0.102: U8.D7 125.25,184.85 v1(125.67,185.27)
  BOTTOM w0.114: v2(130.99,174.73) 130.64,174.73 130.48,174.89 Q6512.1 130.17,175.35 130,175.18 R25322.1
DGPU_PSI: length 42.1
  TOP w0.254: v1(96.52,198.35) 96.67,198.5 PR9016.1
  IN4 w0.089: v1(114.66,181.03) 114.9,181.03 115.06,180.87 115.06,179.47 114.8,179.22 112.06,179.22 111.31,179.97 111.31,180.91 111.91,181.51 111.91,182.29 112.33,182.71 112.33,184.13 110.27,186.19 108.47,186.19 107.97,185.7 104.31,185.7 103.68,185.06 101.39,185.06 100.76,185.7 100.76,186.99 95.21,192.54 95.21,197.29 96.26,198.35 v1(96.52,198.35)
  BOTTOM w0.114: R391.1 114.49,180.87 114.64,181.03 v1(114.66,181.03) 114.95,180.74 R376.2
DGPU_PW_CTRL#: length 5.5
  TOP w0.114: v1(106.29,126.92) 105.84,127.38 105.84,127.81 105.71,127.94 105.05,127.94 104.95,128.04 104.44,128.04 104.19,127.78 R68780.2 103.65,128.11 103.78,128.24 103.78,128.7 103.65,128.83 R68779.2
  BOTTOM w0.102: v1(106.29,126.92) 106.07,126.92 U6539.DG41
DGPU_PWR_EN: length 157.2
  TOP w0.114: v2(89.81,184.2) 89.83,184.17 89.83,183.44 89.63,183.23 89.33,183.23 89.23,183.13 PR9070.2
  IN1 w0.089: v2(123.49,205.64) 124,205.13 124,204.34 123.57,203.91 123.57,197.84 122.65,196.92 122.65,189.23 121.79,188.36 119.07,188.36 116.84,186.13 115.16,186.13 115.01,185.98 112.69,185.98 112.59,185.87 110.21,185.87 109.65,185.32 109.65,185.19 109.39,184.93 108.63,184.93 108.43,185.14 101.32,185.14 99.39,187.07 93.62,187.07 90.75,184.2 v2(89.81,184.2)
  IN3 w0.102: v2(89.81,184.2) 89.81,183.05 91.1,181.76 92.86,181.76 93.26,181.35 94.56,181.35 94.97,180.95 100.45,180.95 100.88,181.38 105.07,181.38 105.61,181.91 107.21,181.91 108.38,180.74 108.38,180.08 110.64,177.82 110.64,176.94 114.45,173.13 114.45,169.9 114.85,169.5 114.85,167.28 115.49,166.65 115.49,163.34 115.16,163.01 115.16,159.74 114.35,158.92 114.35,157.38 113.96,156.99 113.96,151.91 113.81,151.76 113.81,131.57 113.41,131.16 113.41,127.96 114.02,127.35 114.02,123.52 113.69,123.19 113.69,122.6 116.02,120.27 117.88,120.27 118.33,120.72 119.81,120.72 120.18,120.35 v1(120.18,120.34)
  BOTTOM w0.102: U6539.DW9 120.11,121.26 120.11,120.42 120.18,120.35 v1(120.18,120.34)
  BOTTOM w0.114: R68358.2 121.51,116.78 R69104.2 121.32,117.54 120.78,117.54 120.42,117.9 120.42,118.23 120.59,118.41 120.59,119.76 120.24,120.11 120.24,120.27 120.19,120.32 120.19,120.33 v1(120.18,120.34) ; v2(123.49,205.64) 123.49,206.52 v2(124.76,207.79) 124.53,208.02 R323.1
DGPU_PWROK: length 89.7
  TOP w0.114: v1(110.46,179.5) 110.66,179.7 111.02,179.7 v2(111.55,180.24) 111.68,180.11 R25468.2 ; v1(120.88,124.48) 121.08,124.48 121.48,124.89 122.47,124.89 122.58,124.99 122.85,124.99 123.24,125.37 123.62,125.37 124,124.99 124,124.74 124.38,124.36 124.76,124.36 124.89,124.23 R68357.2
  IN3 w0.089: 117.7,131.42 117.7,130.96 117.65,130.91 117.65,129.16 118.23,128.57 119.27,128.57 119.4,128.44 119.4,125.78 119.73,125.45 120.11,125.45 120.52,125.04 120.52,124.85 v1(120.88,124.48)
  IN3 w0.102: v1(116.38,173.78) 116.78,173.78 118.46,172.11 121.28,172.11 122.12,171.27 122.12,170.53 125.27,167.38 125.27,163.98 125.78,163.47 129.46,163.47 130.53,162.4 130.53,158.82 128.57,156.87 124.12,156.87 123.36,156.11 118.28,156.11 117.72,155.55 117.72,131.44 117.7,131.42
  IN4 w0.089: v1(116.38,173.78) 115.44,174.72 114.57,174.72 110.46,178.84 v1(110.46,179.5)
  BOTTOM w0.102: v1(120.88,124.48) 121.06,124.48 U6539.DM6
  BOTTOM w0.114: v1(110.46,179.5) 110.21,179.75 R69110.2
DGPU_PWROK_1.8V: length 28.6
  TOP w0.114: v1(111.83,182.9) 111.86,182.88 111.86,181.61 112.95,180.52 112.95,179.46 113.77,178.63 D13161.2 114.64,178.75 115.36,179.47 Q6652.1
  IN4 w0.089: v1(115.62,176.13) 113.34,178.41 112.54,178.41 110.42,180.53 110.42,181.97 111.35,182.9 v1(111.83,182.9)
  BOTTOM w0.114: v1(115.62,176.13) 115.6,176.15 RG67.2 114.44,175.71 112.61,175.71 112.53,175.79 QG17.6 ; v1(111.83,182.9) 111.83,183.33 v2(112.06,183.56) 112.06,185.52 111.94,185.64 111.94,185.65 111.71,185.88 111.7,185.88 111.61,185.97 R69078.2 111.36,186.57 Q9.2
DISP_ON: length 46.4
  TOP w0.114: v2(80.77,193.06) 79.93,193.9 R446.2 78.09,194.28 R445.1 78.09,195.05 v2(77.47,195.68) 77.23,195.92 U19.3 ; v2(62.83,176.17) 62.99,176.02 62.99,175.15 63.79,174.35 Q6657.2
  IN4 w0.089: v2(80.77,193.06) 80.83,193.13 80.96,193.13 82.15,191.93 82.15,191.31 81.47,190.63 81.07,190.63 80.81,190.89 69.27,190.89 69.03,190.65 64.38,190.65 63.78,190.04 62.81,190.04 62.23,189.46 62.23,187.8 63.98,186.05 63.98,180.72 62.83,179.57 v2(62.83,176.17)
DISP_UTILS: length 7.3
  BOTTOM w0.089: U6539.CE4 123.19,137.04 123.26,137.04 123.75,137.05 124.38,137.05 124.42,137 125.27,137 126.08,137.82 126.54,137.82 126.72,137.99
  BOTTOM w0.114: TP13241.1 128.34,139.01 128.34,138.35 128.06,138.07 126.79,138.07 126.72,137.99
DMIC_CLK: length 2.9
  BOTTOM w0.114: R461.2 25.39,34 25.22,33.83 v2(24.56,33.83) 24.53,33.81 U20.3
DMIC_CLK_L: length 215.9
  IN3 w0.102: v2(29.26,36.6) 28.62,36.6 27,38.22 27,41.4 24.38,44.01 24.38,52.52 23.92,52.98 21.64,52.98 19.86,54.76 19.2,54.76 17.47,56.49 16.78,56.49 15.46,57.81 15.31,57.81 14.73,58.39 14.73,64.97 14.02,65.68 14.02,66.49 14.75,67.23 14.75,72.16 14.65,72.26 14.65,73.17 15.29,73.81 15.79,73.81 17.32,75.33 17.32,86.51 17.7,86.89 17.7,92.35 16.69,93.36 16.69,102.01 18.59,103.91 18.59,112.04 17,113.62 17,116.55 15.33,118.23 15.33,132.46 18.65,135.78 18.65,141.85 10.8,149.69 10.8,157.92 9.01,159.71 9.01,163.65 10.21,164.84 10.21,167.15 15.52,172.47 15.52,174.73 18.38,177.59 24.91,177.59 27.38,175.12 36.43,175.12 36.74,175.43 36.74,178.08 37.79,179.13 40.48,179.13 41.96,180.6 41.96,184.25 42.74,185.04 42.74,188.52 v2(43.61,189.38)
  BOTTOM w0.114: L12.2 51.12,191.31 50.11,191.31 49.45,190.65 48.65,190.65 v2(48.04,190.03) 47.64,189.63 44.62,189.63 44.37,189.38 v2(43.61,189.38) ; R461.1 27.8,34 28.01,34.21 C583.2 29.13,34.21 29.26,34.34 v2(29.26,36.6)
DMIC_CLK_L_C: length 5.3
  BOTTOM w0.114: CN29.1 56.65,192.39 56,191.74 55.72,191.74 v2(55.42,192.05) 55.07,191.69 C548.1 R69062.2 52.73,191.69 L12.1
DMIC_CLK_PCH: length 191
  IN1 w0.089: v1(109.93,123.73) 109.93,122.55 109.29,121.92 107.39,121.92 107.23,122.07 101.01,122.07 100.91,122.17 95.02,122.17 94.1,121.26 93.37,121.26 91.36,119.25 89.43,119.25 88.62,118.44 83.15,118.44 82.62,117.9 82.15,117.9 80.99,116.74 79.27,116.74 79.01,116.48 77.9,116.48 76.5,115.08 75.48,115.08 74.37,113.97 73.1,113.97 65.4,106.27 65.4,105.66 64.02,104.29 63.42,104.29 62.78,103.65 62.78,103.27 61.92,102.41 60.22,102.41 59.96,102.66 57.6,102.66 57.27,102.99 54.43,102.99 54.22,103.2 50.9,103.2 50.01,102.31 48.38,102.31 47.42,103.27 46.11,103.27 45.38,104 45.38,104.67 44.29,105.76 44.29,108.56 43.99,108.86 v1(37.26,108.86)
  IN3 w0.102: v1(37.26,108.86) 36.8,109.32 36.8,110.56 37.64,111.4 37.64,120.55 34.79,123.39 34.79,129.74 32.3,132.23 32.3,136.04 31.67,136.67 31.67,143.02 32.05,143.41 32.05,143.91 32.81,144.68 35.86,144.68 36.24,144.29 37.89,144.29 38.15,144.55 38.15,156.99 37.89,157.25 37.89,163.9 38.4,164.41 38.4,165.55 38.15,165.8 38.15,172.11 43.91,177.87 43.91,183.38 45.28,184.76 45.28,185.98 46.72,187.41 47.73,187.41 48.81,188.49 48.81,189.76 50.85,191.79 52.17,191.79 v2(53.18,192.81)
  BOTTOM w0.102: v1(109.93,123.73) 110.02,123.73 U6539.DN31
  BOTTOM w0.114: R69062.1 53.51,192.48 v2(53.18,192.81)
DMIC_DAT: length 6.3
  BOTTOM w0.114: R459.1 27.99,35.45 27.99,34.9 v2(27.73,34.64) 27.52,34.43 25.31,34.43 25.19,34.31 24.05,34.31 23.94,34.21 U20.2
DMIC_DAT_L: length 208.9
  IN3 w0.102: v2(28.49,37.49) 27.48,38.5 27.48,41.6 24.81,44.27 24.81,52.98 24.4,53.39 21.99,53.39 20.11,55.27 19.4,55.27 17.78,56.89 16.96,56.89 15.64,58.21 15.51,58.21 15.13,58.59 15.13,65.33 14.52,65.94 14.52,66.42 15.16,67.05 15.16,72.34 15.08,72.41 15.08,72.97 15.39,73.28 15.95,73.28 17.83,75.16 17.83,86.26 18.19,86.61 18.19,92.44 17.09,93.53 17.09,101.78 19.02,103.7 19.02,112.18 17.41,113.79 17.41,116.72 15.73,118.4 15.73,132.29 19.06,135.61 19.06,142.01 11.21,149.86 11.21,158.15 9.42,159.94 9.42,163.45 10.71,164.74 10.71,167.03 15.93,172.24 15.93,174.56 18.55,177.19 24.56,177.19 27.03,174.72 36.6,174.72 37.15,175.26 37.15,177.91 37.95,178.72 40.65,178.72 42.36,180.43 42.36,184.07 43.15,184.86 43.15,188.24 v2(43.61,188.69)
  BOTTOM w0.114: R459.2 v2(28.49,37.49) ; L13.2 51.35,190.9 51.33,190.88 50.31,190.88 v2(49.45,190.01) 48.81,190.01 48.41,189.61 48.24,189.61 47.75,189.13 44.88,189.13 44.45,188.69 v2(43.61,188.69)
DMIC_DAT_L_C: length 6.2
  BOTTOM w0.114: CN29.2 57.15,192.25 56.31,191.41 56.05,191.41 v2(55.42,190.78) 55.07,191.13 C547.1 R69063.2 52.73,191.13 L13.1
DMIC_DAT_PCH: length 192.4
  IN1 w0.089: v1(37.26,109.5) 43.99,109.5 44.7,108.78 44.7,105.99 45.89,104.8 45.89,104.12 46.24,103.78 47.67,103.78 48.69,102.77 49.58,102.77 50.46,103.65 54.78,103.65 55.04,103.4 57.42,103.4 57.75,103.07 60.19,103.07 60.45,102.82 61.69,102.82 62.28,103.4 62.28,103.81 63.26,104.8 63.67,104.8 64.43,105.56 64.43,106.07 72.74,114.37 74.09,114.37 75.33,115.62 76.47,115.62 77.74,116.89 78.86,116.89 79.12,117.14 80.83,117.14 81.98,118.29 82.4,118.29 82.95,118.84 88.39,118.84 89.2,119.66 91.18,119.66 93.21,121.69 93.9,121.69 94.78,122.56 101.13,122.56 101.28,122.41 107.47,122.41 107.55,122.32 109.14,122.32 109.52,122.7 109.52,124.01 v1(109.93,124.42)
  IN3 w0.102: v2(51.46,190.14) 52.24,190.14 52.37,190.27 52.37,191.24 52.24,191.37 51.06,191.37 49.32,189.63 49.32,188.36 47.95,186.99 46.88,186.99 45.69,185.8 45.69,184.55 44.32,183.18 44.32,177.7 38.65,172.03 38.65,166.01 38.81,165.86 38.81,164.23 38.3,163.73 38.3,157.48 38.58,157.2 38.58,144.22 38.15,143.79 36.11,143.79 35.63,144.27 32.99,144.27 32.48,143.76 32.48,143.25 32.08,142.85 32.08,137.03 32.81,136.29 32.81,132.48 35.2,130.1 35.2,123.75 38.15,120.8 38.15,111.27 37.26,110.39 v1(37.26,109.5)
  BOTTOM w0.102: U6539.DM31 110.07,124.42 v1(109.93,124.42)
  BOTTOM w0.114: v2(51.46,190.14) 53.39,190.14 53.51,190.27 R69063.1
DNBSWON#: length 77
  TOP w0.114: U37.123 155.46,110.11 156.7,108.87 156.7,107.91 158.41,106.19 v2(158.41,103.91)
  IN4 w0.089: v2(158.41,103.91) 157.81,103.3 156.28,103.3 155.49,102.51 148.25,102.51 147.52,103.25 139.47,103.25 139.21,102.99 131.55,102.99 128.29,106.24 127.55,106.24 125.8,108 118.64,108 117.7,108.94 117.7,109.19 115.69,111.2 114.8,111.2 114.41,111.59 114.41,112.61 114.22,112.8 112.33,112.8 111.93,113.19 111.93,114.35 111.5,114.78 111.2,114.78 110.59,115.39 110.59,116.33 109.88,117.04 109.88,117.78 107.74,119.91 107.74,120.34 106.43,121.65 106.43,121.98 105.71,122.7 105.71,125.37 105.4,125.68 v1(105.34,125.68)
  BOTTOM w0.102: v1(105.34,125.68) 105.55,125.68 U6539.DK41
