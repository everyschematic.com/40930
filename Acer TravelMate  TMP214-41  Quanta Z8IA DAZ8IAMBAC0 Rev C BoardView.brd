# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP7-_FP: length 57.3
  IN3 w0.114: v1(96.18,106.45) 96.01,106.27 96.01,106.14 96.13,106.02 96.49,106.02 96.86,106.39 96.86,106.87 97.95,107.96 99.44,107.96 100.63,109.15 103.63,109.15 105.34,110.87 106.51,110.87 106.89,111.25 108.26,111.25 110.78,113.76 112.94,113.76 114.51,115.34 117.31,115.34 117.97,116 117.97,116.38 118.42,116.84 124.1,116.84 124.89,117.62 124.89,118.23 126.09,119.44 126.09,120.74 126.66,121.31 126.66,124.36 125.9,125.12 125.65,125.12 125.27,125.5 125.27,126.88 125.15,127 125.15,127.14 v1(124.76,127.53)
  BOTTOM w0.089: U6539.DD2 123.6,127.91 124,127.91 124.25,127.66 124.63,127.66 v1(124.76,127.53)
  BOTTOM w0.114: v1(96.18,106.45) 95.84,106.1 95.84,103.43 96.51,102.77 96.95,102.77 97.38,102.33 97.38,100.83 97.09,100.54 96.52,100.54 96.46,100.48 95.5,100.48 95.18,100.16 R67493.1
USBP7-_FP_P2: length 23.1
  BOTTOM w0.114: R67493.2 94.48,100.08 94.48,100.4 94.36,100.53 93.78,100.53 EC8.1 93.02,100.52 86.93,100.52 85.93,101.52 83.13,101.52 82.6,100.99 78.97,100.99 78.55,101.4 74.96,101.4 74.72,101.16 74.72,100.51 74.95,100.28 CN14.6
USBP7-_FP_P4: length 121.8
  TOP w0.114: v2(207.89,97.18) 207.64,97.44 207.4,97.44 207.14,97.7 EC17.1 207.56,99.48 207.56,99.57 v2(207.35,99.79)
  IN1 w0.089: v2(207.89,97.18) 207.61,97.46 207.08,97.46 206.12,96.49 203.63,96.49 203.5,96.62 196.18,96.62 195.62,97.18 193.47,97.18 193.21,96.92 183.56,96.92 183.18,97.3 178.1,97.3 177.78,97.62 177.78,97.72 177.46,98.04 167.97,98.04 167.75,98.26 162.03,98.26 161.84,98.45 152.96,98.45 152.02,99.39 147.09,99.39 146.48,100 140.05,100 139.9,99.84 137.97,99.84 137.82,100 135.66,100 135.33,99.67 133.07,99.67 132.31,100.43 128.24,100.43 127.6,101.06 121.25,101.06 120.98,101.34 119.27,101.34 118.61,100.68 115.03,100.68 114.19,99.84 111.55,99.84 110.59,100.81 108.81,100.81 108.05,101.57 104.13,101.57 103.37,100.81 97.43,100.81 v1(96.69,100.07)
  BOTTOM w0.114: CN52.8 207.35,100.31 207.55,100.11 207.55,99.99 v2(207.35,99.79) ; R67496.1 96.62,100 v1(96.69,100.07)
USBP8+: length 126.6
  TOP w0.114: v1(31.62,100.96) 31.62,100.81 31.47,100.66 30.92,100.66 29.74,101.27 28.13,101.53 22.4,101.53 21.95,101.32 20.1,100.36 19.47,99.73 19.47,99.35 19.2,99.08 U14.3
  IN3 w0.089: v1(120.21,130.06) 120.13,130.06 119.95,130.24 119.95,130.31 120.07,130.43 121.65,130.43 121.84,130.25 121.84,130.04 122.09,129.79 122.09,129.74 122.12,129.71
  IN3 w0.114: 122.12,129.71 122.34,129.49 122.54,129.49 123.35,128.69 123.35,123.89 123.49,123.47 123.49,119.97 122.79,119.28 121.68,119.28 120.57,118.89 118.79,118.37 115.96,118.37 114.13,117.85 112.79,117.18 112.31,116.7 111.44,116.7 110.02,115.9 107.68,113.56 107.68,113.03 107.4,112.75 106.42,112.75 105.53,112.37 102.41,112.37 100.88,111.53 99.49,110.39 97.58,110.37 95.42,110.37 90.48,108.2 88.18,108.08 83.74,108.08 82.15,107.61 81.53,107.61 77.73,105.81 75.99,104.75 75.15,104.15 72.49,104.15 71.55,103.74 69.55,102.46 67.49,101.43 65.58,100.29 58.55,100.29 55.75,99.84 53,99.84 47.8,100.12 42.67,100.12 42.56,100.23 35.82,100.23 35.58,100.47 31.96,100.47 31.67,100.76 31.67,100.91 v1(31.62,100.96)
  BOTTOM w0.114: v1(120.21,130.06) 120.21,130.3 120.02,130.49 U6539.CW9
USBP8+_C: length 18.2
  TOP w0.114: U14.10 19.2,94.89 19.47,94.62 19.47,94.43 19.48,94.42 19.48,94.25 v2(19.43,94.2) ; R425.2 22.21,103.4 22.65,103.84 22.65,104.06 v2(22.88,104.29)
  IN4 w0.089: v2(22.88,104.29) 22.88,104.31 22.68,104.52 22.68,104.64 22.32,105 21.38,105 20.82,104.44 20.82,102.46 20.16,101.8 20.16,95.83 19.6,95.27 19.6,94.38 v2(19.43,94.2)
USBP8+_C_R: length 7.5
  TOP w0.114: R425.1 18.78,103.86 18.43,103.86 D13165.1 17.99,103.86 16.92,103.86 16.48,104.3 16.48,106.78 16.17,107.08 15.92,107.08 15.6,106.76 CN3.3
USBP8-: length 126.7
  TOP w0.114: v1(31.62,100.23) 31.41,100.43 30.86,100.43 29.66,101.05 28.11,101.3 22.45,101.3 22.06,101.12 20.14,100.07 19.7,99.64 U14.2
  IN3 w0.089: v1(119.63,130.06) 119.77,130.2 119.77,130.39 120,130.61 121.73,130.61 122.02,130.32 122.02,130.11 122.24,129.89 122.26,129.89 122.27,129.89 122.28,129.89 122.29,129.89
  IN3 w0.114: 122.29,129.89 122.44,129.73 122.64,129.73 123.59,128.79 123.59,123.93 123.73,123.51 123.73,119.87 122.89,119.03 121.72,119.03 120.64,118.66 118.83,118.13 116,118.13 114.22,117.62 112.93,116.98 112.41,116.46 111.51,116.46 110.17,115.71 107.92,113.46 107.92,112.93 107.5,112.51 106.47,112.51 105.58,112.12 102.47,112.12 101.02,111.33 99.57,110.14 97.58,110.12 95.47,110.12 90.54,107.96 88.19,107.84 83.78,107.84 82.19,107.37 81.58,107.37 77.84,105.6 76.12,104.54 75.23,103.91 72.54,103.91 71.66,103.53 69.67,102.25 67.6,101.21 65.64,100.05 58.57,100.05 55.77,99.6 53,99.6 47.79,99.88 42.57,99.88 42.46,99.98 35.72,99.98 35.48,100.23 v1(31.62,100.23)
  BOTTOM w0.114: v1(119.63,130.06) 119.63,129.89 U6539.DA9
USBP8-_C: length 18.1
  TOP w0.114: v2(22.14,104.29) 22.3,104.29 22.42,104.16 22.42,103.93 22.12,103.63 20.62,103.63 20.49,103.76 20.49,104.29 20.37,104.42 R426.2 ; v2(20.09,94.33) 19.91,94.33 19.7,94.54 U14.11
  IN4 w0.089: v2(20.09,94.33) 19.78,94.64 19.78,95.2 20.34,95.76 20.34,101.73 21,102.39 21,104.37 21.46,104.82 22.25,104.82 22.5,104.57 22.5,104.41 22.37,104.29 22.15,104.29 v2(22.14,104.29)
USBP8-_C_R: length 7.5
  TOP w0.114: CN3.2 15.6,107.61 15.9,107.31 16.27,107.31 16.71,106.87 16.71,104.39 17.01,104.09 17.99,104.09 D13164.1 18.42,104.09 18.92,104.09 R426.1
USBP9+_DB: length 127.9
  TOP w0.114: v1(223.44,122.15) 223.47,122.15 223.69,121.92 223.69,121.62 223.98,121.33 224.55,121.33 R69071.2
  IN1 w0.089: v2(207.88,117.4) 208.18,117.69 208.18,117.98 208.5,118.3 211.95,118.9 212.38,118.98 213.96,119.95 221.24,121.61 221.66,121.61 223.59,121.61 223.72,121.74 223.72,121.9 223.47,122.15 v1(223.44,122.15)
  IN4 w0.089: v1(121.83,128.7) 122.13,128.39 127.89,128.39 128.57,127.71 128.57,127.4 128.95,127.02 129.51,127.02 130.02,126.51 131.11,126.51 132.51,125.12 132.51,119.02 135.43,116.1 135.43,112.98 138.6,109.8 141.19,109.8 141.47,110.08 150.21,110.08 151.78,108.51 153.49,108.51 153.92,108.94 166.75,108.94 167.06,109.25 168.05,109.25 168.45,109.65 169.69,109.65 169.84,109.5 174.04,109.5 178.73,114.18 183.78,115.59 191.27,115.59 195.2,115.16 197.12,115.16 201.09,113.69 206.5,113.69 207.31,113.94 207.69,114.45 208.2,116.61 208.2,117.08 v2(207.88,117.4)
  BOTTOM w0.114: R67462.2 208.2,116.7 208.2,117.08 v2(207.88,117.4) ; U6539.DD5 121.96,128.56 v1(121.83,128.7)
USBP9+_DB_RS232: length 4.1
  TOP w0.114: v2(226.44,121.31) 226.21,121.54 225.95,121.54 225.61,121.19 R69071.1
  BOTTOM w0.114: CN55.8 228.11,121.46 227.9,121.68 226.8,121.68 v2(226.44,121.31)
USBP9+_DB_USB: length 2.4
  BOTTOM w0.114: CN48.10 207.95,113.94 208.12,114.12 208.12,114.72 208.12,115.12 208.12,115.15 R67462.1
USBP9-_DB: length 127.9
  TOP w0.114: R69070.2 224.83,121.68 224.71,121.56 224.07,121.56 223.92,121.71 223.92,121.92 224.14,122.15 v2(224.18,122.15)
  IN1 w0.089: v1(208.65,117.4) 208.35,117.69 208.35,117.91 208.58,118.14 211.99,118.72 212.44,118.81 214.03,119.79 221.26,121.43 221.66,121.43 223.67,121.43 223.9,121.67 223.9,121.9 224.14,122.15 v2(224.18,122.15)
  IN4 w0.089: v1(208.65,117.4) 208.38,117.13 208.38,116.59 207.86,114.37 207.42,113.79 206.53,113.51 201.06,113.51 197.08,114.99 195.19,114.99 191.26,115.41 183.8,115.41 178.82,114.02 174.11,109.32 169.77,109.32 169.62,109.47 168.52,109.47 168.13,109.08 167.14,109.08 166.82,108.76 154,108.76 153.56,108.33 151.71,108.33 150.13,109.9 141.55,109.9 141.27,109.62 138.53,109.62 135.25,112.9 135.25,116.03 132.33,118.95 132.33,125.04 131.04,126.34 129.94,126.34 129.44,126.84 128.87,126.84 128.39,127.33 128.39,127.63 127.81,128.21 122.29,128.21 122.22,128.14 122.22,127.99 v1(122.37,127.83)
  BOTTOM w0.114: v1(122.37,127.83) 122.37,127.96 122.61,128.2 U6539.DD4 ; R67461.2 208.43,116.62 208.43,117.18 v1(208.65,117.4)
USBP9-_DB_RS232: length 4
  TOP w0.114: v1(226.44,122.07) 226.44,121.87 226.33,121.76 225.78,121.76 225.61,121.93 R69070.1
  BOTTOM w0.114: CN55.7 228.25,121.96 228.19,121.9 226.6,121.9 v1(226.44,122.07)
USBP9-_DB_USB: length 2.4
  BOTTOM w0.114: CN48.9 208.45,114.05 208.35,114.15 208.35,114.72 208.35,115.08 R67461.1
USBP10+_BT: length 98.7
  IN4 w0.089: v1(190.74,116.74) 190.62,116.61 190.04,116.61 189.28,117.37 181.66,117.37 180.26,115.97 178.48,115.97 177.57,115.06 177.57,113.84 174.8,111.07 173.22,111.07 173.02,111.27 171.09,111.27 170.25,110.44 168.42,110.44 168.14,110.16 167,110.16 166.35,109.51 151.72,109.51 150.54,110.69 140.94,110.69 140.63,110.39 139.64,110.39 139.24,110.79 139.24,111.32 136.24,114.32 136.24,116.18 133.09,119.33 133.09,125.42 131.36,127.15 130.2,127.15 129.71,127.63 129.71,128.8 128.7,129.82 127.93,129.82 127.68,129.56 126.41,129.56 126.21,129.77 126.21,129.97 v1(126.44,130.2)
  BOTTOM w0.089: U6539.CV4 122.82,130.52 123.07,130.52 123.18,130.46 124.06,130.46 124.35,130.76 125.73,130.76 125.9,130.58 126.03,130.58
  BOTTOM w0.114: v1(190.74,116.74) 190.51,116.51 190.23,116.51 189.15,117.59 189.15,119.53 185.66,123.01 185.41,123.01 185.27,123.15 CN17.3 ; v1(126.44,130.2) 126.06,130.58 126.03,130.58
USBP10-_BT: length 98.7
  IN4 w0.089: v2(190.74,116.07) 190.54,116.28 190.54,116.34 190.45,116.43 189.97,116.43 189.2,117.19 181.73,117.19 180.34,115.8 178.56,115.8 177.74,114.98 177.74,113.76 174.87,110.89 173.15,110.89 172.95,111.1 171.17,111.1 170.33,110.26 168.5,110.26 168.22,109.98 167.07,109.98 166.43,109.33 151.65,109.33 150.46,110.51 141.01,110.51 140.71,110.21 139.57,110.21 139.06,110.72 139.06,111.25 136.06,114.25 136.06,116.1 132.91,119.25 132.91,125.35 131.29,126.97 130.12,126.97 129.54,127.56 129.54,128.73 128.62,129.64 128.01,129.64 127.75,129.38 126.34,129.38 126.03,129.69 126.03,129.97 v1(125.8,130.2)
  BOTTOM w0.089: U6539.CY3 122.85,130.04 122.77,130.12 122.77,130.25 122.86,130.34 123.02,130.34 123.13,130.28 124.13,130.28 124.43,130.58 125.65,130.58 125.84,130.39 125.84,130.37 125.85,130.37 125.85,130.24 v1(125.8,130.2)
  BOTTOM w0.114: CN17.5 185.29,122.65 185.42,122.79 185.57,122.79 188.92,119.43 188.92,117.5 190.14,116.28 190.54,116.28 v2(190.74,116.07)
USIM_DET: length 104.4
  TOP w0.114: v2(225.6,125.35) 225.6,125.88 225.75,126.04 R69065.2 ; v2(200.07,97.56) 198.65,96.14 v2(198.17,96.14) 198.05,96.02 197.7,96.02 196.72,95.04 175.3,95.04 173.9,96.45 172.28,96.45 171.9,96.83 170.07,96.83 169.49,97.41 169.21,97.41 168.28,98.34 U37.68
  IN1 w0.089: v2(200.07,97.56) 200.1,97.53 204.26,97.53 204.59,97.2 205.81,97.2 207.18,98.57 208.9,98.57 208.96,98.51 216.01,98.51 218.19,100.69 221.09,100.69 225.86,105.45 225.86,110.98 228.44,113.56 230.93,113.56 232.07,114.7 232.07,115.72 235,118.64 235,122.83 231.57,126.26 226.51,126.26 v2(225.6,125.35)
  BOTTOM w0.114: v2(225.6,125.35) 225.66,125.29 225.66,124.23 224.63,123.21 223.57,123.21 223.1,122.75 CN49.11
VA2: length 148.6
  IN1 w0.381: v2(72.44,198.4) 73.83,197 76.88,197 79.8,194.08 81.17,194.08 81.63,193.62 v2(81.63,191.79)
  IN2 w0.254: v2(161.27,124.93) 155.87,130.32 155.87,130.83 154.6,132.1 152.45,132.1 152.19,132.36 152.19,133.14 150.72,134.62 144.34,134.62 142.16,136.8 142.16,144.68 140.51,146.33 140.51,151.03 141.78,152.3 141.78,166.27 137.76,170.28 128.11,170.28 v2(127.93,170.46)
  IN3 w0.381: v2(127.93,170.46) 127.35,169.87 125.85,169.87 121.97,173.76 118.99,173.76 116.76,175.99 116.76,176.7 116.5,176.96 115.79,176.96 114.07,178.69 114.07,183.64 113.28,184.43 112.31,184.43 111.81,184.93 110.92,184.93 110.56,184.58 106.83,184.58 105.89,185.52 104.52,185.52 104.44,185.44 99.74,185.44 98.01,183.71 94.18,183.71 93.77,184.13 93.77,186.08 93.14,186.71 93.14,188.49 91.1,190.52 87.55,190.52 86.91,191.16 82.34,191.16 81.71,191.79 v2(81.63,191.79)
  BOTTOM w0.381: v2(161.27,124.93) 161.3,124.9 PR28.1
  vias: v2(70.81,196.26)
VADJ1: length 7.7
  BOTTOM w0.114: R441.2 66.88,188.46 67.07,188.27 R442.1 C558.1 68.69,188.27 68.88,188.46 68.88,188.87 69.44,189.43 69.44,189.71 69.24,189.91 v2(69.24,191.28) 69.65,191.7 CN29.27
VADPBL:
  vias: v2(57.35,205.71)
VCOREI: length 2.2
  BOTTOM w0.203: U6556.8 v2(135.94,119.15) 136.03,119.06 136.75,119.06 R68796.1
VGA_DDC_CLK_RT: length 27.9
  TOP w0.114: U67.15 29.78,155.52 29.03,156.27 v2(29.03,156.6) 28.75,156.89 v2(28.75,157.25) ; CN21.15 8.3,161.69 9.42,160.58 R25529.2 10.43,160.58 10.98,160.03 ESD4.6 ESD4.5 12.48,160.03 12.87,160.42 12.87,160.93 13.13,161.19 C20006.2 13.54,160.9 13.76,160.68 14.65,160.68 v2(14.85,160.88)
  IN1 w0.089: v2(14.85,160.88) 16.84,158.9 23.67,158.9 23.92,158.65 24.3,158.65 24.56,158.9 27.6,158.9 28.75,157.76 v2(28.75,157.25)
VGA_DDC_DAT_RT: length 28.4
  TOP w0.114: v2(14.9,157.12) 14.55,157.47 C20004.1 R25528.2 12.59,157.47 ESD4.1 ESD4.10 10.44,158.03 9.95,158.52 9.44,158.52 9.04,158.11 9.04,157.5 8.3,156.76 CN21.12 ; v2(27.99,157.5) 28.07,157.42 v2(28.07,156.7) 29.38,155.39 U67.16
  IN1 w0.089: v2(28.07,156.7) 28.07,157.98 27.39,158.66 24.68,158.66 24.42,158.39 23.79,158.39 23.53,158.66 16.44,158.66 v2(14.9,157.12)
VGA_DDI2_AUXN_C: length 3.1
  TOP w0.114: U67.3 33.41,152.08 33.58,151.9 33.78,151.9 34.53,151.15 35.25,151.15 C20014.2
VGA_DDI2_AUXP_C: length 3.1
  TOP w0.114: U67.2 33.68,151.68 34.44,150.92 35.23,150.92 C20015.2
VGA_DDI2_TXN0_C: length 3
  TOP w0.114: C20017.2 35.25,153.69 34.14,153.69 33.63,153.18 33.45,153.18 33.36,153.28 U67.6
VGA_DDI2_TXN1_C: length 3.7
  TOP w0.114: U67.8 33.39,154.08 33.46,154.01 33.64,154.01 33.83,154.2 33.83,154.78 34.38,155.33 35.24,155.33 C20019.2
VGA_DDI2_TXP0_C: length 3
  TOP w0.114: C20016.2 35.23,153.46 34.23,153.46 33.72,152.95 33.47,152.95 33.39,152.88 U67.5
VGA_DDI2_TXP1_C: length 3.7
  TOP w0.114: C20018.2 35.24,155.1 34.48,155.1 34.06,154.68 34.06,154.11 33.73,153.78 33.53,153.78 33.43,153.68 U67.7
VGA_OVT#: length 27
  IN2 w0.102: v1(104.64,182.44) 104.64,180.21 106.98,177.87 109.44,177.87 109.85,177.46 115.41,177.46 116.12,178.18 v1(116.12,179.07)
  BOTTOM w0.102: 121.32,180.8 121.91,181.39 123.69,181.39 124.42,182.13 U8.A6
  BOTTOM w0.114: Q15.1 105.17,182.72 104.9,182.44 v1(104.64,182.44) ; 121.32,180.8 118.83,180.8 116.96,178.94 R395.1 116.25,178.94 v1(116.12,179.07)
VGA_RST#: length 11.4
  TOP w0.114: v1(124.82,201.05) 120.77,205.1 v2(119.93,205.1)
  BOTTOM w0.114: v2(119.93,205.1) 118.79,206.24 C364.1 119.33,207.82 119.43,207.92 R296.1
  BOTTOM w0.127: U8.AC7 v1(124.82,201.05)
VGA_SDA: length 3.7
  TOP w0.114: R25530.1 32.31,148.49 32.15,148.33 R458.2 31.16,148.96 31.16,149.63 30.98,149.81 U67.29
VGA_SLK: length 6.2
  TOP w0.114: R25533.2 33.32,146.83 33.32,146.84 33.32,148.27 33.54,148.49 R25531.1 33.33,148.99 32.05,148.99 v2(31.72,149.32) 31.72,149.58 31.38,149.92 U67.30
VGA_VCCSENSE: length 27.5
  TOP w0.203: v1(98.78,191.46) 98.79,191.48 PR9028.2
  IN1 w0.203: v2(116.63,189.38) 116.25,189.38 116.12,189.51 115.36,189.51 115.06,189.2 112.87,189.2 112.21,188.54 108.3,188.54 107.67,189.18 101.93,189.18 100.93,190.17 99.59,190.17 98.62,191.13 98.62,191.31 v1(98.78,191.46)
  BOTTOM w0.203: U8.F2 120.71,186.95 120.07,186.95 119.86,187.17 119.86,188.06 119.25,188.67 117.22,188.67 116.63,189.25 v2(116.63,189.38)
  BOTTOM w0.254: v2(116.63,189.38) 116.76,189.51 PR9026.2
VGA_VSSSENSE: length 27.9
  TOP w0.203: v1(98.17,191.51) 98.47,191.82 PR9029.2
  IN1 w0.203: v1(98.17,191.51) 98.29,191.39 98.29,190.95 99.39,189.86 100.78,189.86 101.77,188.87 107.5,188.87 108.13,188.24 112.34,188.24 113,188.9 115.18,188.9 115.46,189.18 115.9,189.18 v2(116.2,188.87)
  BOTTOM w0.203: U8.F1 119.97,186.55 119.53,186.99 119.53,187.88 119.05,188.36 116.96,188.36 116.45,188.87 v2(116.2,188.87)
  BOTTOM w0.254: PR9031.2 115.77,189.3 v2(116.2,188.87)
VL: length 257.1
  TOP w0.114: v2(30.14,106.7) 30.39,106.46 PR8050.2
  IN3 w0.102: v2(39.01,158.11) 39.6,158.7 39.6,172.29 45.38,178.08 52.88,178.08 53.27,178.47 53.27,178.62 53.84,179.19 v1(53.97,179.19)
  IN4 w0.089: v1(117.55,94.64) 115.62,94.64 114.85,93.87 97.07,93.87 95.54,95.39 93.77,95.39 93.01,94.64 79.69,94.64 76.67,91.61 75.15,91.61 74.39,90.85 50.57,90.85 49.32,92.1 49.32,93.77 48.31,94.79 45.38,94.79 44.75,95.42 37.49,95.42 32.94,99.97 32.94,103.27 30.14,106.07 v2(30.14,106.7) 30.14,107.97 31.32,109.15 31.32,114.29 30.31,115.3 28.33,115.3 27.27,116.35 27.27,121.51 26.21,122.58 26.21,127.15 24.18,129.18 24.18,131.47 24.37,131.66 24.37,153.01 23.56,153.82 v2(23.56,156.58)
  BOTTOM w0.114: v2(23.56,156.58) 23.56,156.4 24.07,155.89 28.25,155.89 28.55,155.6 32.56,155.6 34.08,157.12 35.88,157.12 36.87,158.11 v2(39.01,158.11) ; v1(117.55,94.64) 118.18,94 121.84,94 123.62,95.78 137.59,95.78 140,98.19 140,104.16 139.06,105.1 137.34,105.1 137.26,105.18 136.57,105.18 135.89,105.86 v4(135.89,107.44) 135.55,107.77 135.55,108.23 134.64,109.14 134.64,109.65 133.15,111.14 133.15,112.15 PR3020.1 ; PR6025.1 59.93,177.95 58.94,176.96 57.88,176.96 57.58,177.26 53.82,177.26 53.41,177.67 53.41,178.74 53.87,179.19 v1(53.97,179.19)
VMA_CLK0: length 40
  IN1 w0.102: v1(159,182.02) 159.3,182.32 159.3,184.05 158.03,185.32 156.94,185.32 156.57,185.68 156.57,186.59 156.45,186.71 156.07,186.71 155.94,186.59 155.94,185.63 155.62,185.32 155.12,185.32 154.89,185.55 154.89,186.67 154.78,186.78 154.26,186.78 154.14,186.65 154.14,185.49 153.9,185.25 153.33,185.25 153.08,185.49 153.08,186.71 152.95,186.84 152.45,186.84 152.32,186.71 152.32,185.57 151.97,185.22 151.26,185.22 150.93,185.55 150.93,185.63 150.93,185.81 150.93,186.45 150.8,186.59 150.41,186.59 150.19,186.36 150.19,185.74 149.95,185.51 141.98,185.51 141.35,184.87 140.13,184.87 v1(139.72,185.29)
  BOTTOM w0.079: v1(159,182.02) 159.4,181.63 VRAM1.J12 159.4,181.37 159.48,181.3 159.59,181.3 159.72,181.43 159.72,183.67 160.16,184.11 160.16,184.4 160.13,184.43 160.13,184.45
  BOTTOM w0.102: U8.D24 139.69,184.85 139.79,184.95 139.79,185.21 v1(139.72,185.29)
  BOTTOM w0.127: 160.13,184.45 160.13,185.19 160.7,185.77 160.7,186.56 R25488.2
VMA_CLK0#: length 40.2
  IN1 w0.102: v1(159,181.22) 159.49,181.71 159.49,184.12 158.11,185.51 157.02,185.51 156.76,185.76 156.76,186.66 156.53,186.9 155.99,186.9 155.75,186.66 155.75,185.71 155.54,185.51 155.2,185.51 155.08,185.63 155.08,186.75 154.86,186.97 154.19,186.97 153.95,186.73 153.95,185.57 153.82,185.44 153.4,185.44 153.27,185.57 153.27,186.79 153.03,187.03 152.37,187.03 152.13,186.79 152.13,185.65 151.89,185.41 151.34,185.41 151.12,185.63 151.12,185.81 151.12,186.53 150.87,186.78 150.33,186.78 150,186.44 150,185.82 149.88,185.7 141.9,185.7 141.27,185.06 140.71,185.06 v1(140.5,185.26)
  BOTTOM w0.079: v1(159,181.22) 159,181.21 VRAM1.J11 159.4,181.06 159.48,181.14 159.66,181.14 159.88,181.36 159.88,183.6 160.32,184.04 160.32,184.4 160.36,184.43 160.36,184.45
  BOTTOM w0.102: U8.D25 140.12,184.88 v1(140.5,185.26)
  BOTTOM w0.127: 160.36,184.45 160.36,185.1 160.93,185.67 160.93,186.59 R25488.1
VMA_CLK1: length 43
  IN1 w0.102: v1(159,197.22) 159.24,196.99 159.24,196.68 158.98,196.43 152.87,196.43 149.58,193.13 149.58,191.99 150.16,191.41 153.21,191.41 153.46,191.16 153.46,190.52 153.21,190.27 143.09,190.27 142.46,190.9 139.11,190.9 138.53,191.48 138.28,191.48 138.1,191.66 v1(138.1,191.91)
  BOTTOM w0.079: 160.51,194.02 160.51,194.04 160.55,194.08 160.55,196.21 160.42,196.34 159.92,196.34 159.72,196.54 159.72,197.07 159.64,197.15 159.56,197.15 159.4,196.99 VRAM2.J12 159.4,196.51 159.33,196.44 159.06,196.44 159,196.5 v1(159,197.22)
  BOTTOM w0.127: U8.N22 137.68,192.15 137.92,191.91 v1(138.1,191.91) ; 160.51,194.02 160.51,193.79 160.07,193.35 160.07,192.17 159.94,192.05 R25489.2
VMA_CLK1#: length 43.2
  IN1 w0.102: v1(138.1,191.09) 138.3,191.29 138.45,191.29 139.03,190.71 142.38,190.71 143.01,190.08 153.29,190.08 153.65,190.44 153.65,191.24 153.29,191.6 150.24,191.6 149.77,192.07 149.77,193.05 152.95,196.24 159.06,196.24 159.43,196.6 159.43,197.61 v1(159,198.04)
  BOTTOM w0.079: VRAM2.J11 159.4,197.43 159.53,197.3 159.71,197.3 159.88,197.13 159.88,196.61 159.99,196.49 160.48,196.49 160.7,196.27 160.7,194.08 160.74,194.04 160.74,194.02 ; v1(159,198.04) 159.4,197.64 159.4,197.63
  BOTTOM w0.102: 159.4,197.63 VRAM2.J11
  BOTTOM w0.127: 160.74,194.02 160.74,193.7 160.29,193.26 160.29,192.2 160.39,192.1 R25489.1 ; U8.M22 v1(138.1,191.09)
VMA_DQ0: length 40.3
  IN1 w0.127: v1(162.2,173.22) 161.8,172.82 161.8,172.07 161.19,171.45 156.91,171.45 155.49,172.87 152.32,172.87 151.18,174.01 151.18,175.92 148.75,178.34 137.83,178.34 134.41,181.76 134.41,182.27 134.16,182.52 134.16,183.03 134.32,183.19 134.32,184.82 134.43,184.93 134.43,185.55 v1(133.91,186.08)
  BOTTOM w0.165: v1(162.2,173.22) 162.6,173.62 VRAM1.E2 ; U8.E18 v1(133.91,186.08)
VMA_DQ1: length 37.8
  IN1 w0.127: v1(161.4,173.22) 161.01,172.83 161.01,172.17 160.82,171.99 157.14,171.99 155.62,173.5 152.7,173.5 151.97,174.24 151.97,176.01 149.11,178.87 138.19,178.87 135.43,181.63 135.43,182.27 135.39,182.31 135.39,184.53 134.93,184.99 134.93,185.84 v1(134.71,186.05)
  BOTTOM w0.165: v1(161.4,173.22) 161.79,173.62 VRAM1.F2 ; v1(134.71,186.05) 134.34,186.42 U8.F18
VMA_DQ2: length 48.4
  IN1 w0.127: v1(133.08,186.04) 132.71,185.67 132.71,184.76 131.87,183.92 131.87,181.12 132,181 132,180.49 132.63,179.85 134.69,179.85 137.27,177.27 148.04,177.27 149.91,175.41 149.91,173.38 151.94,171.35 154.73,171.35 155.75,170.33 163.86,170.33 166.2,172.67 v1(166.2,173.22)
  BOTTOM w0.102: v1(133.08,186.04) 132.67,185.65 U8.E16
  BOTTOM w0.165: VRAM1.A2 165.81,173.62 v1(166.2,173.22)
VMA_DQ3: length 46.3
  IN1 w0.127: v1(165.4,173.22) 165.01,172.83 165.01,172.27 163.6,170.86 156.1,170.86 155.05,171.92 152.13,171.92 150.54,173.5 150.54,175.66 148.4,177.81 137.6,177.81 134.92,180.49 133.9,180.49 133.4,181 133.4,181.51 133.14,181.76 133.14,183.92 133.51,184.28 133.51,186.54 v1(133.91,186.94)
  BOTTOM w0.165: U8.F17 133.53,186.49 133.91,186.86 v1(133.91,186.94) ; v1(165.4,173.22) 165.01,173.62 VRAM1.B2
VMA_DQ4: length 31
  IN1 w0.127: v1(161.4,175.62) 161,176.02 161,176.63 160.33,177.3 155.63,177.3 154.86,178.08 152.45,178.08 150.05,180.48 138.87,180.48 137.45,181.9 137.45,182.27 136.37,183.35 v1(136.37,184.4)
  BOTTOM w0.165: U8.D20 136.37,184.46 v1(136.37,184.4) ; VRAM1.F4 161.8,175.22 v1(161.4,175.62)
VMA_DQ5: length 34
  IN1 w0.127: v1(165.4,174.82) 165.01,175.22 165.01,176.03 163.72,177.32 162.14,177.32 161,178.46 156.13,178.46 155.37,179.22 153.08,179.22 150.73,181.57 140.19,181.57 138.37,183.39 137.87,183.39 137.22,184.03 v1(137.22,184.45)
  BOTTOM w0.165: v1(165.4,174.82) 165.01,175.22 VRAM1.B4 ; U8.D21 v1(137.22,184.45)
VMA_DQ6: length 32.8
  IN1 w0.127: v1(136.42,186.02) 136.8,185.64 136.8,183.69 137.71,182.78 138.09,182.78 139.84,181.03 150.38,181.03 152.73,178.68 155.02,178.68 155.84,177.86 160.61,177.86 161.8,176.67 161.8,176.03 162.2,175.63 v1(162.2,175.62)
  BOTTOM w0.165: v1(136.42,186.02) 135.98,186.45 U8.F20 ; VRAM1.E4 162.6,175.22 v1(162.2,175.62)
VMA_DQ7: length 35.2
  IN1 w0.127: v1(166.2,174.82) 165.8,175.22 165.8,176.02 163.88,177.95 162.48,177.95 161.34,179.09 156.38,179.09 154.99,180.49 154.1,180.49 153.64,180.95 152.24,180.95 151.09,182.1 141.78,182.1 141.49,182.39 140.38,182.39 138.85,183.92 137.97,183.92 137.62,184.27 137.62,184.85 v1(137.22,185.25)
  BOTTOM w0.165: v1(137.22,185.25) 136.82,185.65 U8.E21 ; VRAM1.A4 165.81,175.22 v1(166.2,174.82)
VMA_DQ8: length 43
  IN4 w0.127: v1(132.26,186.04) 132.26,187.23 133.11,188.08 133.58,188.08 134.29,187.37 140.54,187.37 140.84,187.68 145.59,187.68 145.76,187.86 149.66,187.86 150.33,188.53 162.57,188.53 164.26,186.84 164.26,183.02 165,182.27 165,180.82 v1(165.4,180.42)
  BOTTOM w0.165: v1(132.26,186.04) 132.26,186.02 131.88,185.65 U8.E15 ; VRAM1.B11 165.01,180.82 v1(165.4,180.42)
VMA_DQ9: length 35.5
  IN4 w0.127: v1(162.2,182.82) 162.6,183.22 162.6,183.79 161.31,185.09 160.55,185.09 159.11,186.52 157.98,186.52 157.14,187.36 150.79,187.36 149.88,186.46 146.72,186.46 145.84,185.57 142.79,185.57 142.16,186.2 141.27,186.2 140.75,185.68 138.77,185.68 138.74,185.65 137.04,185.65 137,185.61 135.94,185.61 135.9,185.65 132.87,185.65 132.48,185.25 v1(132.27,185.25)
  BOTTOM w0.165: v1(162.2,182.82) 162.6,182.42 VRAM1.E13
  BOTTOM w0.178: v1(132.27,185.25) 132.27,185.22 131.89,184.85 U8.D15
VMA_DQ10: length 45.6
  IN4 w0.127: v1(131.36,186.89) 131.18,187.06 131.18,188.46 131.64,188.92 132.77,188.92 132.92,189.07 132.92,189.58 133.31,189.96 134.72,189.96 135.66,189.02 140.33,189.02 140.39,189.07 145.13,189.07 145.14,189.06 149.34,189.06 149.88,189.6 163.15,189.6 166.63,186.11 166.63,182.46 v1(166.2,182.02)
  BOTTOM w0.165: v1(131.36,186.89) 131.75,186.49 U8.F15 ; v1(166.2,182.02) 165.81,182.42 VRAM1.A13
VMA_DQ11: length 49.9
  IN4 w0.127: v1(166.2,180.42) 167.3,181.53 167.3,186.2 163.38,190.13 149.51,190.13 148.98,189.59 147.1,189.59 146.79,189.9 145.73,189.9 145.43,189.61 140.28,189.61 140.05,189.83 135.61,189.83 135.08,190.36 132.67,190.36 129.8,187.5 v1(129.8,186.05)
  BOTTOM w0.165: U8.F13 130.18,186.43 v1(129.8,186.05) ; VRAM1.A11 165.81,180.82 v1(166.2,180.42)
VMA_DQ12: length 37.6
  IN4 w0.127: v1(163,181.22) 162.61,181.62 161.98,181.62 161.8,181.8 161.8,182.18 161.56,182.42 160.37,182.42 159.56,183.23 159.56,183.66 158.41,184.81 157.43,184.81 156.47,185.76 151.45,185.76 150.12,184.44 146.97,184.44 146.35,183.82 144.34,183.82 143.95,183.42 140.51,183.42 139.89,184.04 139.23,184.04 138.84,183.65 134.58,183.65 134.21,184.02 133.6,184.02 133.35,183.76 130.75,183.76 v1(130.64,183.65)
  BOTTOM w0.165: U8.C13 130.25,184.05 v1(130.64,183.65) ; VRAM1.E11 162.6,180.82 v1(163,181.22)
VMA_DQ13: length 37.2
  IN4 w0.127: v1(129.8,182.85) 130.21,182.45 130.78,182.45 131.54,183.2 134.33,183.2 134.41,183.28 139.24,183.28 140.13,182.39 141.14,182.39 141.63,182.89 142.68,182.89 143.05,182.52 143.81,182.52 144.57,183.28 149.72,183.28 151.67,185.23 156.25,185.23 157.31,184.17 158.29,184.17 158.92,183.54 158.92,182.79 160.1,181.62 161.01,181.62 v1(161.4,181.22)
  BOTTOM w0.165: v1(161.4,181.22) 161.8,180.82 VRAM1.F11 ; v1(129.8,182.85) 130.18,183.23 U8.B13
VMA_DQ14: length 44.8
  IN4 w0.127: v1(130.64,185.25) 131.03,185.65 131.03,186.31 131.22,186.49 131.61,186.49 131.84,186.72 131.84,187.18 133.36,188.69 133.36,188.81 133.67,189.12 134.54,189.12 135.65,188.01 136.98,188.01 137.17,188.2 139.9,188.2 139.92,188.22 145.37,188.22 145.54,188.39 149.42,188.39 150.1,189.06 162.92,189.06 164.89,187.09 164.89,183.35 165.5,182.75 165.5,182.12 v1(165.4,182.02)
  BOTTOM w0.165: v1(165.4,182.02) 165.01,182.42 VRAM1.B13 ; U8.E13 130.25,185.65 v1(130.64,185.25)
VMA_DQ15: length 35.5
  IN4 w0.127: v1(130.64,184.45) 131.07,184.02 133.24,184.02 133.49,184.27 134.32,184.27 134.6,183.99 138.55,183.99 138.96,184.4 139.89,184.4 140.33,183.95 143.73,183.95 144.12,184.35 146.13,184.35 146.75,184.97 149.9,184.97 151.23,186.3 156.7,186.3 157.55,185.44 158.54,185.44 159.96,184.02 160.86,184.02 161,183.88 161,183.22 v1(161.4,182.82)
  BOTTOM w0.165: U8.D13 130.25,184.85 v1(130.64,184.45) ; VRAM1.F13 161.8,182.42 v1(161.4,182.82)
VMA_DQ16: length 32.2
  IN4 w0.127: v1(155.82,180.41) 155.49,180.09 155.49,179.5 155.17,179.18 153.68,179.18 152.09,177.59 134.26,177.59 134.16,177.7 132.76,177.7 130.5,179.96 130.5,181.19 v1(131.4,182.08)
  BOTTOM w0.165: VRAM1.N11 156.2,180.79 v1(155.82,180.41) ; v1(131.4,182.08) 131.4,182.81 131.83,183.25 U8.B15
VMA_DQ17: length 26.7
  IN4 w0.127: v1(152.57,180.43) 150.79,178.66 135.3,178.66 135,178.97 133.4,178.97 131.97,180.39 131.97,181.48 v1(132.35,181.86)
  BOTTOM w0.165: v1(132.35,181.86) 132.26,181.95 132.26,183.65 U8.C16 ; VRAM1.U11 152.95,180.82 v1(152.57,180.43)
VMA_DQ18: length 33.5
  IN4 w0.127: v1(156.61,180.42) 156.13,179.94 156.13,179.35 155.24,178.46 154.1,178.46 152.7,177.06 135.05,177.06 134.41,176.43 133.52,176.43 132.89,177.06 132.63,177.06 132.12,177.57 129.97,179.73 129.97,181.52 v1(130.34,181.89)
  BOTTOM w0.165: v1(130.34,181.89) 130.18,182.05 U8.A13 ; v1(156.61,180.42) 157,180.81 VRAM1.M11
VMA_DQ19: length 27.2
  IN4 w0.127: v1(153.41,180.41) 151.12,178.13 135,178.13 134.79,178.33 133.14,178.33 131.11,180.36 131.11,181.11 v1(131.46,181.46)
  BOTTOM w0.165: VRAM1.T11 153.41,180.43 v1(153.41,180.41) ; v1(131.46,181.46) 131.89,181.88 131.89,182.42 U8.A15
VMA_DQ20: length 23
  IN4 w0.127: v1(152.42,182.37) 152.33,182.45 151.91,182.45 151.47,182.01 151.47,182.01 149.72,180.26 136.04,180.26 135.58,180.72 134.44,180.72 v1(134.16,181)
  BOTTOM w0.102: v1(134.16,181) 133.5,181.65 133.5,181.97 134,182.46 134,182.74 134.34,183.09 U8.B18
  BOTTOM w0.165: VRAM1.U13 152.95,182.37 v1(152.42,182.37)
VMA_DQ21: length 23.4
  IN4 w0.127: v1(153.39,183.63) 152.34,183.63 149.5,180.79 138.43,180.79 138.09,181.12 137.46,181.12 137.13,180.79 136.27,180.79 135.81,181.25 134.79,181.25 134.18,181.86 v1(134,181.86)
  BOTTOM w0.165: VRAM1.T13 153.39,182.83 v1(153.39,183.63) ; U8.A18 134.34,182.2 v1(134,181.86)
VMA_DQ22: length 27.3
  IN4 w0.127: v1(155.82,182.82) 156.24,183.25 156.24,183.73 155.81,184.16 152.12,184.16 149.28,181.33 139.62,181.33 138.53,182.42 137.21,182.42 137.06,182.27 137.06,181.51 136.93,181.38 136.57,181.38 136.45,181.51 136.45,182.27 136.29,182.42 135.58,182.42 v1(135.02,181.86)
  BOTTOM w0.165: VRAM1.N13 156.2,182.44 v1(155.82,182.82) ; v1(135.02,181.86) 135.02,182.33 U8.A19
VMA_DQ23: length 27.1
  IN4 w0.127: v1(156.61,182.82) 156.89,183.1 156.89,183.84 156.03,184.7 151.89,184.7 149.06,181.86 139.9,181.86 138.88,182.88 134.79,182.88 v1(134.76,182.85)
  BOTTOM w0.165: v1(134.76,182.85) 134.76,183.67 U8.C19 ; v1(156.61,182.82) 157,182.42 VRAM1.M13
VMA_DQ24: length 21.2
  BOTTOM w0.165: U8.B24 139.32,183.02 139.72,182.62 139.72,181.85
  BOTTOM w0.178: VRAM1.N4 155.8,175.62 155.8,176.2 155.53,176.46 155.53,176.59 155,177.12 153.33,177.12 148.88,181.57 141.19,181.57 141.15,181.61 139.97,181.61 139.72,181.85
VMA_DQ25: length 19.6
  BOTTOM w0.165: 138.95,181.23 138.95,183.57 U8.C23
  BOTTOM w0.178: VRAM1.U4 152.44,175.78 152.44,175.92 148.27,180.09 140.09,180.09 138.95,181.23
VMA_DQ26: length 20.8
  BOTTOM w0.165: U8.A25 140.12,182.2
  BOTTOM w0.178: 140.12,182.2 140.29,182.04 142.37,182.04 142.64,182.3 146.8,182.3 147.06,182.04 149.45,182.04 153.52,177.97 155.25,177.97 156.61,176.61 156.61,175.61 VRAM1.M4
VMA_DQ27: length 18.3
  BOTTOM w0.165: U8.A24 139.32,181.62
  BOTTOM w0.178: VRAM1.T4 153.41,175.61 153.41,176.22 153.23,176.4 153.01,176.4 148.58,180.83 140.39,180.83 140.05,181.17 139.77,181.17 139.32,181.62
VMA_DQ28: length 27.7
  BOTTOM w0.165: U8.A21 136.82,182.09 136.97,181.94 ; 153.41,173.22 VRAM1.T2
  BOTTOM w0.178: 153.41,173.22 152.62,173.22 151.31,171.91 149.74,171.91 147.22,169.39 143.83,169.39 141.3,171.92 141.3,175.61 136.97,179.94 136.97,181.94
VMA_DQ29: length 21.8
  BOTTOM w0.165: U8.B21 137.23,182.84 137.23,182.24 137.36,182.11 137.36,180.61
  BOTTOM w0.178: VRAM1.U2 151.62,173.62 147.36,177.88 143.95,177.88 143.45,177.38 140.59,177.38 137.36,180.61
VMA_DQ30: length 36.3
  BOTTOM w0.165: 156.61,172.13 156.61,173.23 VRAM1.M2 ; U8.C20 135.98,183.84 135.53,183.38 135.53,182.24 135.47,182.18 135.47,180.08
  BOTTOM w0.178: 135.47,180.08 135.47,179.35 139.8,175.02 139.8,171.34 143.22,167.91 147.83,167.91 150.36,170.44 154.92,170.44 156.61,172.13
VMA_DQ31: length 33.6
  BOTTOM w0.165: U8.C21 136.42,183.64 136.42,180.08 ; 155.8,172.54 155.8,173.21 VRAM1.N2
  BOTTOM w0.178: 155.8,172.54 154.43,171.18 150.05,171.18 147.52,168.65 143.53,168.65 140.54,171.63 140.54,175.32 136.42,179.45 136.42,180.08
VMA_DQ32: length 39.2
  IN4 w0.127: v1(138.1,193.57) 137.71,193.17 137.71,191.67 137.87,191.51 138.25,191.51 139.01,190.75 142.23,190.75 142.84,190.14 145.21,190.14 145.51,190.44 147.01,190.44 147.31,190.14 148.46,190.14 149.12,190.8 154.58,190.8 154.95,191.17 161.35,191.17 161.72,191.54 164.51,191.54 166.8,193.82 166.8,197.43 v1(166.2,198.02)
  BOTTOM w0.165: VRAM2.U11 166.2,198.02 v1(166.2,198.02) ; U8.R22 v1(138.1,193.57)
VMA_DQ33: length 27.6
  IN4 w0.127: v1(162.2,198.02) 162.7,198.53 162.7,199.06 162.38,199.39 152.8,199.39 150.03,196.62 145.42,196.62 144.65,195.85 142.91,195.85 141.46,194.4 139.76,194.4 v1(139.73,194.38)
  BOTTOM w0.165: v1(162.2,198.02) 162.6,197.62 VRAM2.N11 ; v1(139.73,194.38) 139.35,193.99 U8.R24
VMA_DQ34: length 34.6
  IN4 w0.127: v1(138.1,194.39) 138.51,193.98 138.51,191.75 139.21,191.05 142.54,191.05 142.82,190.77 145.09,190.77 145.29,190.97 147.15,190.97 147.52,191.33 153.77,191.33 154.14,191.7 160.23,191.7 160.65,192.12 163.67,192.12 165.65,194.1 165.65,195.08 v1(166.2,195.62)
  BOTTOM w0.165: VRAM2.U13 165.81,196.02 v1(166.2,195.62)
  BOTTOM w0.305: v1(138.1,194.39) 137.7,194.79 U8.T22
VMA_DQ35: length 26.1
  IN4 w0.127: v1(161.4,198.02) 160.94,198.48 152.91,198.48 150.41,195.98 145.59,195.98 144.82,195.22 143.05,195.22 141.65,193.82 141.02,193.82 140.84,194 140.17,194 140.13,193.95 139.34,193.95 v1(138.91,193.53)
  BOTTOM w0.165: U8.R23 138.52,193.92 v1(138.91,193.53) ; VRAM2.M11 161.8,197.62 v1(161.4,198.02)
VMA_DQ36: length 25.2
  IN4 w0.127: v1(142.55,193.8) 142.55,193.97 143.27,194.69 145.05,194.69 145.71,195.35 150.67,195.35 151.94,196.62 161.16,196.62 v1(162.2,195.57)
  BOTTOM w0.127: U8.N25 140.42,192.31 140.89,192.78 141.37,192.78 141.6,193.02 142.11,193.02 142.55,193.46 v1(142.55,193.8)
  BOTTOM w0.165: v1(162.2,195.57) 162.6,195.97 VRAM2.N13
VMA_DQ37: length 23.8
  IN4 w0.127: v1(143.31,194.07) 145.2,194.07 145.58,194.45 151.42,194.45 152.95,195.98 153.46,195.98 153.97,195.48 154.48,195.48 154.99,195.98 155.49,195.98 156,195.48 156.64,195.48 157.17,196 160.97,196 v1(161.4,195.57)
  BOTTOM w0.127: v1(143.31,194.07) 143.31,193.88 142.21,192.79 141.7,192.79 141.44,192.53 141.14,192.53 U8.N26
  BOTTOM w0.165: v1(161.4,195.57) 161.8,195.97 VRAM2.M13
VMA_DQ38: length 32.5
  IN4 w0.127: v1(165.4,197.22) 165.01,196.83 165.01,194.21 163.48,192.68 159.68,192.68 159.23,192.24 153.7,192.24 153.34,191.87 147.3,191.87 146.93,191.5 145.07,191.5 144.87,191.3 140.35,191.3 140.11,191.54 140.11,192.12 139.9,192.34 139.27,192.34 v1(138.91,192.7)
  BOTTOM w0.165: U8.N23 v1(138.91,192.7) ; v1(165.4,197.22) 165.01,197.62 VRAM2.T11
VMA_DQ39: length 29
  IN4 w0.127: v1(164.6,195.62) 164.19,195.22 164.19,194.15 163.34,193.29 159.53,193.29 159.01,192.77 153.48,192.77 153.11,192.4 147.07,192.4 146.71,192.04 144.2,192.04 143.72,191.56 141.17,191.56 140.92,191.8 140.92,192.14 140.76,192.3 140.38,192.3 139.94,192.74 v1(139.73,192.74)
  BOTTOM w0.165: v1(164.6,195.62) 164.61,195.62 VRAM2.T13 ; v1(139.73,192.74) 139.32,192.33 U8.N24
VMA_DQ40: length 27.6
  IN4 w0.127: v1(161.4,202.81) 160.99,202.41 160.99,201.74 160.83,201.57 150.29,201.57 147.65,198.93 144.72,198.93 143.77,197.98 141.99,197.98 141.26,197.25 140.42,197.25 140.31,197.36 138.53,197.36 138.03,196.87 v1(138.01,196.87)
  BOTTOM w0.165: v1(138.01,196.87) 138.02,196.86 138.03,196.86 138.42,196.47 U8.V23 ; v1(161.4,202.81) 161.4,202.82 161.8,203.22 VRAM2.M4
VMA_DQ41: length 30.2
  IN4 w0.127: v1(138.03,196.04) 138.03,196.09 138.35,196.42 139.38,196.42 139.42,196.46 141.22,196.46 142.21,197.45 143.99,197.45 144.94,198.4 148.89,198.4 151.53,201.04 162.05,201.04 162.61,201.6 162.61,203.23 v1(163,203.62)
  BOTTOM w0.165: v1(163,203.62) 162.6,203.22 VRAM2.N4 ; v1(138.03,196.04) 137.68,196.39 U8.V22
VMA_DQ42: length 31.9
  IN4 w0.127: v1(138.92,194.39) 139.35,194.82 140.74,194.82 141.27,195.35 141.65,195.35 142.68,196.38 144.43,196.38 145.3,197.25 149.52,197.25 152.19,199.92 163.3,199.92 v1(166.2,202.82)
  BOTTOM w0.165: U8.T23 v1(138.92,194.39) ; v1(166.2,202.82) 165.81,203.22 VRAM2.U4
VMA_DQ43: length 31.6
  IN4 w0.127: v1(138.15,195.21) 138.47,195.54 139.39,195.54 139.47,195.62 140.51,195.62 140.81,195.92 141.46,195.92 142.45,196.91 144.21,196.91 145.16,197.86 149.25,197.86 151.89,200.5 163.08,200.5 v1(165.4,202.82)
  BOTTOM w0.165: v1(138.15,195.21) 138.09,195.21 U8.U22 ; VRAM2.T4 165.01,203.22 v1(165.4,202.82)
VMA_DQ44: length 30.5
  IN4 w0.127: v1(163,205.22) 162.6,205.62 162.6,206.22 162.41,206.42 159.23,206.42 158.61,207.03 152.23,207.03 151.18,205.98 151.18,205.88 147.01,201.71 142.51,201.71 140.91,200.11 140.91,199.18 140.66,198.93 139.23,198.93 v1(138.92,198.61)
  BOTTOM w0.165: v1(163,205.22) 162.6,204.82 VRAM2.N2 ; v1(138.92,198.61) 139.32,198.21 U8.Y24
VMA_DQ45: length 32.7
  IN4 w0.127: v1(138.92,199.35) 138.99,199.35 139.41,199.76 139.89,199.76 140.25,200.12 140.25,200.21 142.29,202.24 146.79,202.24 150.54,206 150.54,206.27 151.91,207.64 160.22,207.64 160.91,206.95 164.28,206.95 165.07,206.16 165.07,205.69 v1(164.6,205.22)
  BOTTOM w0.165: U8.AA24 v1(138.92,199.35) ; v1(164.6,205.22) 164.6,205.22 VRAM2.T2
VMA_DQ46: length 30.1
  IN4 w0.127: v1(162.2,205.22) 161.69,205.74 159.4,205.74 159.26,205.59 158.02,205.59 157.12,206.5 152.45,206.5 151.81,205.86 151.81,205.76 146.67,200.62 142.18,200.62 141.48,199.93 141.48,199.24 140.74,198.5 139.57,198.5 139.29,198.22 138.71,198.22 v1(138.14,197.65)
  BOTTOM w0.165: VRAM2.M2 161.8,204.82 v1(162.2,205.22) ; U8.Y22 v1(138.14,197.65)
VMA_DQ47: length 34.5
  IN4 w0.127: v1(138.07,199.35) 139.57,200.85 140.14,200.85 142.07,202.77 146.56,202.77 149.91,206.12 149.91,206.39 151.69,208.18 160.96,208.18 161.59,207.54 164.46,207.54 165.63,206.37 165.63,205.45 v1(165.4,205.22)
  BOTTOM w0.165: VRAM2.U2 165.4,205.22 v1(165.4,205.22) ; v1(138.07,199.35) 138.47,198.95 U8.AA23
VMA_DQ48: length 20.4
  IN1 w0.127: v1(144.15,203.17) 144.46,203.48 147.84,203.48 152.15,207.79 155.49,207.79 156.79,206.5 156.79,205.41 v1(156.6,205.22)
  BOTTOM w0.165: v1(156.6,205.22) 156.6,205.22 VRAM2.F2 ; 143.4,201.94 143.01,201.54 142.26,201.54 142.16,201.45 U8.AD27
  BOTTOM w0.178: 143.4,201.94 144.15,202.69 v1(144.15,203.17)
VMA_DQ49: length 18.9
  IN1 w0.127: v1(153.4,205.3) 153.4,206.2 153.08,206.52 152.4,206.52 148.07,202.2 142.57,202.2 v1(139.72,199.35)
  BOTTOM w0.165: U8.AB25 v1(139.72,199.35) ; VRAM2.B2 153.8,204.9 v1(153.4,205.3)
VMA_DQ50: length 20.7
  IN1 w0.127: v1(142.91,203.2) 143.38,202.73 147.85,202.73 152.28,207.16 155.35,207.16 156.26,206.26 156.26,205.66 v1(155.82,205.22)
  BOTTOM w0.165: v1(155.82,205.22) 156.2,204.84 VRAM2.E2 ; v1(142.91,203.2) 142.91,202.33 142.59,202 142.26,202 142.12,201.86 141.33,201.86 U8.AD26
VMA_DQ51: length 15.8
  IN1 w0.127: v1(143.02,201.04) 143.64,201.66 144.61,201.66 144.95,201.32 148,201.32 152.06,205.38 v1(152.44,205.38)
  BOTTOM w0.165: v1(143.02,201.04) 143.02,200.91 142.59,200.48 141.35,200.48 141.02,200.15 140.57,200.15 U8.AC25 ; v1(152.44,205.38) VRAM2.A2
VMA_DQ52: length 14.6
  IN1 w0.127: v1(153.41,202.81) 153,203.22 152.21,203.22 148.53,199.54 144.44,199.54 143.95,200.03 142.9,200.03 v1(142.51,199.64)
  BOTTOM w0.165: v1(153.41,202.81) 153.41,202.83 VRAM2.B4 ; v1(142.51,199.64) 142.41,199.64 U8.AA27
VMA_DQ53: length 15
  IN1 w0.127: v1(143.76,199.64) 143.76,199.34 144.19,198.91 148.66,198.91 v1(152.57,202.81)
  BOTTOM w0.127: U8.AA26 141.19,198.95 141.55,198.59 141.87,198.59 142.14,198.86
  BOTTOM w0.165: VRAM2.A4 152.95,203.22 152.57,202.83 v1(152.57,202.81) ; 142.14,198.86 143.1,198.86 143.4,199.17
  BOTTOM w0.178: 143.4,199.17 143.76,199.52 v1(143.76,199.64)
VMA_DQ54: length 17.7
  IN1 w0.127: v1(155.78,202.82) 155.17,202.21 152.86,202.21 149.02,198.37 v1(143.48,198.37)
  BOTTOM w0.102: v1(143.48,198.37) 142.74,197.64 141.29,197.64 U8.W26
  BOTTOM w0.165: VRAM2.E4 156.19,203.22 v1(155.78,202.82)
VMA_DQ55: length 19.7
  IN1 w0.127: v1(156.6,202.81) 156.59,202.81 155.22,201.44 152.85,201.44 149.17,197.76 142.82,197.76 v1(142.21,198.37)
  BOTTOM w0.127: v1(142.21,198.37) 142.1,198.26 141.45,198.26 141.24,198.46 140.48,198.46 U8.Y25
  BOTTOM w0.165: VRAM2.F4 156.6,202.82 v1(156.6,202.81)
VMA_DQ56: length 13.7
  BOTTOM w0.165: U8.R26 141.19,193.99 141.56,194.36 141.83,194.36 142.33,194.86
  BOTTOM w0.178: VRAM2.B13 153.41,195.62 152.64,195.62 151.99,194.97 144.46,194.97 144.35,194.86 142.33,194.86
VMA_DQ57: length 13.9
  BOTTOM w0.165: 142.22,195.16 141.47,195.16 141.29,194.98 141.29,194.63 141.05,194.39 140.52,194.39 U8.T25
  BOTTOM w0.178: VRAM2.A13 152.43,196.02 152.12,195.71 144.51,195.71 143.97,195.16 142.22,195.16
VMA_DQ58: length 18.3
  BOTTOM w0.127: U8.N27 141.87,192.45 143.2,192.45
  BOTTOM w0.178: 143.2,192.45 144.24,193.5 148.56,193.5 149.05,193.01 155.62,193.01 156.74,194.13 156.74,194.81 156.61,194.94 156.61,195.63 VRAM2.F13
VMA_DQ59: length 16.7
  BOTTOM w0.165: U8.R27 142.05,193.99 142.55,194.49
  BOTTOM w0.178: VRAM2.E13 155.8,195.61 155.8,194.89 155.57,194.67 155.57,194.12 155.2,193.75 149.5,193.75 149.01,194.24 143.8,194.24 143.55,194.49 142.55,194.49
VMA_DQ60: length 13.3
  BOTTOM w0.165: 152.63,197.99 VRAM2.A11 ; U8.V26 141.11,196.47 141.58,196 142.41,196
  BOTTOM w0.178: 152.63,197.99 145.32,197.99 143.34,196 142.41,196
VMA_DQ61: length 13.9
  BOTTOM w0.178: VRAM2.B11 153.41,198.01 153.41,198.55 153.08,198.88 145.79,198.88 143.38,196.47 U8.V27
VMA_DQ62: length 18.9
  BOTTOM w0.165: U8.W27 142.99,197.27
  BOTTOM w0.178: 142.99,197.27 143.9,198.18 143.9,199.05 145.21,200.35 155.52,200.35 156.6,199.27 156.6,198.02 VRAM2.F11
VMA_DQ63: length 18.9
  BOTTOM w0.102: VRAM2.E11 155.76,198.06 155.76,198.54 155.47,198.83 155.47,198.94
  BOTTOM w0.165: U8.W25 140.5,196.89
  BOTTOM w0.178: 140.5,196.89 143.2,196.89 144.41,198.1 144.41,198.52 145.51,199.61 154.96,199.61 155.47,199.1 155.47,198.94
VMA_WCK01: length 36.9
  IN3 w0.114: v1(133.9,183.61) 134.27,183.61 134.47,183.41 135.1,183.41 139.65,178.86 148.23,178.86 153.31,173.78 161.36,173.78 163.37,175.8 163.63,175.8 v1(163.8,175.62)
  BOTTOM w0.102: v1(133.9,183.61) 134,183.7 134,184.5 U8.D18 ; VRAM1.D4 163.4,175.22 v1(163.8,175.62)
VMA_WCK01#: length 36.8
  IN3 w0.114: v1(163.8,176.42) 163.8,176.35 163.48,176.03 163.28,176.03 161.27,174.01 153.4,174.01 148.32,179.09 139.75,179.09 135.2,183.64 134.56,183.64 134.41,183.79 134.41,184.07 v1(134.76,184.42)
  BOTTOM w0.102: v1(134.76,184.42) 134.31,184.42 134.21,184.32 134.21,184.18 U8.C18 ; v1(163.8,176.42) 163.4,176.02 VRAM1.D5
VMA_WCK23: length 27.3
  IN3 w0.114: v1(155,175.62) 154.6,176.03 153.03,176.03 149.18,179.88 140.92,179.88 138.41,182.39 137.26,182.39 135.43,184.23 135.43,184.36 134.85,184.93 134.61,184.93 134.27,184.59 133.61,184.59 133.5,184.7 133.32,184.7 v1(133.07,184.44)
  BOTTOM w0.102: v1(133.07,184.44) 133.47,184.85 U8.D17 ; v1(155,175.62) 155,175.61 VRAM1.P4
VMA_WCK23#: length 27.3
  IN3 w0.114: v1(133.1,185.23) 133.4,184.93 133.6,184.93 133.71,184.82 134.17,184.82 134.51,185.16 134.95,185.16 135.66,184.45 135.66,184.32 137.36,182.62 138.5,182.62 141.02,180.11 149.27,180.11 153.12,176.25 154.83,176.25 v1(155,176.42)
  BOTTOM w0.102: VRAM1.P5 155.21,176.02 155,176.23 v1(155,176.42) ; U8.D16 132.73,184.85
  BOTTOM w0.127: v1(133.1,185.23) 133.1,185.22 132.73,184.85
VMA_WCK45: length 35.6
  IN3 w0.089: 140.38,197.3 140.21,197.3 139.92,197.58 139.42,197.58 139.22,197.38 138.68,197.38 138.39,197.09 138.39,196.27 138.41,196.24 138.41,195.75 138.71,195.45 138.88,195.45 138.93,195.4 v1(138.93,195.14)
  IN3 w0.114: 140.38,197.3 140.93,197.3 141.12,197.48 143.85,197.48 151.68,205.32 151.68,206.09 152.35,206.75 156.85,206.75 158.35,205.25 159.14,205.25 159.64,204.75 162.04,204.75 162.48,204.31 162.48,202.74 162.61,202.6 162.78,202.6 v1(163,202.82)
  BOTTOM w0.102: VRAM2.P4 163.4,203.22 v1(163,202.82) ; U8.T24 139.32,195.08 139.21,195.2 138.99,195.2 v1(138.93,195.14)
VMA_WCK45#: length 35.6
  IN3 w0.089: v1(139.74,195.21) 139.03,195.63 138.78,195.63 138.59,195.82 138.59,196.32 138.57,196.34 138.57,197.01 138.75,197.2 139.29,197.2 139.5,197.4 139.85,197.4 140.13,197.12 140.31,197.12 140.36,197.07 140.38,197.07
  IN3 w0.114: 140.38,197.07 141.03,197.07 141.21,197.25 143.94,197.25 151.91,205.22 151.91,205.99 152.45,206.52 156.76,206.52 158.25,205.03 159.04,205.03 159.55,204.52 161.95,204.52 162.25,204.21 162.25,202.64 162.52,202.37 162.65,202.37 v1(163,202.02)
  BOTTOM w0.102: U8.U24 139.32,195.62 139.73,195.21 v1(139.74,195.21) ; VRAM2.P5 163.4,202.42 v1(163,202.02)
VMA_WCK67: length 20.2
  IN3 w0.089: v1(139.72,196.87) 139.72,196.64 139.96,196.41 140.33,196.41 140.36,196.43 140.38,196.43
  IN3 w0.114: v1(155,203.63) 155,203.48 154.86,203.35 154.69,203.35 154.67,203.35 154.45,203.58 151.18,203.58 143.81,196.21 140.98,196.21 140.76,196.43 140.38,196.43
  BOTTOM w0.102: v1(155,203.63) 155,203.62 VRAM2.D4 ; U8.V24 v1(139.72,196.87)
VMA_WCK67#: length 20.2
  IN3 w0.089: 140.38,196.21 140.36,196.21 140.33,196.23 139.9,196.23 v1(139.71,196.04)
  IN3 w0.114: 140.38,196.21 140.67,196.21 140.89,195.98 143.91,195.98 151.27,203.35 154.35,203.35 154.57,203.13 154.68,203.12 154.83,203.12 154.98,202.96 v1(154.98,202.81)
  BOTTOM w0.102: U8.V25 139.81,196.47 139.71,196.37 v1(139.71,196.04) ; v1(154.98,202.81) 155.38,202.42 VRAM2.D5
VNN_CTRL: length 6.8
  BOTTOM w0.102: U6539.DV12 118.75,121.85 119.04,121.56 119.04,121.13 118.77,120.85 118.77,120.14 119.12,119.78 119.5,119.78 119.93,119.35 119.93,118.82 119.78,118.67 119.78,117.57 120.44,116.91 TP13402.1
VR_SVID_ALERT#: length 87.7
  TOP w0.114: R68283.1 R68285.2 120.47,171.82 120.52,171.77 v2(122.35,171.77) 123.44,171.77 124.43,170.79 125.87,170.79 126.25,171.16 v2(126.25,171.17) ; v2(163.75,149.35) 163.57,149.17 PR7005.2
  IN1 w0.089: v2(163.75,149.35) 164.28,149.88 164.89,149.88 165.15,149.63 165.15,148.99 165.02,148.87 164.76,148.87 164.13,148.23 164.13,145.24 164.36,145.01 164.36,142.78 159.88,138.31 159.88,137.63 159.46,137.21 156.1,137.21 154.66,138.66 153.26,138.66 152.98,138.93 149.96,138.93 149.4,139.49 144.26,139.49 143.66,140.09 143.66,146.48 142.24,147.9 142.24,149.88 141.83,150.29 141.83,165.96 139.85,167.94 138.96,167.94 135.05,171.85 126.93,171.85 v2(126.25,171.17)
  BOTTOM w0.114: PR7049.1 163.57,149.17 v2(163.75,149.35)
VR_SVID_CLK: length 85.5
  TOP w0.114: PR7006.2 164.88,148.31 v2(165.55,148.31) ; R68286.2 121.97,171.32 122.04,171.24 123.34,171.24 123.55,171.03 v2(123.55,170.77) 123.55,170.48 123.68,170.35 126.35,170.35 v2(126.6,170.6)
  IN1 w0.089: v2(126.6,170.6) 126.92,170.92 126.92,171.22 127.05,171.35 134.79,171.35 138.67,167.47 139.68,167.47 141.42,165.73 141.42,150.03 141.83,149.63 141.83,147.67 143.25,146.25 143.25,139.93 144.09,139.09 149.02,139.09 149.58,138.53 152.75,138.53 153.03,138.25 154.5,138.25 155.95,136.8 159.68,136.8 160.32,137.44 160.32,138.17 164.76,142.62 164.76,145.18 164.54,145.41 164.54,147.11 164.76,147.34 165.78,147.34 166.11,147.67 166.11,148.05 165.85,148.31 v2(165.55,148.31)
  BOTTOM w0.114: v2(165.55,148.31) 164.88,148.31 PR7006.2
VR_SVID_DATA: length 87
  TOP w0.114: R68284.1 R68287.2 118.54,172.23 118.66,172.36 120.87,172.36 v2(120.95,172.28) 123.69,172.28 124.76,171.22 125.27,171.22 125.65,171.6 v2(125.65,171.7) ; v2(164.74,149.35) 164.63,149.24 PR7004.2
  IN1 w0.089: v2(164.74,149.35) 164.49,149.35 163.72,148.59 163.72,145.07 163.95,144.85 163.95,142.95 159.47,138.47 159.47,137.85 159.23,137.61 156.26,137.61 154.81,139.06 153.49,139.06 153.21,139.34 150.34,139.34 149.78,139.9 144.43,139.9 144.06,140.26 144.06,146.63 142.64,148.05 142.64,150.26 142.24,150.67 142.24,166.21 140.09,168.36 139.36,168.36 135.47,172.25 126.2,172.25 v2(125.65,171.7)
  BOTTOM w0.114: v2(164.74,149.35) 164.63,149.24 PR7004.2
VRALERT#: length 24.5
  TOP w0.089: v1(106.1,128.42) 106.1,128.56 106.55,129 106.55,129.61 106.25,129.91 103.33,129.91 102.92,130.32 102.53,130.32
  TOP w0.114: R68514.1 88.49,124.02 88.54,124.07 R68913.1 88.82,124.61 89.62,125.41 Q6654.3 89.62,126.87 89.77,127.02 90.19,127.02 v2(90.56,127.39) 91.24,128.07 R68513.1 91.64,128.07 91.97,128.39 93.87,128.39 95.17,129.69 98.47,129.69 99.11,130.32 102.53,130.32
  BOTTOM w0.102: U6539.DB39 106.46,128.7 106.18,128.42 v1(106.1,128.42)
VREF_RC: length 2.5
  TOP w0.114: PC7018.2 160.02,143.61 v2(159.91,143.51)
  TOP w0.178: PC7018.2 161.24,143.8 PR7013.2
VRON: length 175.7
  TOP w0.114: U37.69 168.28,98.74 168.45,98.57 168.45,98.54 169.3,97.69 169.58,97.69 170.07,97.21 R25311.1 170.71,97.21 170.82,97.09 172.01,97.09 172.4,96.71 174.01,96.71 175.41,95.31 196.61,95.31 199.04,97.74 199.04,103.3 199.94,104.2 199.94,105.71 198.7,106.95 198.7,110.28 197.91,111.07 197.91,115.8 198.34,116.23 198.34,124.41 200.29,126.36 201.31,126.36 201.98,127.02 v2(205.02,127.02) 206.93,127.02 207.56,127.66 v2(208.59,127.66)
  IN3 w0.102: v2(168.45,146.83) 167.74,147.55 167.74,148.71 166.85,149.6 166.49,149.6 166.24,149.35 166.24,149.35 166.16,149.27 166.16,146.58 164.99,145.41 164.99,141.93 162.56,139.49 161.8,139.49 159.92,137.61 158.51,137.61 157.75,138.37 157.75,138.87 155.57,141.06 154.55,141.06 v2(154.53,141.04) 154.48,140.99 154.48,140.7 154.9,140.28 154.9,139.31 153.84,138.26 153.84,137.72 154.77,136.79 157.02,136.79 157.11,136.7 160.6,136.7 161.08,137.18 164.89,137.18 166.8,135.28 166.8,126.13 169.84,123.09 181.53,123.09 181.91,122.7 185.21,122.7 185.59,123.09 189.91,123.09 191.69,124.86 197.02,124.86 197.91,125.75 202.23,125.75 203.75,127.28 208.21,127.28 v2(208.59,127.66)
  BOTTOM w0.114: v2(168.45,146.83) 167.81,147.47 167.56,147.47 167.4,147.31 PU9006.1
  BOTTOM w0.178: v2(154.53,141.04) 154.65,140.92 PR7050.1
VSTBY_3.3V_R: length 2.8
  BOTTOM w0.254: U6556.18 135.94,125.59 136.11,125.77 v2(136.11,126.21) 135.32,126.21 R68795.2
VSTBY_FSPI: length 8.9
  TOP w0.203: v2(166.8,114.58) 166.07,114.58 165.51,114.02 164.69,114.02 164.54,113.86 164.54,113.43 164.22,113.12 163.94,113.12 163.04,112.21 162.45,112.21 162.26,112.02 U37.106
  TOP w0.254: R359.2 168.81,114.69 R25330.2 166.92,114.69 v2(166.8,114.58)
WIGIG_LED: length 5.5
  TOP w0.114: TP9029.1 187.88,123.97 188.36,123.97 v2(188.46,124.08)
  BOTTOM w0.114: CN17.6 189.58,122.4 188.46,123.52 v2(188.46,124.08)
WLAN_PCIE_WAKE#: length 92.1
  TOP w0.114: R69029.2 183.3,112.39 v1(183.22,112.47)
  IN4 w0.089: v1(183.22,112.47) 182.56,111.81 181.43,111.81 180.89,111.27 180.89,105.33 179.07,103.5 175.84,103.5 172.84,106.5 168.75,106.5 168.32,106.07 162.86,106.07 162.3,106.63 148.05,106.63 147.62,106.19 145.21,106.19 144.44,105.43 140.58,105.43 140.3,105.71 136.93,105.71 135.55,107.08 133.73,107.08 131.74,109.06 130.36,109.06 125.27,114.16 125.27,117.12 124.89,117.5 123.36,117.5 122.73,118.13 122.73,118.89 122.4,119.22 121.84,119.22 120.92,120.14 120.92,120.44 120.31,121.05 118.16,121.05 117.39,121.82 116.25,121.82 114.98,123.09 114.98,125.95 v1(115.42,126.39)
  BOTTOM w0.102: v1(115.42,126.39) 115.49,126.39 115.84,126.04 U6539.DJ19
WLAN_RST#: length 3.3
  BOTTOM w0.114: CN17.52 192.83,110.9 193.29,110.44 193.77,110.44 194.64,109.57 R2665.1
