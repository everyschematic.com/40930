# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
50271-00201-001-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
50951-0084N-001-8P-SOCKET
  round 0.889 hole 0.889 unplated: (0,-2)
  round 1.092 hole 1.092 unplated: (0,2)
  rect 0.66x1.346 smd: 1(-3.905,-3.825) 2(-2.635,-3.825) 3(-1.365,-3.825) 4(-0.095,-3.825) 5(-0.095,3.825) 6(-1.365,3.825) 7(-2.635,3.825) 8(-3.905,3.825)
50960-0084N-001-8P-SOCKET
  rect 0.889x1.346 smd: 1(1.905,3.675) 2(0.635,3.675) 3(-0.635,3.675) 4(-1.905,3.675) 5(-1.905,-3.675) 6(-0.635,-3.675) 7(0.635,-3.675) 8(1.905,-3.675)
51540-03001-V01-30P-L
  rect 0.305x0.838 smd: 1(-7.25,3.175) 2(-6.75,3.175) 3(-6.25,3.175) 4(-5.75,3.175) 5(-5.25,3.175) 6(-4.75,3.175) 7(-4.25,3.175) 8(-3.75,3.175) 9(-3.25,3.175) 10(-2.75,3.175) 11(-2.25,3.175) 12(-1.75,3.175) 13(-1.25,3.175) 14(-0.75,3.175) 15(-0.25,3.175) 16(0.25,3.175) 17(0.75,3.175) 18(1.25,3.175) 19(1.75,3.175) 20(2.25,3.175) 21(2.75,3.175) 22(3.25,3.175) 23(3.75,3.175) 24(4.25,3.175) 25(4.75,3.175) 26(5.25,3.175) 27(5.75,3.175) 28(6.25,3.175) 29(6.75,3.175) 30(7.25,3.175)
  rect 0.787x2.007 smd: 31(-8.95,0) 32(8.95,0)
51614-00601-V01-6P-L
  rect 0.305x0.787 smd: 1(-1.25,2.5) 2(-0.75,2.5) 3(-0.25,2.5) 4(0.25,2.5) 5(0.75,2.5) 6(1.25,2.5)
  rect 0.406x0.787 smd: 7(-2.25,0) 8(2.25,0)
51619-01501-V03-15P-L
  rect 0.305x1.295 smd: 1(-3.5,2.8) 2(-3,2.8) 3(-2.5,2.8) 4(-2,2.8) 5(-1.5,2.8) 6(-1,2.8) 7(-0.5,2.8) 8(0,2.8) 9(0.5,2.8) 10(1,2.8) 11(1.5,2.8) 12(2,2.8) 13(2.5,2.8) 14(3,2.8) 15(3.5,2.8)
  rect 1.803x1.397 smd: 16(-5.15,0) 17(5.15,0)
51619-01601-V01-16P-L
  rect 0.305x1.295 smd: 1(-3.75,2.8) 2(-3.25,2.8) 3(-2.75,2.8) 4(-2.25,2.8) 5(-1.75,2.8) 6(-1.25,2.8) 7(-0.75,2.8) 8(-0.25,2.8) 9(0.25,2.8) 10(0.75,2.8) 11(1.25,2.8) 12(1.75,2.8) 13(2.25,2.8) 14(2.75,2.8) 15(3.25,2.8) 16(3.75,2.8)
  rect 1.803x1.397 smd: 17(-5.4,0) 18(5.4,0)
51653-0100N-V01-10P-L
  rect 0.305x1.295 smd: 1(-4.5,2.65) 2(-3.5,2.65) 3(-2.5,2.65) 4(-1.5,2.65) 5(-0.5,2.65) 6(0.5,2.65) 7(1.5,2.65) 8(2.5,2.65) 9(3.5,2.65) 10(4.5,2.65)
  rect 1.803x1.397 smd: 11(-6.65,0) 12(6.65,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
AUDIO-2SJ3127-023111F-6P
  oval 0.991x1.753 hole 0.508x1.245: 1(-4.55,-2.065) 2(4.15,-3.155) 3(4.15,-0.155) 4(4.15,3.845) 5(-4.55,0.375) 6(-4.55,4.245)
BGA6-TEXAS-CD3271-6P
  round 0.305 smd: A1(-0.5,-0.25) A2(-0.5,0.25) B1(0,-0.25) B2(0,0.25) C1(0.5,-0.25) C2(0.5,0.25)
BGA25-ITE-IT8353VG
  round 0.254 smd: A1(-1,-1) A2(-1,-0.5) A3(-1,0) A4(-1,0.5) A5(-1,1) B1(-0.5,-1) B2(-0.5,-0.5) B3(-0.5,0) B4(-0.5,0.5) B5(-0.5,1) C1(0,-1) C2(0,-0.5) C3(0,0) C4(0,0.5) C5(0,1) D1(0.5,-1) D2(0.5,-0.5) D3(0.5,0) D4(0.5,0.5) D5(0.5,1) E1(1,-1) E2(1,-0.5) E3(1,0) E4(1,0.5) E5(1,1)
BGA105-INTEL-DELTABRIDGE-0_5S
  oval 0.178x0.33 smd: A1(-2.53,-2.53) A12(-2.53,2.53) B1(-2.07,-2.53) B12(-2.07,2.53) C1(-1.61,-2.53) C12(-1.61,2.53) D1(-1.15,-2.53) D12(-1.15,2.53) E1(-0.69,-2.53) E12(-0.69,2.53) F1(-0.23,-2.53) F12(-0.23,2.53) G1(0.23,-2.53) G12(0.23,2.53) H1(0.69,-2.53) H12(0.69,2.53) J1(1.15,-2.53) J12(1.15,2.53) K1(1.61,-2.53) K12(1.61,2.53) L1(2.07,-2.53) L12(2.07,2.53) M1(2.53,-2.53) M12(2.53,2.53)
  oval 0.33x0.178 smd: A2(-2.53,-2.07) A3(-2.53,-1.61) A4(-2.53,-1.15) A5(-2.53,-0.69) A6(-2.53,-0.23) A7(-2.53,0.23) A8(-2.53,0.69) A9(-2.53,1.15) A10(-2.53,1.61) A11(-2.53,2.07) M2(2.53,-2.07) M3(2.53,-1.61) M4(2.53,-1.15) M5(2.53,-0.69) M6(2.53,-0.23) M7(2.53,0.23) M8(2.53,0.69) M9(2.53,1.15) M10(2.53,1.61) M11(2.53,2.07)
  round 0.229 smd: B2(-2.07,-2.07) B3(-2.07,-1.61) B4(-2.07,-1.15) B5(-2.07,-0.69) B6(-2.07,-0.23) B7(-2.07,0.23) B8(-2.07,0.69) B9(-2.07,1.15) B10(-2.07,1.61) B11(-2.07,2.07) C2(-1.61,-2.07) C3(-1.3,-1.3) C5(-1.3,-0.65) C6(-1.3,0) C7(-1.3,0.65) C9(-1.3,1.3) C11(-1.61,2.07) D2(-1.15,-2.07) D11(-1.15,2.07) E2(-0.69,-2.07) E3(-0.65,-1.3) E5(-0.65,-0.65) E6(-0.65,0) E7(-0.65,0.65) E9(-0.65,1.3) E11(-0.69,2.07) F2(-0.23,-2.07) F3(0,-1.3) F5(0,-0.65) F6(0,0) F7(0,0.65) F9(0,1.3) F11(-0.23,2.07) G2(0.23,-2.07) G3(0.65,-1.3) G5(0.65,-0.65) G6(0.65,0) G7(0.65,0.65) G9(0.65,1.3) G11(0.23,2.07) H2(0.69,-2.07) H11(0.69,2.07) J2(1.15,-2.07) J3(1.3,-1.3) J5(1.3,-0.65) J6(1.3,0) J7(1.3,0.65) J9(1.3,1.3) J11(1.15,2.07) K2(1.61,-2.07) K11(1.61,2.07) L2(2.07,-2.07) L3(2.07,-1.61) L4(2.07,-1.15) L5(2.07,-0.69) L6(2.07,-0.23) L7(2.07,0.23) L8(2.07,0.69) L9(2.07,1.15) L10(2.07,1.61) L11(2.07,2.07)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA595-NVIDIA-N13P-GV2-S-A2
  round 0.381 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A15(-10.7,0.84) A16(-10.7,1.64) A18(-10.7,3.32) A19(-10.7,4.12) A21(-10.7,5.8) A22(-10.7,6.6) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1449-INTEL-TIGERL-U
  round 0.356 smd: A3(-22.115,-10.877) A24(-22.115,-1.135) A26(-22.115,-0.485) A27(-22.115,0.165) A29(-22.115,0.815) A30(-22.115,1.465) A32(-22.115,2.115) A33(-22.115,2.765) A35(-22.115,3.415) A52(-22.115,11.405) B2(-21.565,-11.389) B24(-21.465,-1.135) B26(-21.465,-0.485) B27(-21.465,0.165) B29(-21.465,0.815) B30(-21.465,1.465) B32(-21.465,2.115) B33(-21.465,2.765) B35(-21.465,3.415) B53(-21.655,11.865) C1(-21.105,-11.865) D24(-20.815,-1.135) D26(-20.815,-0.485) D27(-20.815,0.165) D29(-20.815,0.815) D30(-20.815,1.465) D32(-20.815,2.115) D33(-20.815,2.765) D35(-20.815,3.415) DV1(21.656,-11.865) DV53(21.695,11.865) DW2(22.115,-11.381) DW52(22.115,11.365) E24(-20.165,-1.135) E26(-20.165,-0.485) E27(-20.165,0.165) E29(-20.165,0.815) E30(-20.165,1.465) E32(-20.165,2.115) E33(-20.165,2.765) E35(-20.165,3.415) G22(-19.439,-2.281) G24(-19.439,-1.366) G26(-19.439,-0.451) G28(-19.439,0.429) G30(-19.439,1.344) G32(-19.439,2.259) G34(-19.327,3.173) H22(-18.788,-2.28) H24(-18.788,-1.366) H26(-18.788,-0.451) H28(-18.788,0.429) H30(-18.788,1.344) H32(-18.788,2.259) H34(-18.677,3.173) K22(-18.138,-2.28) K24(-18.138,-1.366) K26(-18.138,-0.451) K28(-18.138,0.429) K30(-18.138,1.344) K32(-18.138,2.259) K34(-18.027,3.173) L22(-17.488,-2.28) L24(-17.488,-1.366) L26(-17.488,-0.451) L28(-17.488,0.429) L30(-17.488,1.344) L32(-17.488,2.259) L34(-17.377,3.173) N22(-16.838,-2.28) N24(-16.838,-1.366) N26(-16.838,-0.451) N28(-16.838,0.429) N30(-16.838,1.344) N32(-16.838,2.259) N34(-16.727,3.173) P22(-16.126,-2.316) P24(-16.126,-1.401) P26(-16.126,-0.451) P28(-16.126,0.429) P30(-16.126,1.344) P32(-16.126,2.259) T15(-15.493,-5.272) T17(-15.493,-4.357) T19(-15.493,-3.707) T21(-15.493,-2.791) T23(-15.493,-1.875) T25(-15.493,-0.96) T27(-15.493,-0.045) T29(-15.493,0.87) T31(-15.493,1.785) T33(-15.493,2.7) T35(-15.493,3.615) U15(-14.844,-5.272) U17(-14.844,-4.357) U19(-14.844,-3.707) U21(-14.844,-2.791) U23(-14.844,-1.875) U25(-14.844,-0.96) U27(-14.844,-0.045) U29(-14.844,0.87) U31(-14.844,1.785) U33(-14.844,2.7) U35(-14.844,3.615) V15(-14.194,-5.272) V17(-14.194,-4.357) V19(-14.194,-3.707) V21(-14.194,-2.791) V23(-14.194,-1.875) V25(-14.194,-0.96) V27(-14.194,-0.045) V29(-14.194,0.87) V31(-14.194,1.785) V33(-14.194,2.7) V35(-14.194,3.615) W16(-13.73,-4.815) W20(-13.73,-3.248) W22(-13.73,-2.333) W24(-13.73,-1.419) W26(-13.73,-0.503) W28(-13.73,0.411) W30(-13.73,1.326) W32(-13.73,2.242) W34(-13.73,3.156)
  round 0.33 smd: A4(-22.115,-10.227) A51(-22.115,10.755) B3(-21.473,-10.745) B52(-21.487,11.237) C53(-21.005,11.865) CY15(13.483,-5.499) CY17(13.483,-4.669) CY18(13.483,-3.838) CY20(13.483,-3.008) CY22(13.483,-2.179) CY24(13.483,-1.348) CY26(13.483,-0.518) CY28(13.483,0.311) CY30(13.483,1.141) CY31(13.483,1.972) CY33(13.483,2.802) CY35(13.483,3.631) D2(-20.917,-11.218) DA15(14.133,-5.499) DA17(14.133,-4.669) DA18(14.133,-3.838) DA20(14.133,-3.008) DA22(14.133,-2.179) DA24(14.133,-1.348) DA26(14.133,-0.518) DA28(14.133,0.311) DA30(14.133,1.141) DA31(14.133,1.972) DA33(14.133,2.802) DA35(14.133,3.631) DC15(14.783,-5.499) DC17(14.783,-4.669) DC18(14.783,-3.838) DC20(14.783,-3.008) DC22(14.783,-2.179) DC24(14.783,-1.348) DC26(14.783,-0.518) DC28(14.783,0.311) DC30(14.783,1.141) DC31(14.783,1.972) DC33(14.783,2.802) DC35(14.783,3.631) DD15(15.433,-5.499) DD17(15.433,-4.669) DD18(15.433,-3.838) DD20(15.433,-3.008) DD22(15.433,-2.179) DD24(15.433,-1.348) DD26(15.433,-0.518) DD28(15.433,0.311) DD30(15.433,1.141) DD31(15.433,1.972) DD33(15.433,2.802) DD35(15.433,3.631) DU1(21.005,-11.865) DU53(21.045,11.865) DV2(21.487,-11.213) DV52(21.477,11.237) DW3(22.115,-10.731) DW51(22.115,10.715) E1(-20.455,-11.865)
  round 0.305 smd: A6(-22.115,-9.577) A48(-22.115,9.455) A49(-22.115,10.105) AA39(-12.932,5.314) AA41(-12.933,6.24) AA42(-12.933,6.89) AA44(-12.933,7.54) AA45(-12.933,8.19) AA47(-12.933,8.84) AA48(-12.872,9.59) AB4(-12.692,-10.493) AB5(-12.692,-9.843) AB7(-12.692,-9.193) AB8(-12.692,-8.543) AB9(-12.692,-7.893) AB12(-12.692,-6.968) AB40(-12.475,5.776) AC10(-12.235,-7.43) AC39(-12.018,5.314) AC41(-12.018,6.24) AC42(-12.018,6.89) AC44(-12.018,7.54) AC45(-12.018,8.19) AC47(-12.018,8.84) AC49(-12.234,9.91) AC50(-12.234,10.56) AD4(-11.776,-10.493) AD5(-11.776,-9.843) AD7(-11.776,-9.193) AD8(-11.776,-8.543) AD9(-11.776,-7.893) AD12(-11.777,-6.968) AD40(-11.56,5.776) AD48(-11.599,9.59) AD51(-11.599,10.701) AE10(-11.32,-7.43) AE39(-11.103,5.314) AE41(-11.103,6.24) AE42(-11.103,6.89) AE44(-11.103,7.54) AE45(-11.103,8.19) AE47(-11.103,8.84) AF4(-10.862,-10.493) AF5(-10.862,-9.843) AF7(-10.862,-9.193) AF8(-10.862,-8.543) AF9(-10.862,-7.893) AF12(-10.863,-6.968) AF40(-10.645,5.776) AF49(-10.9,9.915) AF50(-10.9,10.565) AG10(-10.405,-7.43) AG39(-10.187,5.314) AG41(-10.188,6.24) AG42(-10.188,6.89) AG44(-10.188,7.54) AG45(-10.188,8.19) AG47(-10.188,8.84) AG48(-10.327,9.59) AG50(-10.327,10.24) AH4(-9.946,-10.493) AH5(-9.946,-9.843) AH7(-9.946,-9.193) AH8(-9.946,-8.543) AH9(-9.946,-7.893) AH12(-9.947,-6.968) AH40(-9.73,5.776) AH49(-9.685,9.915) AH50(-9.685,10.565) AJ10(-9.49,-7.43) AJ39(-9.273,5.314) AJ41(-9.273,6.24) AJ42(-9.273,6.89) AJ44(-9.273,7.54) AJ45(-9.273,8.19) AJ47(-9.273,8.84) AK4(-9.031,-10.493) AK5(-9.031,-9.843) AK7(-9.031,-9.193) AK8(-9.031,-8.543) AK9(-9.031,-7.893) AK12(-9.032,-6.968) AK40(-8.815,5.776) AK48(-9.046,9.59) AK51(-9.046,10.701) AL10(-8.575,-7.43) AL39(-8.358,5.314) AL41(-8.358,6.24) AL42(-8.358,6.89) AL44(-8.358,7.54) AL45(-8.358,8.19) AL47(-8.358,8.84) AL49(-8.347,9.915) AL50(-8.347,10.565) AM4(-8.117,-10.493) AM5(-8.117,-9.843) AM7(-8.117,-9.193) AM8(-8.117,-8.543) AM9(-8.117,-7.893) AM12(-8.118,-6.968) AM40(-7.9,5.776) AN10(-7.66,-7.43) AN39(-7.442,5.314) AN41(-7.443,6.24) AN42(-7.443,6.89) AN44(-7.443,7.54) AN45(-7.443,8.19) AN47(-7.443,8.84) AN48(-7.774,9.59) AN50(-7.774,10.24) AP4(-7.201,-10.493) AP5(-7.201,-9.843) AP7(-7.201,-9.193) AP8(-7.201,-8.543) AP9(-7.201,-7.893) AP12(-7.202,-6.968) AP40(-6.985,5.776) AP49(-7.131,9.915) AP50(-7.131,10.565) AR10(-6.745,-7.43) AR39(-6.528,5.314) AR41(-6.528,6.24) AR42(-6.528,6.89) AR44(-6.528,7.54) AR45(-6.528,8.19) AR47(-6.528,8.84) AT4(-6.287,-10.493) AT5(-6.287,-9.843) AT7(-6.287,-9.193) AT8(-6.287,-8.543) AT9(-6.287,-7.893) AT12(-6.288,-6.968) AT48(-6.492,9.59) AT51(-6.492,10.701) AU10(-5.83,-7.43) AU40(-6.07,5.776) AU49(-5.793,9.915) AU50(-5.793,10.565) AV4(-5.372,-10.493) AV5(-5.372,-9.843) AV7(-5.372,-9.193) AV8(-5.372,-8.543) AV9(-5.372,-7.893) AV12(-5.373,-6.968) AV39(-5.612,5.314) AV41(-5.613,6.24) AV42(-5.613,6.89) AV44(-5.613,7.54) AV45(-5.613,8.19) AV47(-5.613,8.84) AW10(-4.915,-7.43) AW40(-5.155,5.776) AW48(-5.155,9.59) AW51(-5.155,10.701) AY4(-4.456,-10.493) AY5(-4.456,-9.843) AY7(-4.456,-9.193) AY8(-4.456,-8.543) AY9(-4.456,-7.893) AY12(-4.457,-6.968) AY39(-4.697,5.314) AY41(-4.698,6.24) AY42(-4.698,6.89) AY44(-4.698,7.54) AY45(-4.698,8.19) AY47(-4.698,8.84) AY49(-4.455,9.915) AY50(-4.455,10.565) B5(-21.473,-10.095) B6(-21.422,-9.439) B51(-21.487,10.587) BA10(-4,-7.43) BA40(-4.24,5.776) BA48(-3.882,9.59) BA50(-3.882,10.24) BB4(-3.542,-10.493) BB5(-3.542,-9.843) BB7(-3.542,-9.193) BB8(-3.542,-8.543) BB9(-3.542,-7.893) BB12(-3.543,-6.968) BB39(-3.783,5.314) BB41(-3.783,6.24) BB42(-3.783,6.89) BB44(-3.783,7.54) BB45(-3.783,8.19) BB47(-3.783,8.84) BC10(-3.085,-7.43) BC40(-3.325,5.776) BC49(-3.239,9.915) BC50(-3.239,10.565) BD4(-2.627,-10.493) BD5(-2.627,-9.843) BD7(-2.627,-9.193) BD8(-2.627,-8.543) BD9(-2.627,-7.893) BD12(-2.627,-6.968) BD39(-2.867,5.314) BD41(-2.868,6.24) BD42(-2.868,6.89) BD44(-2.868,7.54) BD45(-2.868,8.19) BD47(-2.868,8.84) BD48(-2.601,9.59) BD51(-2.601,10.701) BE10(-2.17,-7.43) BE40(-2.41,5.776) BF4(-1.711,-10.493) BF5(-1.711,-9.843) BF7(-1.711,-9.193) BF8(-1.711,-8.543) BF9(-1.711,-7.893) BF12(-1.712,-6.968) BF39(-1.952,5.314) BF41(-1.953,6.24) BF42(-1.953,6.89) BF44(-1.953,7.54) BF45(-1.953,8.19) BF47(-1.953,8.84) BF49(-1.901,9.915) BF50(-1.901,10.565) BG10(-1.255,-7.43) BG40(-1.495,5.776) BG48(-1.328,9.59) BG50(-1.328,10.24) BH4(-0.797,-10.493) BH5(-0.797,-9.843) BH7(-0.797,-9.193) BH8(-0.797,-8.543) BH9(-0.797,-7.893) BH12(-0.798,-6.968) BH39(-1.038,5.314) BH41(-1.038,6.24) BH42(-1.038,6.89) BH44(-1.038,7.54) BH45(-1.038,8.19) BH47(-1.038,8.84) BH49(-0.685,9.915) BH50(-0.685,10.565) BJ10(-0.34,-7.43) BJ40(-0.58,5.776) BK4(0.119,-10.493) BK5(0.119,-9.843) BK7(0.119,-9.193) BK8(0.119,-8.543) BK9(0.119,-7.893) BK12(0.118,-6.968) BK39(-0.122,5.314) BK41(-0.123,6.24) BK42(-0.123,6.89) BK44(-0.123,7.54) BK45(-0.123,8.19) BK47(-0.123,8.84) BK48(-0.047,9.59) BK51(-0.047,10.701) BL10(0.575,-7.43) BL40(0.335,5.776) BL49(0.592,9.91) BL50(0.592,10.56) BM4(1.034,-10.493) BM5(1.034,-9.843) BM7(1.034,-9.193) BM8(1.034,-8.543) BM9(1.034,-7.893) BM12(1.033,-6.968) BM39(0.792,5.314) BM41(0.792,6.24) BM42(0.792,6.89) BM44(0.792,7.54) BM45(0.792,8.19) BM47(0.792,8.84) BN10(1.49,-7.43) BN40(1.25,5.776) BN48(1.23,9.59) BN50(1.23,10.24) BP4(1.681,-10.565) BP5(1.681,-9.915) BP7(1.948,-9.193) BP8(1.948,-8.543) BP9(1.948,-7.893) BP12(1.947,-6.968) BP39(1.707,5.314) BP41(1.707,6.24) BP42(1.707,6.89) BP44(1.707,7.54) BP45(1.707,8.19) BP47(1.707,8.84) BP49(1.868,9.91) BP50(1.868,10.56) BR3(2.244,-10.89) BR4(2.244,-10.24) BR10(2.405,-7.43) BR40(2.165,5.776) BT4(2.807,-10.565) BT5(2.807,-9.915) BT7(2.864,-9.193) BT8(2.864,-8.543) BT9(2.864,-7.893) BT12(2.863,-6.968) BT39(2.623,5.314) BT41(2.622,6.24) BT42(2.622,6.89) BT44(2.622,7.54) BT45(2.622,8.19) BT47(2.622,8.84) BT48(2.506,9.59) BU10(3.32,-7.43) BU40(3.08,5.776) BU49(3.144,9.91) BU50(3.144,10.56) BV3(3.481,-10.893) BV5(3.481,-9.891) BV7(3.779,-9.193) BV8(3.779,-8.543) BV9(3.779,-7.893) BV12(3.777,-6.968) BV39(3.537,5.314) BV41(3.537,6.24) BV42(3.537,6.89) BV44(3.537,7.54) BV45(3.537,8.19) BV47(3.537,8.84) BV48(3.779,9.59) BV51(3.779,10.701) BW4(4.155,-10.565) BW5(4.155,-9.915) BW10(4.235,-7.43) BW40(3.995,5.776) BY3(4.718,-10.89) BY4(4.718,-10.24) BY7(4.693,-9.193) BY8(4.693,-8.543) BY9(4.693,-7.893) BY12(4.692,-6.968) BY39(4.453,5.314) BY41(4.452,6.24) BY42(4.452,6.89) BY44(4.452,7.54) BY45(4.452,8.19) BY47(4.452,8.84) BY49(4.418,9.91) BY50(4.418,10.56) C11(-21.14,-7.358) C13(-21.143,-6.103) C16(-21.14,-4.831) C19(-21.143,-3.594) C23(-21.143,-1.734) C49(-21.297,9.962) CA10(5.15,-7.43) CA40(4.91,5.776) CA48(5.056,9.59) CA50(5.056,10.24) CB4(5.281,-10.565) CB5(5.281,-9.915) CB7(5.609,-9.193) CB8(5.609,-8.543) CB9(5.609,-7.893) CB12(5.608,-6.968) CB39(5.368,5.314) CB41(5.367,6.24) CB42(5.367,6.89) CB44(5.367,7.54) CB45(5.367,8.19) CB47(5.367,8.84) CC3(5.955,-10.893) CC5(5.955,-9.908) CC10(6.065,-7.43) CC40(5.825,5.776) CC49(5.693,9.91) CC50(5.693,10.56) CD7(6.523,-9.193) CD8(6.523,-8.543) CD9(6.523,-7.893) CD12(6.522,-6.968) CD39(6.282,5.314) CD41(6.282,6.24) CD42(6.282,6.89) CD44(6.282,7.54) CD45(6.282,8.19) CD47(6.282,8.84) CD48(6.331,9.59) CE4(6.629,-10.565) CE5(6.629,-9.915) CE40(6.74,5.776) CE49(6.97,9.91) CE50(6.97,10.56) CF3(7.192,-10.89) CF4(7.192,-10.24) CF10(6.98,-7.43) CF39(7.198,5.314) CF41(7.197,6.24) CF42(7.197,6.89) CF44(7.197,7.54) CF45(7.197,8.19) CF47(7.197,8.84) CG4(7.755,-10.565) CG5(7.755,-9.915) CG7(7.438,-9.193) CG8(7.438,-8.543) CG9(7.438,-7.893) CG12(7.437,-6.968) CG40(7.655,5.776) CG48(7.604,9.59) CG51(7.604,10.701) CH10(7.895,-7.43) CH39(8.113,5.314) CH41(8.112,6.24) CH42(8.112,6.89) CH44(8.112,7.54) CH45(8.112,8.19) CH47(8.112,8.84) CH49(8.304,9.915) CH50(8.304,10.565) CJ3(8.429,-10.893) CJ5(8.429,-9.888) CJ7(8.354,-9.193) CJ8(8.354,-8.543) CJ9(8.354,-7.893) CJ12(8.353,-6.968) CJ40(8.57,5.776) CK4(9.103,-10.565) CK5(9.103,-9.915) CK10(8.81,-7.43) CK39(9.027,5.314) CK41(9.027,6.24) CK42(9.027,6.89) CK44(9.027,7.54) CK45(9.027,8.19) CK47(9.027,8.84) CK48(8.877,9.59) CK50(8.877,10.24) CL3(9.666,-10.89) CL4(9.666,-10.24) CL7(9.268,-9.193) CL8(9.268,-8.543) CL9(9.268,-7.893) CL12(9.267,-6.968) CL40(9.485,5.776) CL49(9.52,9.915) CL50(9.52,10.565) CM10(9.725,-7.43) CM39(9.943,5.314) CM41(9.942,6.24) CM42(9.942,6.89) CM44(9.942,7.54) CM45(9.942,8.19) CM47(9.942,8.84) CN4(10.229,-10.565) CN5(10.229,-9.915) CN7(10.184,-9.193) CN8(10.184,-8.543) CN9(10.184,-7.893) CN12(10.183,-6.968) CN40(10.4,5.776) CN48(10.158,9.59) CN51(10.158,10.701) CP3(10.903,-10.893) CP5(10.903,-9.888) CP10(10.64,-7.43) CP39(10.857,5.314) CP41(10.857,6.24) CP42(10.857,6.89) CP44(10.857,7.54) CP45(10.857,8.19) CP47(10.857,8.84) CP49(10.858,9.915) CP50(10.858,10.565) CR7(11.099,-9.193) CR8(11.099,-8.543) CR9(11.099,-7.893) CR12(11.098,-6.968) CR40(11.315,5.776) CR48(11.431,9.59) CR50(11.431,10.24) CT4(11.577,-10.565) CT5(11.577,-9.915) CT10(11.555,-7.43) CT39(11.772,5.314) CT41(11.772,6.24) CT42(11.772,6.89) CT44(11.772,7.54) CT45(11.772,8.19) CT47(11.772,8.84) CU3(12.14,-10.89) CU4(12.14,-10.24) CU7(12.013,-9.193) CU8(12.013,-8.543) CU9(12.013,-7.893) CU12(12.012,-6.968) CU40(12.23,5.776) CU49(12.074,9.915) CU50(12.074,10.565) CV4(12.703,-10.565) CV5(12.703,-9.915) CV10(12.47,-7.43) CV39(12.688,5.314) CV41(12.687,6.24) CV42(12.687,6.89) CV44(12.687,7.54) CV45(12.687,8.19) CV47(12.687,8.84) CV48(12.712,9.59) CV51(12.712,10.701) CW7(12.929,-9.193) CW8(12.929,-8.543) CW9(12.929,-7.893) CW12(12.928,-6.968) CW40(13.145,5.776) CY3(13.377,-10.893) CY5(13.4,-9.963) CY39(13.602,5.314) CY41(13.602,6.24) CY42(13.602,6.89) CY44(13.602,7.54) CY45(13.602,8.19) CY47(13.602,8.84) CY49(13.473,9.915) CY50(13.473,10.565) D4(-20.83,-10.571) D5(-20.841,-9.915) D8(-20.815,-8.771) D9(-20.815,-7.931) D11(-20.49,-7.358) D12(-20.815,-6.755) D15(-20.815,-5.394) D16(-20.49,-4.831) D18(-20.815,-4.268) D20(-20.815,-3) D22(-20.767,-2.273) D36(-20.913,4.075) D38(-20.812,4.748) D39(-20.487,5.34) D40(-20.812,5.908) D42(-20.913,6.622) D43(-20.821,7.28) D45(-20.55,8.008) D46(-20.811,8.606) D49(-20.695,9.713) D50(-20.836,10.479) D52(-20.836,11.234) DA4(14.051,-10.565) DA5(14.051,-9.915) DA7(13.844,-9.193) DA8(13.844,-8.543) DA9(13.844,-7.893) DA11(13.844,-7.243) DA12(13.844,-6.593) DA50(14.046,10.24) DB3(14.614,-10.89) DB4(14.614,-10.24) DB37(14.517,4.29) DB38(14.517,4.94) DB39(14.517,5.59) DB41(14.517,6.24) DB42(14.517,6.89) DB44(14.517,7.54) DB45(14.517,8.19) DB47(14.517,8.84) DC7(14.758,-9.193) DC8(14.758,-8.543) DC9(14.758,-7.893) DC11(14.758,-7.243) DC12(14.758,-6.593) DC49(14.689,9.91) DC50(14.689,10.56) DD4(15.177,-10.565) DD5(15.177,-9.915) DD6(15.433,-9.265) DD8(15.433,-8.351) DD10(15.433,-7.436) DD13(15.433,-6.52) DD37(15.432,4.29) DD38(15.432,4.94) DD39(15.432,5.59) DD41(15.432,6.24) DD42(15.432,6.89) DD44(15.432,7.54) DD45(15.432,8.19) DD47(15.432,8.84) DD51(15.327,10.701) DE3(15.851,-10.893) DE5(15.826,-9.872) DF4(16.42,-10.562) DF6(16.083,-9.265) DF8(16.083,-8.351) DF10(16.083,-7.436) DF13(16.083,-6.52) DF15(16.083,-5.606) DF17(16.083,-4.696) DF19(16.083,-3.787) DF21(16.083,-2.879) DF23(16.083,-1.97) DF25(16.083,-1.06) DF27(16.083,-0.151) DF29(16.083,0.757) DF31(16.083,1.666) DF33(16.083,2.576) DF35(16.083,3.485) DF37(16.083,4.393) DF39(16.083,5.303) DF41(16.083,6.212) DF43(16.083,7.12) DF45(16.083,8.029) DF47(16.083,8.939) DF49(16.088,9.915) DF50(16.088,10.565) DG5(16.476,-9.908) DG6(16.733,-9.265) DG8(16.733,-8.351) DG10(16.733,-7.436) DG13(16.733,-6.52) DG15(16.733,-5.606) DG17(16.733,-4.696) DG19(16.733,-3.787) DG21(16.733,-2.879) DG23(16.733,-1.97) DG25(16.733,-1.06) DG27(16.733,-0.151) DG29(16.733,0.757) DG31(16.733,1.666) DG33(16.733,2.576) DG35(16.733,3.485) DG37(16.733,4.393) DG39(16.733,5.303) DG41(16.733,6.212) DG43(16.733,7.12) DG45(16.733,8.029) DG47(16.733,8.939) DG50(16.661,10.24) DH3(17.038,-10.886) DH4(17.038,-10.236) DH49(17.305,9.91) DH50(17.305,10.56) DJ4(17.601,-10.562) DJ5(17.601,-9.912) DJ6(17.383,-9.265) DJ8(17.383,-8.351) DJ10(17.383,-7.436) DJ13(17.383,-6.52) DJ15(17.383,-5.606) DJ17(17.383,-4.696) DJ19(17.383,-3.787) DJ21(17.383,-2.879) DJ23(17.383,-1.97) DJ25(17.383,-1.06) DJ27(17.383,-0.151) DJ29(17.383,0.757) DJ31(17.383,1.666) DJ33(17.383,2.576) DJ35(17.383,3.485) DJ37(17.383,4.393) DJ39(17.383,5.303) DJ41(17.383,6.212) DJ43(17.383,7.12) DJ45(17.383,8.029) DJ47(17.383,8.939) DK6(18.033,-9.265) DK8(18.033,-8.351) DK10(18.033,-7.436) DK13(18.033,-6.52) DK15(18.033,-5.606) DK17(18.033,-4.696) DK19(18.033,-3.787) DK21(18.033,-2.879) DK23(18.033,-1.97) DK25(18.033,-1.06) DK27(18.033,-0.151) DK29(18.033,0.757) DK31(18.033,1.666) DK33(18.033,2.576) DK35(18.033,3.485) DK37(18.033,4.393) DK39(18.033,5.303) DK41(18.033,6.212) DK43(18.033,7.12) DK45(18.033,8.029) DK47(18.033,8.939) DK51(17.942,10.701) DL3(18.274,-10.888) DL5(18.255,-9.877) DL49(18.513,9.905) DL50(18.583,10.555) DM4(18.844,-10.153) DM6(18.683,-9.265) DM8(18.683,-8.351) DM10(18.683,-7.436) DM13(18.683,-6.52) DM15(18.683,-5.606) DM17(18.683,-4.696) DM19(18.683,-3.787) DM21(18.683,-2.879) DM23(18.683,-1.97) DM25(18.683,-1.06) DM27(18.683,-0.151) DM29(18.683,0.757) DM31(18.683,1.666) DM33(18.683,2.576) DM35(18.683,3.485) DM37(18.683,4.393) DM39(18.683,5.303) DM41(18.683,6.212) DM43(18.683,7.12) DM45(18.683,8.029) DM47(18.683,8.939) DN1(19.473,-11.862) DN4(19.363,-10.562) DN5(19.457,-9.916) DN6(19.333,-9.265) DN8(19.333,-8.351) DN10(19.333,-7.436) DN13(19.333,-6.52) DN15(19.333,-5.606) DN17(19.333,-4.696) DN19(19.333,-3.787) DN21(19.333,-2.879) DN23(19.333,-1.97) DN25(19.333,-1.06) DN27(19.333,-0.151) DN29(19.333,0.757) DN31(19.333,1.666) DN33(19.333,2.576) DN35(19.333,3.485) DN37(19.333,4.393) DN39(19.333,5.303) DN41(19.333,6.212) DN43(19.333,7.12) DN45(19.333,8.029) DN47(19.333,8.939) DN49(19.244,9.77) DN51(19.157,10.875) DN53(19.152,11.536) DP4(20.019,-10.496) DP50(19.705,10.515) DP52(19.745,11.165) DP53(19.745,11.815) DR1(20.355,-11.865) DR2(20.124,-11.257) DR5(20.101,-9.826) DR7(20.12,-9.173) DR9(20.165,-8.017) DR11(20.149,-7.36) DR12(20.165,-6.703) DR15(20.165,-5.397) DR16(20.149,-4.74) DR18(20.165,-4.083) DR21(20.165,-2.777) DR22(20.149,-2.12) DR24(20.165,-1.463) DR27(20.165,-0.157) DR28(20.149,0.5) DR30(20.165,1.157) DR32(20.165,2.463) DR34(20.149,3.12) DR35(20.165,3.777) DR38(20.165,5.083) DR40(20.149,5.74) DR41(20.165,6.397) DR44(20.165,7.703) DR46(20.149,8.36) DR47(20.154,9.026) DR49(20.222,9.678) DR51(20.295,10.814) DR53(20.395,11.865) DT2(20.837,-11.213) DT4(20.837,-10.563) DT6(20.737,-9.435) DT8(20.49,-8.59) DT14(20.49,-6.05) DT19(20.49,-3.43) DT25(20.49,-0.81) DT31(20.49,1.81) DT37(20.49,4.43) DT43(20.49,7.05) DT47(20.804,9.026) DT49(20.875,9.676) DT50(20.832,10.438) DT52(20.822,11.226) DU5(21.225,-9.942) DU11(21.14,-7.36) DU16(21.14,-4.74) DU22(21.14,-2.12) DU28(21.14,0.5) DU34(21.14,3.12) DU40(21.14,5.74) DU46(21.14,8.36) DV4(21.487,-10.563) DV6(21.455,-9.315) DV47(21.454,9.026) DV49(21.473,9.936) DV51(21.474,10.586) DW5(22.115,-10.081) DW6(22.115,-9.431) DW47(22.115,9.031) DW49(22.115,10.065) E2(-20.256,-11.221) E3(-20.125,-10.58) E6(-20.119,-9.605) E7(-20.176,-8.952) E9(-20.165,-7.931) E12(-20.165,-6.755) E13(-20.15,-6.103) E15(-20.165,-5.394) E18(-20.165,-4.268) E19(-20.15,-3.594) E22(-20.109,-2.325) E38(-20.162,4.748) E41(-20.202,6.134) E44(-20.18,7.425) E47(-20.175,8.792) E48(-20.067,9.548) E51(-20.187,10.578) E52(-20.186,11.23) E53(-20.355,11.865) F1(-19.798,-11.865) F49(-19.73,10.109) F53(-19.7,11.865) G14(-19.439,-5.945) G16(-19.439,-5.029) G18(-19.439,-4.114) G20(-19.439,-3.198) G36(-19.327,4.056) G38(-19.327,4.939) G39(-19.338,5.59) G41(-19.338,6.24) G42(-19.338,6.89) G44(-19.338,7.54) G45(-19.338,8.19) G47(-19.338,8.84) G48(-19.251,9.59) G51(-19.251,10.701) H4(-19.106,-10.493) H5(-19.096,-9.843) H7(-19.096,-9.193) H8(-19.096,-8.543) H9(-19.096,-7.893) H11(-19.096,-7.243) H12(-19.096,-6.593) H14(-18.788,-5.941) H16(-18.788,-5.025) H18(-18.788,-4.109) H20(-18.788,-3.194) H36(-18.677,4.056) H38(-18.677,4.939) J39(-18.423,5.59) J41(-18.423,6.24) J42(-18.423,6.89) J44(-18.423,7.54) J45(-18.423,8.19) J47(-18.423,8.84) J49(-18.612,9.91) J50(-18.612,10.56) K4(-18.191,-10.493) K5(-18.182,-9.843) K7(-18.182,-9.193) K8(-18.182,-8.543) K9(-18.182,-7.893) K11(-18.182,-7.243) K12(-18.182,-6.593) K14(-18.138,-5.941) K16(-18.138,-5.025) K18(-18.138,-4.109) K20(-18.138,-3.194) K36(-18.027,4.056) K38(-18.027,4.939) K48(-17.945,9.59) K50(-17.915,10.24) L14(-17.488,-5.941) L16(-17.488,-5.025) L18(-17.488,-4.109) L20(-17.488,-3.194) L36(-17.377,4.056) L38(-17.377,4.939) L39(-17.508,5.59) L41(-17.508,6.24) L42(-17.508,6.89) L44(-17.508,7.54) L45(-17.508,8.19) L47(-17.508,8.84) L49(-17.336,9.91) M4(-17.266,-10.493) M5(-17.266,-9.843) M7(-17.266,-9.193) M8(-17.266,-8.543) M9(-17.266,-7.893) M11(-17.266,-7.243) M12(-17.266,-6.593) M50(-17.321,10.56) N14(-16.838,-5.941) N16(-16.838,-5.025) N18(-16.838,-4.109) N20(-16.838,-3.194) N36(-16.727,4.056) N38(-16.727,4.939) N39(-16.593,5.59) N41(-16.593,6.24) N42(-16.593,6.89) N44(-16.593,7.54) N45(-16.593,8.19) N47(-16.593,8.84) N48(-16.67,9.59) P4(-16.352,-10.493) P5(-16.352,-9.843) P7(-16.352,-9.193) P8(-16.352,-8.543) P9(-16.352,-7.893) P11(-16.352,-7.243) P12(-16.352,-6.593) P14(-16.126,-5.941) P16(-16.126,-5.061) P18(-16.126,-4.146) P20(-16.126,-3.231) P33(-16.126,2.911) P35(-16.144,3.615) P49(-16.06,9.91) P50(-16.06,10.56) R37(-15.678,4.29) R38(-15.678,4.94) R39(-15.678,5.59) R41(-15.678,6.24) R42(-15.678,6.89) R44(-15.678,7.54) R45(-15.678,8.19) R47(-15.678,8.84) T4(-15.437,-10.493) T5(-15.437,-9.843) T7(-15.437,-9.193) T8(-15.437,-8.543) T9(-15.437,-7.893) T11(-15.437,-7.243) T12(-15.437,-6.593) T48(-15.425,9.59) T51(-15.425,10.701) U37(-14.763,4.29) U38(-14.763,4.94) U39(-14.763,5.59) U41(-14.763,6.24) U42(-14.763,6.89) U44(-14.763,7.54) U45(-14.763,8.19) U47(-14.763,8.84) U49(-14.786,9.91) U50(-14.786,10.56) V4(-14.521,-10.493) V5(-14.521,-9.843) V7(-14.521,-9.193) V8(-14.521,-8.543) V9(-14.521,-7.893) V11(-14.521,-7.243) V12(-14.521,-6.593) W37(-13.848,4.29) W38(-13.848,4.94) W39(-13.848,5.59) W41(-13.848,6.24) W42(-13.848,6.89) W44(-13.848,7.54) W45(-13.848,8.19) W47(-13.848,8.84) W48(-14.148,9.59) W50(-14.148,10.24) Y4(-13.607,-10.493) Y5(-13.607,-9.843) Y7(-13.607,-9.193) Y8(-13.607,-8.543) Y9(-13.607,-7.893) Y11(-13.607,-7.243) Y12(-13.607,-6.593) Y49(-13.51,9.91) Y50(-13.51,10.56)
  oval 0.356x0.254 smd: A7(-22.115,-8.796) A9(-22.115,-7.931) A12(-22.115,-6.735) A15(-22.115,-5.394) A40(-22.115,5.979) A43(-22.115,7.413) A45(-21.85,8.008) A46(-22.115,8.701) B8(-21.465,-8.771) B9(-21.465,-7.931) B12(-21.465,-6.735) B13(-21.793,-6.103) B15(-21.465,-5.394) B40(-21.462,5.979) B42(-21.563,6.622) B43(-21.467,7.36) B46(-21.461,8.681) B48(-21.474,9.333) C45(-21.2,8.008) DT9(20.815,-8.017) DT12(20.815,-6.703) DT15(20.815,-5.397) DT18(20.815,-4.083) DT21(20.815,-2.777) DT24(20.815,-1.463) DT27(20.815,-0.157) DT30(20.815,1.157) DT32(20.815,2.463) DT35(20.815,3.777) DT38(20.815,5.083) DT41(20.815,6.397) DT44(20.815,7.703) DU8(21.14,-8.67) DU14(21.14,-6.05) DU43(21.14,7.05) DV8(21.8,-8.761) DV9(21.465,-8.017) DV11(21.79,-7.36) DV12(21.465,-6.703) DV14(21.79,-6.05) DV15(21.465,-5.397) DV38(21.465,5.083) DV40(21.79,5.74) DV41(21.465,6.397) DV43(21.79,7.05) DV44(21.465,7.703) DV46(21.79,8.36) DW9(22.115,-8.017) DW12(22.115,-6.703) DW15(22.115,-5.397) DW38(22.115,5.083) DW41(22.115,6.397) DW44(22.115,7.703)
  oval 0.305x0.203 smd: A18(-22.115,-4.268) A20(-22.115,-3) A38(-22.112,4.748) B18(-21.465,-4.268) B19(-21.793,-3.594) B20(-21.465,-3) B22(-21.47,-2.298) B23(-21.793,-1.734) B36(-21.563,4.06) B38(-21.462,4.748) B39(-21.787,5.32) C39(-21.137,5.34) DU19(21.14,-3.43) DU25(21.14,-0.81) DU31(21.14,1.81) DU37(21.14,4.43) DV16(21.79,-4.74) DV18(21.465,-4.083) DV19(21.79,-3.43) DV21(21.465,-2.777) DV22(21.79,-2.12) DV24(21.465,-1.463) DV25(21.79,-0.81) DV27(21.465,-0.157) DV28(21.79,0.5) DV30(21.465,1.157) DV31(21.79,1.81) DV32(21.465,2.463) DV34(21.79,3.12) DV35(21.465,3.777) DV37(21.79,4.43) DW18(22.115,-4.083) DW21(22.115,-2.777) DW24(22.115,-1.463) DW27(22.115,-0.157) DW30(22.115,1.157) DW32(22.115,2.463) DW35(22.115,3.777)
  oval 0.203x0.305 smd: AA51(-12.872,10.89) AA53(-12.872,11.54) AB1(-12.812,-11.865) AB2(-12.812,-11.215) AC1(-12.162,-11.865) AC2(-12.162,-11.215) AC52(-12.234,11.21) AC53(-12.234,11.86) AD1(-11.512,-11.865) AD2(-11.512,-11.215) AD52(-11.599,11.351) AF1(-10.862,-11.865) AF2(-10.862,-11.215) AF52(-10.9,11.215) AF53(-10.9,11.865) AG1(-10.212,-11.865) AG2(-10.212,-11.215) AG51(-10.327,10.89) AG53(-10.327,11.54) AH52(-9.685,11.215) AH53(-9.685,11.865) AJ1(-9.562,-11.865) AJ2(-9.562,-11.215) AK1(-8.912,-11.865) AK2(-8.912,-11.215) AK52(-9.046,11.351) AL52(-8.347,11.215) AL53(-8.347,11.865) AM1(-8.262,-11.865) AM2(-8.262,-11.215) AN1(-7.612,-11.865) AN2(-7.612,-11.215) AN51(-7.774,10.89) AN53(-7.774,11.54) AP52(-7.131,11.215) AP53(-7.131,11.865) AR1(-6.961,-11.865) AR2(-6.961,-11.215) AT1(-6.311,-11.865) AT2(-6.311,-11.215) AT52(-6.492,11.351) AU1(-5.661,-11.865) AU2(-5.661,-11.215) AU52(-5.793,11.215) AU53(-5.793,11.865) AW1(-5.011,-11.865) AW2(-5.011,-11.215) AW52(-5.155,11.351) AY1(-4.361,-11.865) AY2(-4.361,-11.215) AY52(-4.455,11.215) AY53(-4.455,11.865) BA51(-3.882,10.89) BA53(-3.882,11.54) BB1(-3.711,-11.865) BB2(-3.711,-11.215) BC1(-3.061,-11.865) BC2(-3.061,-11.215) BC52(-3.239,11.215) BC53(-3.239,11.865) BD52(-2.601,11.351) BE1(-2.411,-11.865) BE2(-2.411,-11.215) BF1(-1.761,-11.865) BF2(-1.761,-11.215) BF52(-1.901,11.215) BF53(-1.901,11.865) BG51(-1.328,10.89) BG53(-1.328,11.54) BH1(-1.112,-11.865) BH2(-1.112,-11.215) BH52(-0.685,11.215) BH53(-0.685,11.865) BJ1(-0.462,-11.865) BJ2(-0.462,-11.215) BK1(0.188,-11.865) BK2(0.188,-11.215) BK52(-0.047,11.351) BL52(0.592,11.21) BL53(0.592,11.86) BM1(0.761,-11.543) BN51(1.23,10.89) BN53(1.23,11.54) BP1(1.681,-11.865) BP2(1.681,-11.215) BP52(1.868,11.21) BP53(1.868,11.86) BT1(2.807,-11.865) BT2(2.807,-11.215) BT51(2.506,10.89) BT53(2.506,11.54) BU52(3.144,11.21) BU53(3.144,11.86) BV1(3.481,-11.543) BV52(3.779,11.351) BW1(4.155,-11.865) BW2(4.155,-11.215) BY52(4.418,11.21) BY53(4.418,11.86) CA51(5.056,10.89) CA53(5.056,11.54) CB1(5.281,-11.865) CB2(5.281,-11.215) CC1(5.955,-11.543) CC52(5.693,11.21) CC53(5.693,11.86) CD51(6.331,10.89) CD53(6.331,11.54) CE1(6.629,-11.865) CE2(6.629,-11.215) CE52(6.97,11.21) CE53(6.97,11.86) CG1(7.755,-11.865) CG2(7.755,-11.215) CG52(7.604,11.351) CH52(8.304,11.215) CH53(8.304,11.865) CJ1(8.429,-11.543) CK1(9.103,-11.865) CK2(9.103,-11.215) CK51(8.877,10.89) CK53(8.877,11.54) CL52(9.52,11.215) CL53(9.52,11.865) CN1(10.229,-11.865) CN2(10.229,-11.215) CN52(10.158,11.351) CP1(10.903,-11.543) CP52(10.858,11.215) CP53(10.858,11.865) CR51(11.431,10.89) CR53(11.431,11.54) CT1(11.577,-11.865) CT2(11.577,-11.215) CU52(12.074,11.215) CU53(12.074,11.865) CV1(12.703,-11.865) CV2(12.703,-11.215) CV52(12.712,11.351) CY1(13.377,-11.543) CY52(13.473,11.215) CY53(13.473,11.865) DA1(14.051,-11.865) DA2(14.051,-11.215) DA51(14.046,10.89) DA53(14.126,11.54) DC52(14.689,11.21) DC53(14.779,11.865) DD52(15.327,11.351) DF52(16.088,11.215) DG51(16.661,10.89) N1(-16.548,-11.864) N2(-16.548,-11.214) R1(-15.898,-11.864) R2(-15.898,-11.214) T1(-15.248,-11.864) T2(-15.248,-11.214) V1(-14.597,-11.864) V2(-14.597,-11.214) W1(-14.028,-11.545) W51(-14.148,10.89) W53(-14.148,11.54) Y1(-13.461,-11.865) Y2(-13.461,-11.215) Y52(-13.51,11.21) Y53(-13.51,11.86)
  oval 0.254x0.356 smd: DD1(15.177,-11.865) DD2(15.177,-11.215) DE1(15.851,-11.543) DF1(16.42,-11.862) DF2(16.42,-11.212) DF53(16.088,11.865) DG53(16.741,11.54) DH52(17.305,11.21) DJ1(17.601,-11.862) DJ2(17.601,-11.212) DJ53(17.394,11.865) DK52(17.942,11.351) DL1(18.247,-11.543) DL52(18.583,11.205) DL53(18.583,11.855) DM1(18.903,-11.534) DN2(19.473,-11.212) G1(-19.148,-11.864) G2(-19.148,-11.214) G52(-19.249,11.363) J1(-18.498,-11.864) J2(-18.498,-11.214) J52(-18.607,11.21) J53(-18.607,11.86) K1(-17.848,-11.864) K2(-17.848,-11.214) K51(-17.915,10.89) K53(-17.915,11.54) M1(-17.198,-11.864) M2(-17.198,-11.214) M52(-17.321,11.21) M53(-17.321,11.86) N51(-16.628,10.89) N53(-16.628,11.54) P52(-16.06,11.21) P53(-16.06,11.86) T52(-15.425,11.351) U52(-14.786,11.21) U53(-14.786,11.86)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C1808
  rect 1.041x2.311 smd: 1(-2.175,0) 2(2.175,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CLIP-39X35-100X18-3P
  rect 2.54x0.457 smd: 1(-1.975,0) 3(1.975,0)
  rect 0.991x0.889 smd: 2(0,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
D-SOD523-1_2X0_8
  rect 0.406x0.406 smd: 1(-0.7,0) 2(0.7,0)
D-SOD523-1_2X0_8-1N4148WT-7
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
DCJK-30738-11202-001-3P
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.092x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AR0-26001-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
