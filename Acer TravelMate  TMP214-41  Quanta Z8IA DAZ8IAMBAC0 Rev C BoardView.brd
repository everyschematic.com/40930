# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLANPWR#: length 42.2
  TOP w0.114: R68764.2 173.05,111.14 173,111.09 173,110.65 v1(172.89,110.54)
  IN1 w0.089: v1(199.59,108.48) 199.26,108.81 194.53,108.81 193.82,108.1 183.31,108.1 181.02,110.39 174.9,110.39 174.65,110.13 173.3,110.13 173.17,110.26 173.12,110.26 172.89,110.49 v1(172.89,110.54)
  IN2 w0.102: v1(199.59,108.48) 199.59,108.63 201.85,110.89 202.36,110.89 203.37,111.91 203.37,113.31 202.92,113.76 202.92,116.58 v1(202.48,117.01)
  BOTTOM w0.114: v1(202.48,117.01) 202.53,117.06 R68758.1 203.32,117.06 203.74,117.48 Q6601.1
WRST#: length 13.5
  TOP w0.114: U37.14 152.81,104.34 153.23,103.91 v2(153.23,103.89) ; C6571.1 146.73,103.78 146.58,103.93 D63.2 146.1,103.14 146.2,103.04 v2(146.2,102.74) 146.2,102.68 v1(145.77,102.26) 145.56,102.04 R25300.1
  IN3 w0.102: v1(145.77,102.26) 146.15,102.64 148.81,102.64 150.18,104.01 153.09,104.01 153.21,103.89 v2(153.23,103.89)
WRST#_8350: length 8
  TOP w0.114: U6516.A2 153.22,213.64 v2(152.83,213.26)
  BOTTOM w0.114: v2(152.83,213.26) 153,213.26 153.39,213.64 153.84,213.64 154.22,214.02 v2(154.22,214.27) 154.48,214.27 154.58,214.17 R25633.2 C20142.1 156,213.76 155.87,213.64 154.6,213.64 154.34,213.37 D13093.2
WRST_IT8013: length 38.8
  TOP w0.114: v1(144.55,102.26) 144.55,102.11 v2(144.06,101.62) 144.44,101.25 145.84,101.25 147.09,102.49 R69014.1
  BOTTOM w0.114: 139.27,120.29 138.6,119.63 138.6,117.5 137.97,116.86 136.19,116.86 135.38,116.05 135.38,115.67 134.72,115.01 134.72,111.55 135.5,110.77 136.32,110.77 137,110.08 137,108.33 137.61,107.72 137.61,106.42 137.76,106.27 140.81,106.27 144.55,102.53 v1(144.55,102.26) ; 139.27,120.29 C96881.1 139.27,121.28 138.6,121.95 U6556.4 ; 139.27,120.29 140.29,120.29 140.41,120.42 140.41,120.79 R68799.1 140.41,121.21 140.51,121.31 141.43,121.31 141.68,121.55 D13148.2
XD_CD#: length 1.9
  BOTTOM w0.114: TP99.1 33,63.33 32.16,62.49 U40.7
XD_D7: length 4.8
  BOTTOM w0.114: U40.23 26.96,61.99 26.58,62.37 26.58,63.41 26.36,63.62 25.9,63.62 25.73,63.45 24.58,63.45 TP96.1
XDP_TCK: length 8.4
  BOTTOM w0.102: U6539.B6 121.33,165.01 121.33,168.12 120.9,168.55 120.9,169.64 121.08,169.82 121.2,169.82 121.3,169.92 R68265.2 121.3,170.91 TP13246.1
  BOTTOM w0.114: TP13246.1 121.58,172.01 R68274.1
XDP_TDI_CPU: length 6.8
  BOTTOM w0.102: U6539.A12 118.78,166.17 118,166.95 118,169.24 TP13245.1 118.16,169.8 117.98,169.97 117.98,171.52 117.93,171.57 R68269.2
XDP_TDO_CPU: length 7.3
  BOTTOM w0.102: U6539.D12 118.8,164.39 118.48,164.72 118.48,166.17 117.65,167 117.65,168.17 117.77,168.3 117.77,168.93 117.44,169.27 R68268.2 117.44,170.71 TP13244.1
XDP_TMS_CPU: length 5.9
  BOTTOM w0.102: R68267.2 119.76,169.33 TP13243.1 119.83,169.21 119.83,168.14 120.27,167.7 120.27,166.6 119.69,166.02 119.69,165.17 U6539.B9
XDP_TRST#: length 2.7
  TOP w0.114: R68271.2 124.48,162.23 124.38,162.33 TP13242.1 123.63,162.33 123.5,162.2 122.92,162.2 v1(122.78,162.06)
  BOTTOM w0.102: v1(122.78,162.06) 122.54,161.83 U6539.K4
XIN: length 5.3
  TOP w0.114: U6544.10 84.66,112.17 84.7,112.21 85.45,112.21 85.61,112.06 85.61,111.9 85.49,111.78 85.14,111.78 85.01,111.66 85.01,111.4 85.11,111.3 C96778.1 85.67,111.3 85.77,111.4 86.28,111.4 86.72,110.96 Y7.1
XOUT: length 6.1
  TOP w0.114: U6544.11 84.75,112.67 84.78,112.65 C96777.1 85.62,112.65 86.36,111.91 88.44,111.91 89.29,112.76 Y7.3
XTAL1: length 7.3
  TOP w0.114: R511.1 28.35,169.06 v2(28.01,168.71) 27.38,169.34 25.42,169.34 25.09,169.01 25.09,168.02 24.08,167.01 U6521.9
XTAL2: length 7.1
  TOP w0.114: U6521.10 24.15,167.41 24.86,168.13 24.86,169.11 25.34,169.59 27.63,169.59 v2(28.11,170.08) R512.1
XTAL_38P4M_IN: length 4.7
  BOTTOM w0.102: 124.88,124.39 124.38,124.39 U6539.DL1
  BOTTOM w0.114: 124.88,124.39 124.98,124.39 125.52,123.85 126.41,123.85 126.63,123.62 R68446.1 127.33,123.62 127.36,123.65 R68444.2
XTAL_38P4M_IN_R: length 3.5
  BOTTOM w0.114: Y6.1 130.99,123.59 130.84,123.44 129.48,123.44 129.3,123.62 C96711.2 128.41,123.62 128.38,123.65 R68444.1
XTAL_38P4M_OUT: length 4.8
  BOTTOM w0.102: 124.85,124.13 124.81,124.18 124.18,124.18 123.84,124.52 U6539.DM1
  BOTTOM w0.114: R68447.2 127.68,122.96 127.46,123.17 R68446.2 126.7,123.17 126.28,123.59 125.39,123.59 124.85,124.13
XTAL_38P4M_OUT_R: length 2.6
  BOTTOM w0.114: R68447.1 128.13,123.16 128.25,123.29 128.7,123.29 128.82,123.16 C96713.2 129.02,122.93 129.24,123.15 129.45,123.15 Y6.3
XTAL_SSIN: length 5.3
  BOTTOM w0.102: U8.A10 127.7,182.35 127.37,182.02 127.37,181.08 126.38,180.08 125.75,180.08 125.04,179.38
  BOTTOM w0.114: R331.1 124.89,178.97 125.04,179.12 125.04,179.38
XTAL_TCP0_25MHZ_IN: length 5.7
  TOP w0.079: C96814.2 19.89,67.87 19.73,67.71 19.73,66.19 U6549.L9
  TOP w0.114: C96814.2 19.89,70.15 20.75,71.02 Y8.1
XTAL_TCP0_25MHZ_OUT: length 4.4
  TOP w0.079: C96815.2 19.22,67.84 19.35,67.71 19.48,67.71 19.54,67.65 19.54,67.38 19.41,67.26 19.35,67.26 19.22,67.13 19.22,66.98 19.49,66.71 U6549.M9
  TOP w0.114: C96815.2 19.44,68.09 19.55,68.2 19.55,68.38 19.42,68.51 18.77,68.51 18.64,68.63 Y8.3
N10350616: length 6.7
  TOP w0.178: v2(163.11,147.85) 162.61,147.85 162.13,148.33 PR7007.2 ; PC7001.2 162.3,149.83 162.13,149.66 PR7007.2 ; PR7001.2 161.73,149.15 PR7007.2
  TOP w0.203: PR7005.1 163.11,148.74 v2(163.11,147.85) 163.62,147.85 163.77,148 PR7006.1 164.12,148.68 PR7004.1
N10356361: length 12
  TOP w0.203: v1(156.46,142.8) 156.59,142.8 PR7023.2
  IN2 w0.178: v1(156.46,142.8) 156.26,142.6 156.26,140.48 155.54,139.77 155.44,139.77 v2(155.39,139.72)
  BOTTOM w0.178: v1(156.46,142.8) 156.84,143.18 PR7025.2 ; PR7022.2 149.36,138.9 149.59,139.14 149.86,139.14 150.03,138.96 151.43,138.96 v2(151.81,138.58) 152.19,138.96 154.22,138.96 154.99,139.72 v2(155.39,139.72)
N15767591: length 1.6
  TOP w0.203: R25614.2 55.85,120.98 56.48,120.98 56.53,121.03 v2(56.59,121.03) 57.38,121.03 C20130.2
N16244674: length 2.5
  TOP w0.203: U67.28 30.58,149.45 v2(30.45,149.32) 30.45,148.56 30.68,148.33 R1616.2
N16251939: length 4.1
  TOP w0.114: U6521.46 21.89,160 v2(21.59,159.7) 21.59,158.93 R67598.1
N16251941: length 2.3
  TOP w0.114: U6521.47 22.29,161.8 22.4,161.69 v2(22.4,161.57) R67599.1
N16390345: length 2
  TOP w0.114: R244.2 45.29,118.21 44.75,117.67 v2(44.75,117.52)
  TOP w0.203: R244.2 45.29,118.67 45.38,118.77 C266.2
N16826936: length 3.9
  BOTTOM w0.114: U11.2 v2(126.92,210.72) 126.25,210.72 R324.2 R323.2
N17011327: length 1.8
  BOTTOM w0.203: U20.39 18.71,36.11 18.56,36.26 18.56,36.99 C572.2
N17011330: length 2.4
  BOTTOM w0.114: C566.2 17.04,36.62 17.38,36.28 17.38,35.68 17.55,35.51 U20.37
N17011339: length 1.8
  BOTTOM w0.114: U20.34 16.3,33.81 16.11,33.99 C567.1
N17011340: length 3.3
  BOTTOM w0.203: U20.19 19.91,28.44 19.89,28.42 19.89,28.35
  BOTTOM w0.254: C573.1 19.53,27.04 19.53,27.99 19.89,28.35
N17011365: length 3.3
  BOTTOM w0.114: R454.2 v2(23.93,36.09) 23.75,35.91 22.96,35.91 22.78,36.09 22.44,36.09 22.31,35.96 U20.48
N17011429: length 1.8
  BOTTOM w0.102: R69059.1 24.43,31.39 24.01,31.81 U20.8
N17011431: length 5.5
  BOTTOM w0.114: C578.1 27.95,31.37 v4(27.25,31.37) 26.59,31.37 26.14,31.82 24.51,31.82 24.12,32.21 U20.7
N17011437: length 3.7
  BOTTOM w0.114: R738.2 26.43,30.32 26.1,29.99 24.43,29.99 23.82,30.61 U20.11
N17011447: length 2.2
  BOTTOM w0.114: C846.1 v2(24.28,29.36) 24.28,29.51 23.58,30.21 U20.12
N17011480: length 4.3
  BOTTOM w0.114: C566.1 15.17,36.09 15.3,35.96 16.17,35.96 16.58,35.56 16.58,35.17 16.28,34.87 16.28,34.37 16.45,34.21 U20.35
N17061276: length 2.3
  BOTTOM w0.114: PR13.1 109.7,104.46 109.7,103.86 110.12,103.44 PJ1.3
N17061293: length 3.6
  TOP w0.114: PR1.2 77.13,201.03 77.13,203.48 77.01,203.6 PR3.1
  vias: v2(75.97,201.11)
N17061294: length 2.1
  BOTTOM w0.152: PU1.20 157.99,116.9 157.73,116.64 157.73,115.61 PR5.1
N17061299: length 2.2
  BOTTOM w0.152: PU1.19 158.39,116.89 157.98,116.48 157.98,115.69 PR6.1
N17061317: length 1.9
  BOTTOM w0.114: PJ1.5 106.12,103.78 106.35,104.02 PR14.1
N17061319: length 3.2
  TOP w0.114: PR209.1 139.67,114.2 139.54,114.06 139.54,112.34 139.67,112.21 139.67,112.01 139.8,111.88 PR210.1
  vias: v1(142.16,119.91) v1(142.16,119.28) v1(142.79,119.91) v1(142.79,119.28) v1(143.43,119.91) v1(143.43,119.28) v1(144.06,119.91) v1(144.06,119.28) v1(144.7,119.91) v1(144.7,119.28) v2(143.68,113.69)
N17061327: length 160.3
  TOP w0.114: v2(75.36,199.16) 75.36,198.78 75,198.42 PC2.2 74.53,199.1 74.62,199.18 PQ9054.4 ; PQ1.4 69.45,199.22 69.41,199.26 PC1.2 69.25,199.96 v2(68.75,199.46)
  IN3 w0.102: v2(162.1,124.34) 162.1,124.23 160.7,122.83 157.4,122.83 156.76,123.47 156.76,132.23 155.43,133.56 154.67,133.56 150.84,137.39 144.87,137.39 143.51,138.75 143.51,145.61 142.41,146.71 142.41,150.9 141.9,151.41 141.9,155.22 142.36,155.67 142.36,165.3 137.4,170.27 133.46,170.27 129.84,173.89 129.84,174.65 128.95,175.54 128.95,178.2 128.72,178.43 124.35,178.43 123.87,177.95 120.04,177.95 117.27,180.71 117.27,183.33 114.98,185.62 114.98,186.08 113.71,187.35 111.81,187.35 110.92,188.24 108.45,188.24 107.11,189.58 101.95,189.58 101.39,190.14 96.06,190.14 94.53,191.67 93.09,191.67 91.49,193.26 91.49,197.12 89.2,199.41 80.06,199.41 78.66,198.02 76.5,198.02 v2(75.36,199.16) 69.06,199.16 v2(68.75,199.46)
  BOTTOM w0.114: v2(162.1,124.34) 162.27,124.17 PR29.1
N17061416: length 3.4
  BOTTOM w0.508: PC19.1 152.68,113.93 v2(152.45,113.69) 151.01,113.69 PR33.2
N17061438: length 2.8
  TOP w0.114: v2(153.64,118.41) 153.34,118.71 PR11.2
  TOP w0.508: PR11.2 153.34,120.19 153.19,120.34 PC15.2
N17061451: length 2.8
  BOTTOM w0.114: PJ1.4 108.12,103.6 108.43,103.91 109.06,103.91 109.19,104.04 PR12.1
N17061494: length 4.2
  TOP w0.508: PQ2.4 149.69,120.33 v2(150.52,119.5) 150.52,119.12 150.24,118.84 PR4.1 148.93,118.22 PC17.2
N17072870:
  vias: v2(164.71,162.05) v3(164.73,165.82) v3(164.73,165.06) v3(164.73,164.3) v3(164.73,163.53) v3(164.73,162.77) v3(165.5,165.82) v3(165.5,165.06) v3(165.5,164.3) v3(165.5,163.53) v3(165.5,162.77) v3(165.5,162.01)
N17073105: length 19.2
  TOP w0.203: v1(167.71,166.09) 167.78,166.16 PR9263.2
  IN1 w0.203: v2(171.5,152.8) 170.73,153.57 170.73,154.33 169.84,155.22 169.84,155.61 168.75,156.7 168.75,159.47 167.41,160.8 167.41,165.79 v1(167.71,166.09)
  BOTTOM w0.203: PC9089.2 PR9094.1 171,150.91 v2(171.88,151.79) 171.88,152.42 v2(171.5,152.8)
N17184837: length 4.9
  BOTTOM w0.114: R735.1 25.93,24.69 25.7,24.91 25.7,25.17 25.49,25.37 D11.1 24.2,25.37 v2(23.58,24.75) 23.07,24.24 D6543.1
N17326408: length 173.5
  TOP w0.114: v2(157.32,122.36) 157.77,122.81 v2(158.29,122.81) 159.53,122.81 159.76,123.03 PR9276.2 ; PR235.2 57.2,202.8 57.2,203.59 PR230.1 56.56,203.42 v2(56.56,203.22)
  TOP w0.254: PQ17.2 160.56,122.31 160.35,122.52 PR9276.2
  IN3 w0.102: v2(56.56,203.22) 56.56,201.7 55.99,201.13 55.99,198.58 57.58,197 61.13,197 62.28,198.14 71.67,198.14 72.44,197.38 78.53,197.38 79.93,198.78 89.33,198.78 91.26,196.84 91.26,193.17 93.08,191.35 94.16,191.35 95.75,189.76 101.09,189.76 101.49,189.35 107.01,189.35 109.25,187.12 113.56,187.12 114.73,185.95 114.73,185.49 117.04,183.18 117.04,180.59 119.93,177.7 124,177.7 124.51,178.2 128.57,178.2 128.7,178.08 128.7,174.39 133.14,169.95 137.33,169.95 142.13,165.15 142.13,155.83 141.65,155.34 141.65,151.09 142.16,150.58 142.16,146.58 143.24,145.5 143.24,138.64 144.76,137.12 150.73,137.12 154.6,133.25 155.37,133.25 156.51,132.1 156.51,123.17 v2(157.32,122.36)
N17412621: length 5.3
  TOP w0.152: PR30.1 161.03,121.52 161.21,121.7 161.21,122.12 v2(161.39,122.3)
  BOTTOM w0.152: v2(161.39,122.3) 161.37,122.29 159.67,122.29 159.19,121.81 PU1.5
N17419587: length 17.3
  TOP w0.254: PR8002.2 PR8008.1 56.04,196.99 56.04,198.92 55.75,199.21 PQ8003.3 55.31,200.06 v2(54.98,199.73) ; v2(62.03,197.2) 62.39,197.56 v2(62.61,197.56) 62.61,197.84 62.49,197.95 PC8003.2 62.4,198.72 PQ8001.4
  IN3 w0.254: v2(54.98,199.73) 54.98,198.83 57.2,196.62 61.45,196.62 v2(62.03,197.2)
N17419880: length 9.8
  TOP w0.254: PQ8004.3 32.2,100.34 32.2,101.34 31.92,101.62 31.92,102.77 v2(31.41,103.27) 31.16,103.53 v2(31.16,104.16)
  IN2 w0.508: v2(31.16,104.16) 31.18,104.18 v2(34.5,104.18)
N17421868: length 2.3
  TOP w0.114: v2(35.86,119.66) 36.65,119.66 PR8022.1 37.14,119.17 PQ8012.3
N17421870: length 2.4
  TOP w0.114: PQ8006.4 38.4,115.03 38.47,115.11 PR8000.2 38.44,115.6 PQ8012.6
N17421874: length 2.9
  TOP w0.114: PR8031.1 37.79,119.56 PQ8012.2 PQ8012.5
N17421890: length 124.3
  TOP w0.114: PQ8009.2 33.79,118.22 34.72,119.15 v2(34.72,119.53) ; v1(80.21,191.74) 80.21,191.72 80.53,191.4 PQ8010.2 80.53,190.59 80.31,190.37 80.31,189.89 80.46,189.74 PD8001.2 81.14,189.18 81.59,188.74 81.59,188.14 81.42,187.98 PR8023.2
  IN1 w0.089: v2(43.84,118.77) 43.2,119.4 34.84,119.4 v2(34.72,119.53)
  IN3 w0.102: v2(43.84,118.77) 43.23,118.77 42.84,119.15 42.84,157.25 43.73,158.14 43.73,159.15 43.1,159.79 43.1,171.21 46.66,174.77 55.41,174.77 57.72,177.09 58.77,177.09 61.77,180.08 61.77,185.65 62.26,186.14 62.47,186.14 62.86,186.53 62.86,187.14 62.53,187.47 62.53,187.73 62.17,188.08 62.17,189.53 62.53,189.89 63.16,189.89 63.32,190.04 63.95,190.04 64.69,190.78 64.82,190.78 65.7,191.67 65.7,192.3 66.34,192.94 69.39,192.94 70.78,191.54 72.94,191.54 73.32,191.16 79.62,191.16 v1(80.21,191.74)
N17421892: length 1.8
  TOP w0.114: PR8024.1 88.75,190.49 88.09,190.49 v2(87.93,190.65) 87.71,190.43 PQ8013.3
N17421946: length 4
  TOP w0.114: PQ8013.5 PQ8013.2 88.62,189.23 v2(88.9,189.51) 89.41,190.02 PR8032.1
N17421950: length 24.1
  TOP w0.114: PQ8013.6 85.53,188.58 85.38,188.73 85.38,189.19 v2(85.19,189.38) 85.06,189.51 84.3,189.51 PR8030.2 83.43,189.7 81.51,189.7 81.28,189.94 81.28,190.9 81.22,190.95 v1(81.22,191) ; PQ8007.4 68.54,200.09 v2(68.68,200.23)
  IN2 w0.102: v1(81.22,191) 81.17,191.06 81.17,191.11 80.94,191.33 79.49,191.33 74.13,196.69 72.41,196.69 68.87,200.23 v2(68.68,200.23)
N17421954: length 4.1
  TOP w0.114: PR9278.1 84.78,188.95 84.86,188.87 84.86,188.87 85.35,188.39 85.35,188.09 v2(85.53,187.91) 86.36,187.91 87.03,188.58 PQ8013.1
N17421956: length 5.2
  TOP w0.114: PQ8013.4 84.53,189.88 84.25,190.16 84.25,191.16 83.87,191.54 v2(83.61,191.54) 83.36,191.54 82.81,190.99 PQ8010.1
N17422036: length 6.1
  TOP w0.114: PQ8009.1 34.05,116.32 34.34,116.61 34.34,117.29 34.92,117.88 35.83,117.88 v2(36.24,118.28) 37.14,117.39 PQ8012.4
N17423044: length 7.5
  TOP w0.114: v2(36.49,97.94) 36.17,98.27 PQ8005.6 36.87,98.82 37,98.96 37,100.3 37.33,100.63 37.41,100.63 37.69,100.91 37.69,101.75 38.2,102.26 39.2,102.26 PR9277.1
N17423573: length 2.3
  TOP w0.381: PR9279.2 38.7,120.34 38.58,120.22 v2(38.58,119.28) 38.44,119.14 PQ8012.1
N17424509: length 21.4
  TOP w0.114: v1(80.79,192.43) 80.92,192.43 PQ8010.3 81.48,193.82 v2(81.4,193.9) ; PR9280.1 v2(69.41,203.98)
  IN2 w0.102: v2(69.41,203.98) 71.08,202.32 71.08,198.66 72.74,197 74.15,197 78.95,192.2 80.56,192.2 v1(80.79,192.43)
N17424572: length 2.1
  TOP w0.114: PR9281.1 36.24,116.15 v2(36.24,117.01) 36.24,117.12 36.09,117.27 PQ8009.3
N17424918: length 2.8
  BOTTOM w0.152: PR19.1 162.66,118.38 v2(162.35,118.69) 162.1,118.69 161.44,119.35 PU1.11
N17424920: length 3.5
  BOTTOM w0.152: PU1.12 161.46,118.95 162.28,118.13 162.28,117.7 162.53,117.45 162.83,117.45 163.02,117.26 PR17.1
N17424921: length 2.7
  BOTTOM w0.152: PU1.7 161.6,121.35 v2(161.84,121.1) 162.27,121.1 PR32.1
N17424925: length 2.4
  BOTTOM w0.152: PR25.1 163.02,119.88 162.75,120.15 PU1.9
N17424950: length 2.5
  BOTTOM w0.152: PU1.15 160.85,117.35 161.01,117.19 PR205.2 161.92,117.19 162.17,116.93 PR8.2
N17661815: length 3
  BOTTOM w0.152: PR26.1 163.07,120.62 v2(163.01,120.57) 162.99,120.55 PU1.8
N17755724: length 54
  IN3 w0.102: v2(164.51,129.56) 164.51,130.32 164.13,130.71 161.84,130.71 160.32,132.23 158.67,132.23 155.94,134.96 154.8,134.96 152.57,137.18 152.57,139.09 153.11,139.62 v2(153.11,139.9)
  IN4 w0.089: v2(153.11,139.9) 153.11,139.95 152.88,140.18 144.24,140.18 141.65,142.77 141.65,147.44 139.24,149.86 131.72,149.86 v2(131.49,149.63)
  BOTTOM w0.114: v2(131.49,149.63) 131.41,149.63 130.94,149.16 130.55,149.16 130.11,149.6 PR7085.1 PR7088.1
  BOTTOM w0.203: v2(164.51,129.56) 164.73,129.56 PR7084.1 164.99,130.06 PR7087.2 164.57,130.9 164.07,131.4 PC7070.2 163.93,131.4 163.15,130.62 PR7081.1
N18453595: length 14.3
  TOP w0.114: R67866.1 221.73,106.88 v2(222.6,106.88) 221.91,107.57 v2(221.72,107.57)
  BOTTOM w0.114: v2(221.72,107.57) 222.66,107.57 223.31,108.23 226.92,108.23 231.14,104.01 CN11.13
N18723876:
  vias: v2(24.8,190.58) v2(25.46,190.62) v2(25.93,184.83)
N18867651:
  vias: v2(203.65,130.07)
N18867812:
  vias: v2(34.08,161.44)
N18922914: length 1.2
  BOTTOM w0.381: U8.AA8 v1(126.5,199.39) 126.89,199.01 U8.AA9
  vias: v2(123.79,197.79)
N19138106: length 1.6
  TOP w0.102: v1(137.32,186.08) 137.32,186.21 136.91,186.63 R321.2
  BOTTOM w0.102: v1(137.32,186.08) 137.62,186.37 U8.F22
N19138109: length 2.2
  TOP w0.102: R322.2 136.82,189.2 137,189.02 137.46,189.02 137.87,188.61 v1(138.1,188.61)
  BOTTOM w0.102: U8.J22 v1(138.1,188.61)
N19521323: length 5.1
  BOTTOM w0.114: PQ6000.3 170.61,131.47 v2(171.31,130.77) 171.5,130.58 171.5,130.07 172.89,128.67 PR6006.1
N19521733: length 3.5
  BOTTOM w0.114: PQ6000.2 169.66,134.33 169.72,134.39 PR9268.2 ; PR9268.2 PR9285.1 ; PR9268.2 PR9269.2 171.15,134.8 PR6012.1
N19549602: length 4.1
  BOTTOM w0.114: PQ6001.2 61.32,183.85 61.16,183.69 PR9271.2 ; PR9271.2 PR9270.2 61.58,183.13 PR6024.1 ; PR9271.2 PR9287.1
N19634328: length 19.9
  TOP w0.114: v2(168.83,104.21) 168.8,104.21 168.68,104.34 U37.83 ; v2(183.85,102.07) 183.83,102.1 183.8,102.1 183.75,102.15 v2(183.18,102.15) 183.01,101.98 R67886.1
  IN1 w0.089: v2(183.85,102.07) 183.56,101.78 175.12,101.78 174.39,102.51 173.4,102.51 172.13,103.78 169.24,103.78 168.83,104.19 v2(168.83,104.21)
N20910893: length 5.4
  BOTTOM w0.114: R67539.1 32.05,53.43 31.63,53.01 Q6565.2 30.95,51.3 30.53,50.87 v2(30.53,50.47) 30.71,50.29 R67865.2
N20911229: length 6.5
  BOTTOM w0.114: R67888.2 32.05,50.54 32.56,51.05 32.56,54.61 32.72,54.77 R67887.1 33.07,55.27 33.63,55.84 Q6570.2
N21263014: length 16.7
  TOP w0.102: 124.18,183.21 126.13,183.21 126.91,183.99 126.91,184.89 v1(127.29,185.28)
  TOP w0.114: 124.18,183.21 123.33,183.21 120.97,180.85 118.56,180.85 117.7,181.71 114.88,181.71 114.8,181.63 114.14,181.63 TP65.1
  BOTTOM w0.102: v1(127.29,185.28) 127.67,185.65 U8.E10
N21263017: length 1.5
  TOP w0.114: TP66.1 127.75,186.08 127.72,186.05 v1(127.27,186.05)
  BOTTOM w0.102: U8.F10 127.7,186.48 v1(127.27,186.05)
N22317721:
  vias: v2(33.19,45.49) v2(33.89,44.88) v2(33.95,45.54) v2(33.99,44.22)
N22358547: length 4.1
  TOP w0.114: v2(218.87,102) 218.74,102 218.07,102.67 F2.2
  TOP w0.508: F2.2 217.6,102.02 v2(217.35,101.77)
  BOTTOM w0.254: CN53.10 217.9,101.57 217.7,101.77 v2(217.35,101.77)
N23734831:
  vias: v2(97.96,193.44)
N24164996: length 9.4
  TOP w0.089: 110.03,122.07 110.48,122.52 110.48,124.04 v1(110.84,124.41)
  TOP w0.114: TP13238.1 110.64,116.87 110.54,116.97 110.54,118.26 109.74,119.06 109.74,121.78 110.03,122.07
  BOTTOM w0.102: U6539.DM29 110.96,124.41 v1(110.84,124.41)
N24164998: length 8.2
  TOP w0.089: v1(111.75,125.03) 111.7,125.03 111.38,124.71 111.38,123.42 111.04,123.09 111.04,122.32 110.79,122.07
  TOP w0.114: 110.79,122.07 110.17,121.45 110.17,119.48 110.78,118.87 TP13239.1
  BOTTOM w0.102: U6539.DK27 111.89,125.08 111.8,125.08 v1(111.75,125.03)
N24182417: length 4.5
  BOTTOM w0.102: U6539.AR2 123.59,150.05 124.12,150.05 124.52,149.66 127.1,149.66
  BOTTOM w0.114: 127.1,149.66 127.24,149.66 R68313.2
N24199172: length 3.8
  TOP w0.508: v2(6.65,11.45) 5.88,11.45 5.1,12.23 5.1,13.01 4.69,13.41 Q28.2
N24203006: length 1.4
  TOP w0.114: U6544.27 77.99,111.67 TP13303.1
N24212326: length 3.5
  TOP w0.114: Q6591.1 v2(73.27,187.54) 72.99,187.26 R68790.2
N24212345: length 5.4
  TOP w0.114: R68567.2 76.46,188.87 v2(76.49,188.84) 76.66,188.67 76.66,188.03 76.47,187.84 76.47,187.63 76.55,187.55 Q6592.3 77.05,186.37 76.31,185.64 Q6591.2
N24507636:
  vias: v2(6.42,37.49)
N24507642: length 4.3
  BOTTOM w0.203: PC9097.1 4.24,38.36 v2(4.24,37.69) PR6418.2 4.93,36.97 PR283.1 4.61,36.1 4.82,35.89 PU3003.6
N24507664: length 1.9
  BOTTOM w0.203: PR6414.1 6.24,38.68 PC9097.2 5.34,38.21 5.38,38.17 PR6418.1
N24507676: length 9.1
  IN1 w0.089: v2(6.07,35.32) 5.32,36.06 5.32,40.61 v2(5.51,40.79)
  BOTTOM w0.114: PU3003.1 6.14,35.39 v2(6.07,35.32) ; v2(5.51,40.79) 5.43,40.71 PR6417.2 4.97,40.51 4.56,40.09 PC6229.2
N24507691: length 3.6
  BOTTOM w0.114: PR284.2 5.69,31.72 v2(5.69,32.46) 5.89,32.66 5.89,33.93 5.38,34.44 PU3003.5
N24586142: length 1.3
  TOP w0.089: TP13352.1 123.03,124.56 v1(122.76,124.56)
  BOTTOM w0.102: v1(122.76,124.56) 122.61,124.41 U6539.DN4
N24586144: length 8.4
  BOTTOM w0.102: U6539.DT6 121.99,122.68 122.31,122.36 122.31,122.07 122.28,122.04 122.28,121.75 122.45,121.59 122.45,121.13 122.58,121 122.65,121 123.06,120.6 123.06,120.24 123.35,119.95
  BOTTOM w0.114: TP13353.1 124.58,116.4 124.58,116.53 124.58,116.53 124.58,118.72 123.35,119.95
N24690147: length 4.1
  TOP w0.102: C386.2 v2(129.96,186.66)
  TOP w0.381: C380.2 130.96,188.61 130.96,188.15 131.17,187.94 L4.2 130.7,187.73 130.61,187.63 C386.2
  BOTTOM w0.381: v1(128.92,186.94) 128.92,186.87 U8.F11
N24716276: length 1.5
  BOTTOM w0.114: TP13407.1 19.66,52.65 U6555.1
N24716283: length 2.1
  BOTTOM w0.114: TP13408.1 19.35,54.89 18.81,54.34 U6555.40
N24717383: length 13.1
  TOP w0.114: v1(13.25,52.98) 16.17,52.98 18.89,55.7 v1(20.11,55.7)
  BOTTOM w0.114: v1(13.25,52.98) 13.03,52.98 12.87,52.83 12.87,52.47 13.04,52.31 U6555.30 ; R69081.1 20.09,57.68 v2(20.06,57.65) 20.06,55.75 v1(20.11,55.7) 20.29,55.7 20.48,55.89 R68712.1
N24718994: length 3.4
  BOTTOM w0.114: R68718.1 19.34,45.24 18.92,45.67 18.16,45.67 17.57,46.25 17.43,46.25 17.31,46.38 U6555.14
N24719030: length 16.8
  BOTTOM w0.114: R68971.1 29.63,42.05 29.12,41.54 R68719.1 28.28,41.88 27.41,41.88 27.28,41.75 27.28,41.18 27.27,41.17 26.64,40.54 26.21,40.54 25.32,41.42 23.69,41.42 21.74,43.38 v2(21.74,43.86) 21.43,43.86 20.58,44.71 20.58,45.2 19.83,45.95 18.26,45.95 17.81,46.4 U6555.13
N24720119: length 4.6
  BOTTOM w0.114: U6555.21 13.11,47.81 11.71,46.41 R68721.1 ; R68721.1 10.62,46.41 10.52,46.31 Q6623.3 ; R68721.1 R68888.1
N24720120: length 6.9
  BOTTOM w0.114: Q6621.3 11.15,43.77 11.19,43.81 R68887.1 R68720.1 11.89,44.37 11.98,44.47 11.98,46 v2(12.95,46.96) U6555.20
N24742096: length 3.9
  BOTTOM w0.508: PQ9011.3 102.06,189.7 103.1,188.66 PD9001.2 103.73,188.11 PR9075.2
N24742104: length 11.6
  BOTTOM w0.508: PQ9009.2 98.66,190.15 v2(99.39,190.88) 99.39,191.06 100.03,191.7 PQ9011.2 100.47,191.19 100.76,190.9 102.31,190.9 103.63,189.58 PQ9010.3 103.95,190.25 103.93,190.27 PR9077.1 PR9074.2
N24742107:
  vias: v2(96.44,186.05) v2(96.39,185.39) v2(97.2,185.82)
N24742118: length 1.2
  BOTTOM w0.114: PR9078.2 104.82,183.79 104.65,183.62 PU9003.3
N24742123: length 2.5
  BOTTOM w0.508: PR9073.2 96.43,191.8 96.95,191.28 v2(97.45,191.28) 97.72,191 PQ9009.3
N24742126: length 20.1
  BOTTOM w0.114: PQ9010.2 104.76,190.08 104.57,189.89 104.57,189.27 104.31,189.01 103.47,189.01 102.08,190.4 99.87,190.4 99.18,189.71 99.18,185.76 98.7,185.28 v2(98.7,183.11) 98.7,182.67 99.11,182.27 99.11,181.76 99.26,181.61 PR9079.2 99.95,182.05 100.36,182.46 PC9073.1 99.99,182.83 99.99,183.41 100.2,183.62 PU9003.4
N24742146: length 1
  BOTTOM w0.508: PR9080.2 PC9071.1
N24742173: length 5.9
  TOP w0.114: PR9069.2 89.14,185.88 89.33,185.7 89.33,185.44 v2(89.92,184.85) 90.14,184.63 90.83,184.63 90.85,184.65 91.88,184.65 92,184.53 PC9059.1 PU9002.4
N24742207: length 1.7
  TOP w0.114: PU9002.10 96.05,183.77 v2(96.13,183.69) 96.16,183.66 PC9063.1
N24742208: length 4.8
  TOP w0.114: PU9002.12 95.85,184.57 96.28,184.14 96.86,184.14 97.66,184.93 v2(98.47,184.93) 98.69,184.93 98.82,184.81 PC9062.1
N24742222: length 4.3
  TOP w0.114: PU9002.5 92.57,183.77 PC9060.1 91.44,182.65 90.42,182.65 v2(90.34,182.72) 89.91,182.72 89.86,182.78 PR9070.1
N24742230: length 3.9
  TOP w0.114: PU9002.3 92.62,184.57 PC9064.1 92,185.51 91.86,185.65 90.65,185.65 90.57,185.72 PR9072.2
N24846908:
  vias: v2(34.69,175.69)
N24846932:
  vias: v2(27.53,174.47)
N24915888: length 2.1
  TOP w0.114: R69051.1 28.88,148.14 28.37,147.62 v2(28.37,147.47)
  TOP w0.203: U67.26 29.78,149.64 29.76,149.63
N24995566: length 4.2
  BOTTOM w0.114: PU3002.5 130.38,114.6 v2(130.78,114.2) 131.36,114.2 PC6228.1 131.61,113.7 131.85,113.46 132.62,113.46 PR3020.2
N24995570: length 2.1
  BOTTOM w0.114: PU3002.1 130.37,117.9 130.37,118.87 v2(130.4,118.89) 130.4,119 130.83,119.43 PR3021.2
N24995581: length 2.5
  BOTTOM w0.114: PU3002.3 132.28,118.51 132.41,118.64 132.89,118.64 v2(133.1,118.43) 133.55,117.98 PR3022.1
N25112700: length 2.1
  TOP w0.114: v1(119.94,127) 120.44,126.5 120.44,125.98 TP13365.1
  BOTTOM w0.102: v1(119.94,127) 120.06,127 U6539.DF8
N25115277: length 6.3
  TOP w0.114: R821.2 107.39,106.1 107.55,106.26 Q85.1 108.95,106.26 109.14,106.45 109.14,107.46 109.45,107.77 110.76,107.77 110.84,107.69 v2(111.35,107.69) 111.35,108.33 R825.2
N25115299: length 3.2
  TOP w0.114: Q86.2 105.24,105.21 v2(106.32,106.3) 106.57,106.55 R821.1
N25121416: length 8.8
  BOTTOM w0.203: R68757.2 R68758.2 ; R68758.2 202.79,116.61 202.38,116.2 v2(202.33,116.2) 201.9,116.64 201.9,116.73 Q6600.2 ; R68758.2 203.37,116.61 203.4,116.64 203.85,116.64 203.91,116.58 C96878.2 C96870.2 ; C96870.2 R68752.2 ; C96870.2 205.02,118.64 204.88,118.78 Q6601.3
N25121434: length 2.8
  BOTTOM w0.203: Q6601.2 203.55,118.13 203.52,118.1 R68755.1 202.69,118.1 202.63,118.16 R68941.2 R68942.2
N25121442: length 3.3
  BOTTOM w0.203: R68751.2 206.55,116.74 206.29,116.99 205.93,116.99 205.82,117.09 Q6601.6 206.39,117.48 206.54,117.63 206.54,118.01 206.41,118.13 Q6601.5
N25125657: length 9.8
  TOP w0.114: U37.35 154.26,94.42 153.82,93.98 151.61,93.98 v2(151.38,94.21) 146.78,94.21 146.32,94.67 R68750.2
N25126048: length 3.2
  BOTTOM w0.114: v2(25.73,46.28) 25.18,46.28 R68759.2 R68761.1 25.31,47.64 25.37,47.7 Q6603.3
N25130063: length 3
  TOP w0.114: U37.82 168.4,103.94 168.68,103.65 169.21,103.65 169.37,103.81 C1208.2 169.37,104.67 R960.1
N25130097: length 6.7
  TOP w0.114: R895.1 169.21,113.18 169.05,113.02 C6580.2 168.47,113.02 167.23,111.78 166.7,111.78 v2(166.59,111.68) 166.25,111.34 166.25,110.5 165.87,110.12 165.59,110.12 165.46,110.24 U37.98
N25130580: length 45.3
  TOP w0.114: R68870.1 R68769.1 v2(175.04,122.59) 176.96,120.67 176.96,119.28 178.48,117.75 178.48,116.48 176.68,114.68 v1(176.19,114.68) ; v1(172.74,112.29) 172.27,111.82 R68764.1 ; U37.20 152.87,101.94 v2(154.84,103.91)
  IN2 w0.102: v1(154.84,105.58) 154.94,105.69 160.55,105.69 161.51,106.65 163.7,106.65 164.38,107.34 166.72,107.34 168.07,108.68 168.07,109.04 168.65,109.62 169.84,109.62 171.37,111.15 171.6,111.15 v1(172.74,112.29) 173.25,112.8 174.32,112.8 v1(176.19,114.68)
  BOTTOM w0.114: v1(154.84,105.58) v2(154.84,103.91)
N25235355: length 3
  TOP w0.114: PQ8005.2 38.05,99.47 38.43,99.85 38.43,100.43 38.55,100.55 PR8017.2 39.93,100.55 PR8015.2
N25257440: length 6.8
  TOP w0.114: PQ8005.3 37.77,100.48 v2(38.15,100.87) PR9277.2 v2(38.32,101.7) ; PR8007.2 34.92,101.62 35.18,101.36 v2(35.37,101.36)
  IN1 w0.089: v2(35.37,101.36) 35.71,101.7 v2(38.32,101.7)
N25257697: length 5.8
  TOP w0.114: PR8014.1 33.73,97.38 v2(33.73,96.8) 34.35,96.8 PR8006.2 34.88,97.06 35.37,97.55 PR8016.1 35.67,97.89 35.42,98.14 35.42,99.1 35.79,99.47 PQ8005.5
N25318825: length 1.9
  TOP w0.254: PQ8000.3 52.2,199.16 v2(53.08,199.16) 53.11,199.13 PR8005.1
N25318883: length 7.9
  TOP w0.254: PR8011.2 52.95,196.94 52.67,196.67 PR8010.1 51.78,197.46 50,199.24 PQ8000.2 49.46,199.9 v2(49.07,200.3) 48.81,200.05 PR8012.1
N25318964: length 3.8
  TOP w0.254: PR8012.2 48.66,198.68 v2(47.98,198.68) 47.98,198.37 PR8013.1 49.55,197.55 PQ8000.1
N25319146: length 6.8
  TOP w0.114: PR8001.2 52.88,200.46 53.11,200.68 54.22,200.68 v2(54.35,200.81)
  TOP w0.254: PR8001.2 52.88,200.12 52.89,200.11 52.89,199.88 53.06,199.71 54.05,199.71 54.8,198.97 PQ8003.2 53.98,198.06 53.64,198.4 PR8005.2
N25365001: length 51.8
  TOP w0.254: PR9103.2 165.83,209.28 v2(165.83,208.43) ; PQ9084.3 159.9,169.83 v2(159.99,169.92) 160.14,170.08 161.97,170.08 162.28,169.77 v2(162.28,169.54)
  IN1 w0.254: v2(162.28,169.54) 162.28,169.36 162.65,168.98 167.74,168.98 168.57,169.82 168.57,189.63 167.03,191.18 167.03,207.35 165.95,208.43 v2(165.83,208.43)
N25415674: length 6
  TOP w0.114: Q6604.2 229.7,92.8 R68792.2 231.34,93.65 v2(232.52,94.83) 232.75,95.06 Q6605.3
N25430988: length 1.8
  TOP w0.508: PQ12.3 99.84,97.46 99.61,97.69 PR106.2
N25430994:
  vias: v2(14.5,146.22)
N25431520: length 4.1
  TOP w0.114: v2(34.97,124.1) 35.6,123.48 PQ9050.3
  TOP w0.508: PQ9050.3 37,124.15 36.5,124.65 PR9227.2
N25498070: length 3.3
  BOTTOM w0.114: U6556.15 133.14,123.45 132.89,123.7 v2(132.89,125.05) 132.63,125.31 R68881.2
N25498073: length 4.5
  BOTTOM w0.114: U6556.14 132.77,122.95 v2(132.38,123.34) 132.38,125.11 R68867.2
N25804343: length 1
  TOP w0.254: PR9027.2 94.93,195.5 94.88,195.45 PR9030.2
N25817818: length 3.5
  TOP w0.508: v2(167.2,167.99) 167.08,167.99 166.36,167.28 PR9099.2 165.01,167.28 164.77,167.51 PQ9085.3
N25817820: length 8.4
  TOP w0.508: PQ9086.3 160.29,167.82 160.62,167.49 PR9101.1 160.98,168.05 160.99,168.06 PR9100.2 161.3,168.55 161.4,168.46 PQ9085.2 162.7,168.46 163.37,167.79 163.37,165.68 v2(162.91,165.22)
N25821251: length 3.3
  TOP w0.114: PR9092.2 163.8,158.29 v2(163.95,158.14)
  TOP w0.203: 162.95,158.34 162.94,158.34 PR9092.2
  TOP w0.508: 162.95,158.34 163.15,158.14 163.15,157 PC9088.1
N25875824: length 2.4
  TOP w0.114: R68844.1 R68846.2
  TOP w0.203: U6562.2 169.21,145.44 169.44,145.66 R68846.2
N25875922: length 4.7
  TOP w0.203: R68846.1 168.98,146.68 169.14,146.83 170.23,146.83 170.61,147.22 170.61,148.36 170.34,148.63 U6561.4
N25875939: length 6.4
  TOP w0.203: R68845.1 172.64,151.41 v2(172.3,151.75) Q6611.3 169.68,151.75 169.08,151.15 v2(169.08,150.64)
  BOTTOM w0.203: Q6610.2 169.53,150.45 169.34,150.64 v2(169.08,150.64)
N25875956: length 3.1
  TOP w0.203: R68852.2 R68849.2 173.18,148.01 172.92,147.75 172.61,147.75 172.19,147.33 U6561.1
N25876028: length 4
  TOP w0.114: R68851.2 167.52,149.37 R68850.2 ; R68851.2 167.8,149.51 167.8,149.65 167.96,149.81 168.6,149.81 168.7,149.91 v2(168.91,149.91) 169.05,150.05 Q6611.2 ; R68851.2 R68848.2
N25876122: length 3.1
  TOP w0.114: v2(167.69,143.15) 167.44,142.91 R68853.1 167.69,142.26 168.19,141.75 168.43,141.75 168.56,141.88 U6562.4
N25876250: length 2.8
  BOTTOM w0.203: 168.83,146 168.7,145.87 168.68,145.87 168.56,145.75 U6563.4 ; 168.83,146 168.98,146.15 168.98,146.17 169.01,146.2 R68856.1 ; 168.83,146 168.83,146 168.93,145.89 v2(168.96,145.95) 168.83,145.89 168.83,146
N26402629: length 3.1
  TOP w0.114: PJ9005.1 34.33,132.98 v2(34.08,132.74)
N26712738: length 5.4
  TOP w0.114: R69083.2 151.48,113.69 v2(151.56,113.61) 151.73,113.43 152.83,113.43 153.09,113.17 R69084.2 153.09,112.72 153.33,112.48 153.91,112.48 154.26,112.13 U37.126
N26812254: length 3.1
  TOP w0.114: PQ9088.3 25.2,141.13 PR9286.2 v2(25.2,138.08)
N26985789: length 4.6
  TOP w0.089: v1(119.03,125.75) 119.03,125.75 119.4,125.38 119.4,123.49 119.81,123.09 120.24,123.09 TP13391.1
  BOTTOM w0.102: v1(119.03,125.75) 119.13,125.75 U6539.DK10
N27093787: length 11.3
  TOP w0.079: v5(20.26,64.86) 20.28,64.86 20.31,64.89 20.35,64.89 U6549.J6
  IN3 w0.102: v5(20.26,64.86) 20.29,64.86 20.87,64.28 20.87,64.03 21.25,63.65 22.09,63.65 22.65,63.09 22.65,61.44 25.06,59.03 25.06,58.06 24.73,57.73 v1(24.73,57.48)
  BOTTOM w0.114: v1(24.73,57.48) 24.84,57.58 R68878.1
N27303190: length 3.1
  TOP w0.114: v1(120.87,127.02) 120.87,127.01 121.01,126.87 122.82,126.87 122.85,126.84 TP13392.1
  BOTTOM w0.102: U6539.DF6 121,127.02 v1(120.87,127.02)
N27303193: length 6.4
  TOP w0.089: 112.57,122.07 112.57,123.16 113.03,123.62 113.03,124.58 v1(113.57,125.12)
  TOP w0.114: TP13393.1 112.39,119.86 112.57,120.04 112.57,122.07
  BOTTOM w0.102: v1(113.57,125.12) 113.75,125.12 U6539.DK23
N27407759: length 3.5
  BOTTOM w0.114: v2(96.69,103.3) 96.56,103.43 R68919.1
  BOTTOM w0.203: 96.55,105.18 R68920.1 ; 96.55,105.18 96.55,105.67 96.73,105.85 U6554.5 ; 96.55,105.18 96.55,104.17 R68919.1
N27485779: length 8.9
  IN3 w0.102: v1(121.48,140.1) 121.83,140.1 122.22,140.48 124.38,140.48 126.03,142.14 127.55,142.14 127.93,142.52 v2(127.93,142.64)
  BOTTOM w0.102: U6539.BV7 121.48,139.88 v1(121.48,140.1) ; v2(127.93,142.64) 128.32,142.26 128.43,142.26
  BOTTOM w0.114: 128.43,142.26 TP13394.1
N27485780: length 9.1
  IN3 w0.102: v2(127.17,142.64) 127,142.64 126.87,142.52 126.03,142.52 125.14,141.63 124.76,141.63 124.63,141.75 122.98,141.75 121.84,140.61 121.38,140.61 v1(120.87,140.1)
  BOTTOM w0.102: U6539.BV8 120.87,139.92 v1(120.87,140.1) ; TP13395.1 127.17,142.77 v2(127.17,142.64)
N27485781: length 4.4
  BOTTOM w0.089: U6539.CG2 123.44,135.67 123.7,135.92 124,135.92 124.51,136.42 125.88,136.42 126.16,136.7
  BOTTOM w0.114: 126.16,136.7 126.28,136.83 TP13396.1
N27485782: length 5
  BOTTOM w0.089: U6539.CG1 123.99,135.74 124.08,135.74 124.51,136.17 125.9,136.17 126.16,136.42
  BOTTOM w0.114: 126.16,136.42 127.43,136.42 127.73,136.72 TP13397.1
N27487756: length 14.4
  TOP w0.089: v1(109.02,126.95) 108.63,126.56 108.63,125.75 108.48,125.6 108.48,123.44 108.05,123.01 108.05,122.27 108.1,122.22 108.1,122.07
  TOP w0.114: 108.1,122.07 108.1,118.67 106.65,117.22 106.65,116.48 106.9,116.23 107.49,116.23 107.69,116.02 107.69,115.29 TP13398.1
  BOTTOM w0.102: v1(109.02,126.95) 108.95,126.95 U6539.DF35
N27533429: length 4.5
  TOP w0.114: R68925.1 25.07,161.94 25.19,161.82 25.45,161.82 25.56,161.94 R67506.1 26.28,161.94 26.38,161.84 26.62,161.84 26.72,161.94 R67505.1 27.74,161.94 28.13,161.55 Q6618.3
N27664004: length 6.1
  BOTTOM w0.102: U6539.DW38 106.97,120.71 107.22,120.46 107.22,119.21 106.52,118.51 106.22,118.51 105.96,118.26 105.96,117.6 106.34,117.22 v4(106.34,116.99) R68939.2
N27752748: length 10.9
  TOP w0.254: v2(17.95,24.73) 18.13,24.91 18.13,27.35 19.17,28.39 21.31,28.39 22.07,27.63 v2(22.78,27.63) 23.04,27.37 23.04,26.93 23.46,26.5 R736.2
  BOTTOM w0.254: v2(17.95,24.73) 18.16,24.94 R450.2
N27826847: length 4.6
  BOTTOM w0.114: R68945.1 196.04,113.05 195.91,113.18 194.03,113.18 193.8,113.4 CN17.42
N27826858: length 2.5
  BOTTOM w0.114: CN17.40 193.89,113.9 194.1,113.69 R68944.1
N27826869: length 4.7
  BOTTOM w0.114: CN17.38 195.8,114.4 196.04,114.17 R68943.1
N27947671: length 96.6
  IN4 w0.089: v1(116.29,123.75) 116.25,123.7 116.25,122.58 116.5,122.32 117.65,122.32 118.44,121.54 120.44,121.54 121.38,120.6 121.38,120.29 121.76,119.91 122.7,119.91 124.23,118.39 124.51,118.39 126.28,116.61 126.28,113.43 130.45,109.27 131.82,109.27 133.8,107.29 135.63,107.29 136.99,105.93 140.37,105.93 140.61,105.69 144.43,105.69 145.57,106.83 166.67,106.83 166.8,106.7 173.58,106.7 176.55,109.67 178.96,109.67 181.61,112.32 181.61,112.62 181.91,112.93 183.18,112.93 183.94,113.69 193.47,113.69 194.48,112.67 v2(195.37,112.67)
  BOTTOM w0.102: v1(116.29,123.75) 116.45,123.59 116.91,123.59 117.11,123.39 117.11,122.35 117.45,122.02 U6539.DV15
  BOTTOM w0.114: R68946.1 v2(195.37,112.67)
N27947696: length 6.6
  TOP w0.089: 121.58,122.58 121.08,123.09 120.57,123.09 120.38,123.28 119.87,123.28 119.58,123.57 119.58,125.86 119.13,126.31 119.05,126.31 119.03,126.33 v1(119.03,126.33)
  TOP w0.114: TP13401.1 121.81,122.35 121.58,122.58
  BOTTOM w0.102: U6539.DJ10 119.19,126.33 v1(119.03,126.33)
N27947896: length 110.1
  IN4 w0.089: v1(112.66,127.02) 113.16,127.53 113.84,127.53 113.96,127.4 113.96,123.59 115.97,121.59 117.29,121.59 118.08,120.8 120.29,120.8 120.67,120.42 120.67,120.06 121.94,118.79 121.94,117.85 122.55,117.24 124.76,117.24 125.01,116.99 125.01,114.14 130.3,108.86 131.67,108.86 133.4,107.13 133.4,106.7 133.89,106.21 136.05,106.21 136.77,105.48 139.95,105.48 140.23,105.2 144.6,105.2 145.38,105.99 147.7,105.99 148.1,106.4 162.15,106.4 162.68,105.86 167.74,105.86 168.27,105.33 173.63,105.33 175.66,103.3 179.14,103.3 181.1,105.25 181.1,111.2 181.5,111.6 182.9,111.6 184.78,113.48 193.29,113.48 194.51,112.26 196.03,112.26 196.64,111.66 v2(197.02,111.66)
  BOTTOM w0.102: U6539.DF25 112.8,127.02 v1(112.66,127.02)
  BOTTOM w0.114: R68947.2 v2(197.02,111.66)
N27947914: length 108.8
  IN4 w0.089: v1(111.75,127.02) 112.19,126.58 112.19,122.96 113.36,121.79 115.01,121.79 116.12,120.67 116.12,120.07 116.51,119.68 120.34,119.68 121.46,118.56 121.46,117.78 122.88,116.35 124,116.35 124.51,115.85 124.51,114.09 130.14,108.45 131.52,108.45 132.89,107.08 132.89,106.6 133.7,105.79 135.71,105.79 136.44,105.05 139.62,105.05 139.87,104.8 144.9,104.8 145.69,105.58 147.9,105.58 148.25,105.94 153.59,105.94 154.35,105.18 154.99,105.18 155.75,105.94 157.96,105.94 158.44,105.46 166.92,105.46 167.46,104.92 173.3,104.92 175.33,102.89 179.29,102.89 181.5,105.1 181.5,111.02 181.68,111.2 183.05,111.2 184.93,113.08 192.68,113.08 194.1,111.66 v2(195.37,111.66)
  BOTTOM w0.102: v1(111.75,127.02) 111.89,127.02 U6539.DF27
  BOTTOM w0.114: R68948.2 v2(195.37,111.66)
N28099262: length 6.5
  TOP w0.114: R68834.1 207.36,107.79 207.56,107.59 v2(207.56,107.31) R68953.1 R68952.2 R68950.1 R68951.1 204.3,107.31 204.01,107.6 ; R68838.1 203.73,107.32 204.01,107.6 ; R68828.2 204.3,108.51 204.01,108.22 204.01,107.6
N28099429: length 5.2
  TOP w0.114: R68831.1 208.23,114.29 208.42,114.1 R68832.2 208.42,113.41 208.71,113.13 208.71,111.66 209.09,111.27 209.6,111.27 209.72,111.15 U6559.2
N28099505: length 1.4
  TOP w0.114: U6558.4 208.09,113.3 207.97,113.41 R68832.1
N28099527: length 2.3
  TOP w0.114: U6558.1 206.79,109.61 206.67,109.5 v2(206.67,109.09) 207.01,108.76 207.05,108.76 R68834.2
N28099545: length 2.5
  TOP w0.254: Q6608.3 201.71,122.43 v2(201.98,122.7) 202.48,123.21 R68833.2
N28099579: length 1.6
  TOP w0.114: R68857.1 210.37,113.81 U6559.4
N28099660: length 13.8
  TOP w0.114: D13149.3 203.63,109.71 203.75,109.84 203.75,112.16 203.16,112.76 D13150.3 v2(202.61,114.45) 202.99,114.83 202.99,116.35 203.37,116.74 R68837.1
N28099672: length 1.2
  TOP w0.114: R68838.2 203.27,107.41 203.24,107.45 D13149.1
N28379472: length 5.7
  TOP w0.254: v1(98.75,195.96) 97.76,195.96 97.47,196.25 PR9023.1 97.47,196.54 PR9024.1 96.45,197.32 v2(96.41,197.35) 96.21,197.56 PC9025.1
  BOTTOM w0.254: PR9021.2 98.06,195.78 98.24,195.96 v1(98.75,195.96)
N28379477: length 2.7
  BOTTOM w0.61: PR9019.1 v2(105.86,195.91) 106.4,195.91 106.94,196.45 PC9024.1
N28380796: length 1.6
  TOP w0.203: PR9017.1 98.49,197.74 98.22,198.02 97.58,198.02 TP9000.1
N28380828: length 3.7
  TOP w0.254: PR9000.2 95.2,192.77 95.72,193.28 PC9004.1 96.49,193.28 96.88,193.67 v2(97.38,193.67) 97.7,193.67 98.08,194.05 PR9002.2
N28433042: length 16.3
  TOP w0.254: v1(102.55,192.9) 102.6,192.9 102.72,192.78 103.13,192.78 PR9033.1 103.26,192.94 102.5,193.7 PU9000.13
  IN2 w0.254: v2(106.86,199.03) 105.66,199.03 104.19,197.55 104.19,196.11 103.3,195.22 103.3,193.49 102.74,192.94 102.59,192.94 v1(102.55,192.9)
  BOTTOM w0.254: PR9274.1 107.34,202.82 105.55,201.03 105.55,200.33 105.76,200.12 106.39,200.12 v2(106.42,200.1) 106.86,199.66 v2(106.86,199.03)
N28477601: length 4.6
  BOTTOM w0.203: R339.2 R343.2 133.11,177.7 132.99,177.57 v2(132.68,177.57) 132.13,177.57 132.12,177.57 R341.2 131.13,177.57 130.75,177.95 R342.2
N28607521: length 2.7
  TOP w0.254: PU9000.22 103.7,198.06 103.7,198.17 v1(103.88,198.35)
  BOTTOM w0.203: PR9034.1 104.09,197.67 v2(104.24,197.81) 104.24,197.99 v1(103.88,198.35)
N28835637: length 3.7
  TOP w0.114: U37.5 150.57,107.94 R68765.2 R68871.2 148.31,107.53 v2(148.25,107.59)
N29093947: length 3.6
  TOP w0.114: Q14.2 112.14,187.05 v2(112.44,187.35) R386.1 113.1,187.57 112.69,187.98 112.69,188.72 112.82,188.85 112.85,188.85 Q16.3
N29227824: length 9.9
  BOTTOM w0.114: R68976.2 29.43,43.96 29.69,44.22 29.69,45.62 29.81,45.75 D13160.2 31.41,45.75 v2(31.61,45.56) 31.61,43.65 30.91,42.95 30.91,41.93 30.65,41.68 C96906.2 R68969.1
N30140264: length 3.4
  TOP w0.114: R25519.2 151.78,208.59 151.94,208.43 v2(152.83,208.43)
  TOP w0.508: R25519.2 151.78,210.38 D13092.2
N30263848: length 4.3
  TOP w0.079: 154.54,212.62 154.54,212.68 154.86,213 154.86,213.89 U6516.B3
  TOP w0.114: C20140.2 153.69,211.58 154.54,212.43 154.54,212.62
N30263849: length 2.9
  TOP w0.114: U6516.A1 154.11,213.02 153.79,212.69 152.63,212.69 152.32,213 152.32,213.38 TP9067.1
N30263851: length 4
  TOP w0.114: TP9068.1 156.74,209.72 156.74,211.83 155.61,212.96 U6516.D1
N30263855: length 3.1
  TOP w0.114: U6516.B1 154.28,212.81 154.28,212.62 153.52,211.86 153.08,211.86 TP9071.1
N30263859: length 7.3
  TOP w0.079: U6516.E1 156.24,213.14 156.74,212.64
  TOP w0.114: 156.74,212.64 157.29,212.09 157.29,210.95 157.91,210.33 157.91,208.43 158.41,207.92 TP9072.1
N30330849:
  vias: v2(165.78,159.66) v3(165.15,151.41) v3(165.15,150.64) v3(165.91,151.41) v3(165.91,150.64) v3(166.67,151.41) v3(166.67,150.64) v3(167.43,152.42) v3(167.43,151.41) v3(167.43,150.64) v3(168.32,150.59)
N30330942: length 2
  BOTTOM w0.508: PC9079.2 164.8,158.33 165.88,159.41 PR9089.1
N30344538: length 1
  BOTTOM w0.114: R69004.1 7.16,53.24 7.03,53.11 U6553.14
N30344562: length 2.4
  BOTTOM w0.114: R68902.1 R68681.1 6.11,53.44 6.52,53.03 6.53,53.03 U6553.13
N30344604: length 2.7
  BOTTOM w0.114: U6553.12 6.03,52.98 5.9,53.11 4.87,53.11 4.37,53.61 C96909.1
N30344614: length 3.2
  BOTTOM w0.114: R68902.2 5.66,55.42 v2(6.08,55.84) 6.97,55.84 7.2,56.07 Q6617.3
N30344643: length 1.6
  BOTTOM w0.114: U6553.8 4.75,50.19 4.62,50.06 4.62,49.81 4.21,49.4 R69008.1
N30344645: length 1.3
  BOTTOM w0.114: U6553.9 4.73,50.7 4.21,50.17 R69009.1
N30344649: length 2
  BOTTOM w0.114: U6553.11 5.01,51.7 4.36,52.35 R69005.1 C96908.1
N30345632: length 11.7
  BOTTOM w0.114: U6553.4 7.03,48.16 6.78,47.9 5.25,47.9 5.2,47.85 R68677.2 4.44,47.85 4.31,47.72 4.31,47.01 4.24,46.94 v2(4.24,44.6) 3.98,44.35 R68680.1 4.39,43.81 4.62,43.58 4.62,42.69 4.87,42.44 5.99,42.44 6.12,42.31 Q6593.3
N30355139: length 1.8
  BOTTOM w0.114: U6553.7 4.89,49.7 4.62,49.43 4.62,48.79 4.41,48.59 C96910.2
N30442036:
  vias: v2(37.23,161.01)
N30442060: length 4.7
  TOP w0.114: PR6023.1 35.73,166.76 PC6051.1 35.48,165.49 PU6002.4
N30442062: length 1.7
  TOP w0.114: PU6002.12 35.88,161.78 36.04,161.61 PC6056.1
N30442063: length 1.7
  TOP w0.114: PC6057.1 34.97,161.67 35.08,161.77 PU6002.10
N30452871: length 4.5
  TOP w0.114: PU6002.5 35.08,165.27 v2(34.89,165.45) 35.22,165.78 PC6053.1 34.72,166.76 PR6028.2
N30452875: length 5.1
  TOP w0.114: PR6027.2 36.62,168.17 36.72,168.07 36.72,166.79 PC6052.1 36.94,165.93 36.67,165.93 v2(36.16,165.43) 35.88,165.14 PU6002.3
N30586955: length 4.7
  BOTTOM w0.203: PU6000.12 175.71,132.81 v2(175.71,132.81) 175.69,132.84 PR6014.2 175.62,133.69 174.86,134.45 PR6010.1 174.14,135 173.9,135 PC6024.2
N30586967: length 1.9
  BOTTOM w0.114: PC6024.1 172.77,135.36 v2(172.77,136.17)
  BOTTOM w0.203: PR6011.1 172.79,134.46 PC6024.1
N30587068: length 5
  BOTTOM w0.203: PC6059.2 60.98,181.74 PR6030.1 60.07,182.51 v2(59.91,182.66) PR6031.2 58.52,182.66 57.98,183.21 57.75,183.21 57.65,183.3 PU6003.9
N30587073: length 1.9
  BOTTOM w0.114: PR6029.1 v2(61.83,179.96)
  BOTTOM w0.203: PC6059.1 PR6029.1
N30587125:
  vias: v2(57.09,180.97)
N30587150: length 3.5
  BOTTOM w0.114: PQ6001.3 59.92,187.52 v2(58.49,187.52) 58.49,186.94 58.14,186.59 PR6021.1
N30587190: length 4.5
  TOP w0.203: PR6003.2 173.98,129.85 v2(174.06,129.77) 174.63,129.77 v2(174.88,130.02) 175.67,130.02 PR6007.1
  BOTTOM w0.203: PR6004.2 PR6005.1 174.06,129.69 174.22,129.84 174.71,129.84 v2(174.88,130.02)
N30789824: length 3.6
  TOP w0.079: 153.64,214.98 153.66,214.98 153.75,214.89 154.36,214.89 U6516.B4
  TOP w0.114: TP9073.1 153.08,216.94 153.08,215.29 153.39,214.98 153.64,214.98
N30789945: length 6.6
  TOP w0.079: 156.39,212.62 156.26,212.75 156.13,212.75 155.86,213.01 155.86,213.39 U6516.D2
  TOP w0.114: TP9070.1 157.53,210.21 157.02,210.72 157.02,211.98 156.39,212.62
N30839245: length 4.6
  BOTTOM w0.114: Q32.2 113.35,108.85 113.19,108.85 112.95,108.61 112.95,108.43 112.72,108.2 v2(112.72,106.4) 112.56,106.24 C750.2 112.6,105.55 R609.2
N31076875:
  vias: v2(203.2,127.63)
N31161958: length 6.1
  TOP w0.114: v2(198.7,128.93) 199.98,128.93 PC6025.1 200.83,128.93 201.37,128.93 201.62,128.67 v2(201.9,128.67) 201.9,129.5 PR6013.1
  BOTTOM w0.114: v2(198.7,128.93) PU6001.4
N31161974: length 6.7
  BOTTOM w0.114: PC6028.1 207.88,127.45 207.67,127.25 206.2,127.25 v2(205.94,127.5) 205.54,127.9 203.86,127.9 203.24,128.53 PU6001.12
N31161976: length 3.3
  BOTTOM w0.114: PU6001.10 202.82,129.33 203.65,128.49 v2(204.13,128.49) 204.26,128.37 PC6029.1
N31162017: length 4.2
  TOP w0.114: PR6016.2 198.65,130.61 198.8,130.45 199.09,130.45 PC6027.1 199.23,129.92 198.83,129.92 v2(198.57,129.66) 198.85,129.39 v2(199.2,129.39)
  BOTTOM w0.114: PU6001.5 199.26,129.33 v2(199.2,129.39)
N31162025: length 4.8
  TOP w0.114: v2(199.17,128.46) 198.87,128.46 198.55,128.14 v2(198.55,127.73) 199.13,127.73 199.42,128.02 PC6026.1 199.75,127.34 199.53,127.12 PR6015.2
  BOTTOM w0.114: v2(199.17,128.46) 199.24,128.53 PU6001.3
N31353100: length 1
  TOP w0.114: PC551.2 v2(33.56,140.65)
N31548948: length 2.6
  TOP w0.114: v2(55.62,148.38) 55.74,148.26 R69022.2
  BOTTOM w0.114: v2(55.62,148.38) 55.62,148.36 55.67,148.31 55.67,148.23 56.08,147.82 JDIM02.96
N31551497: length 2.1
  TOP w0.114: R69023.2 43.76,147.75 v2(43.73,147.72)
  BOTTOM w0.114: v2(43.73,147.72) 43.83,147.82 JDIM1.96
N31552936: length 1.8
  TOP w0.114: Q124.2 56.2,135.93 56.59,136.32 v2(56.77,136.32) 57.25,136.32 57.25,136.32 R1684.2
N31558072: length 1.7
  TOP w0.114: Q6639.2 v2(54.34,142.29) 54.08,142.54 R69025.2
N31570187: length 3
  TOP w0.114: v1(93.49,178.1) 94.03,178.63 R69026.2
  BOTTOM w0.114: v1(93.49,178.1) 93.13,177.74 Q6640.2
N31759245: length 3.5
  TOP w0.114: R69030.1 189.43,121.61 v1(189.48,121.56)
  BOTTOM w0.114: v1(189.48,121.56) 189.48,121.76 189.78,122.07 190.93,122.07 191.1,121.9 CN17.8
N31759916: length 4
  TOP w0.114: v1(190.09,121.56) 190.09,122.02 190.25,122.18 v2(190.6,122.18) 191,122.18 191.27,121.91 R69031.1
  BOTTOM w0.114: CN17.12 190.75,120.9 v1(190.09,121.56)
N31760419: length 3.1
  TOP w0.114: R69032.1 189.91,119.92 189.91,119.91 v2(189.91,119.4)
  BOTTOM w0.114: CN17.20 190.41,118.9 v2(189.91,119.4)
N31760441: length 16.7
  TOP w0.114: v1(115.36,114.45) 115.74,114.07 115.74,113.94 115.9,113.79 R69034.2 116.38,113.79 116.5,113.66 R69033.2
  IN2 w0.102: v1(112.66,126.39) 112.19,125.92 112.19,122.58 113.46,121.31 113.46,119.15 115.64,116.96 115.64,115.44 115.36,115.16 v1(115.36,114.45)
  BOTTOM w0.102: U6539.DJ27 112.31,126.04 v1(112.66,126.39)
N31858909: length 3.5
  TOP w0.114: R69035.2 133.52,124.74 v2(134.09,125.31) 134.41,125.63 134.77,125.63 v1(134.79,125.6)
  BOTTOM w0.114: v1(134.79,125.6) 134.94,125.46 U6556.16
N31870175:
  vias: v2(234.11,120.16)
N31870199: length 9.4
  TOP w0.114: Q6642.2 234.29,125.44 234.11,125.63 v2(233.47,125.63) C96918.2 R69043.2 232.3,126.91 232.07,127.15 231.57,127.15 231.31,126.9 231.31,124.86 230.95,124.5 Q6643.3
N31875033: length 4.5
  TOP w0.114: R69046.1 218.64,106.61 C96921.2 218.64,108.19 218.39,108.44 217.72,108.44 v2(217.04,109.12) 216.41,109.12 Q6644.3
N31875049: length 5.9
  TOP w0.114: Q6645.3 213.41,104.8 213.53,104.67 C96920.2 R69047.2 215.97,105.57 216.1,105.69 v2(216.1,106.22) 215.79,106.53 Q6644.2
N32270324: length 3.6
  TOP w0.114: Q62.3 25.59,136.31 25.45,136.17 25.45,134.89 R68907.1
N32270343: length 3.5
  TOP w0.114: Q62.6 23.65,135.01 23.29,134.64 22.78,134.64 22.65,134.77 22.65,134.9 22.54,135.01 v2(22.24,135.01) 22.01,134.78 R68906.1
N32484985: length 2.7
  TOP w0.254: PQ8008.2 57.09,194.7 PR8021.1 56.6,195.7 PR8018.2
N32484987: length 3.3
  TOP w0.114: PR8021.2 57.9,194.17 57.95,194.22 PR8027.1 58.71,193.88 58.71,193.87 59,193.58 PR8025.2 59.63,193.86 v4(59.63,194.43)
N32485009:
  vias: v2(52.52,191.59)
N32485013: length 5.6
  TOP w0.254: PR8019.2 55.63,195.71 55.29,195.37 54.53,195.37 54,195.91 PR8020.2 53.74,195.33 54.09,194.98 PQ8008.1 52.51,194.7 PQ8011.1
N32485017: length 8.3
  TOP w0.254: PQ8011.3 51.53,193.87 51.56,193.9 v2(52.9,193.9) 56.58,193.9 PR8029.1 57.7,193.19 57.73,193.21 PR8026.1
N32485347: length 2.1
  TOP w0.254: PQ8004.2 34.68,101.38 34.47,101.59 PR8007.1 PR8003.1
N33144601:
  vias: v2(220.01,123.59) v2(220.77,123.59) v2(223.06,133.91) v2(223.72,133.91)
N33147251: length 3.4
  TOP w0.114: v2(87.64,171.38) PR9288.2
  TOP w0.203: 88.31,173.89 89.2,173.89 89.35,173.73 89.81,173.73 89.99,173.92 PU5001.2
N33772426: length 1.9
  BOTTOM w0.114: TP2092.1 32.1,71.67 CN16.10
N33772437: length 3.7
  BOTTOM w0.114: R69098.1 17.29,69.46 17.6,69.77 v2(17.6,70.58) CN16.68
N34070491: length 6.7
  BOTTOM w0.089: 123.24,166.52 123.24,165.67 123.24,165.66 123.24,165.41 123.24,165.4 123.24,165.29 123.12,165.17 123.12,164.74 U6539.D4
  BOTTOM w0.102: TP13410.1 124.25,169.57 124.25,168.55 124,168.3 124,167.92 123.24,167.15 123.24,166.52
N34070504: length 1.3
  TOP w0.114: v1(118.48,145.2) 118.56,145.28 119.14,145.28 TP13411.1
  BOTTOM w0.102: U6539.BF12 118.55,145.13 v1(118.48,145.2)
N34070780: length 7.5
  TOP w0.114: TP13412.1 116.25,155.43 116.64,155.83 116.64,156.24 116.21,156.68 115.93,156.68 115.29,157.32 v1(115.29,157.93)
  BOTTOM w0.102: U6539.V21 114.97,157.61 v1(115.29,157.93)
N34070795: length 5.1
  TOP w0.114: v1(115.29,156.63) 115.46,156.46 116.12,156.46 116.38,156.21 116.38,155.85 115.97,155.44 115.97,153.41 TP13413.1
  BOTTOM w0.102: U6539.W20 115.3,156.8 115.29,156.79 v1(115.29,156.63)
N34070810: length 2.2
  TOP w0.102: v1(107.49,158.59) 108.35,158.59
  TOP w0.114: TP13414.1 109.01,158.59 108.35,158.59
  BOTTOM w0.102: U6539.U37 107.76,158.32 v1(107.49,158.59)
N34070825: length 1.4
  TOP w0.114: v1(107.22,137.37) 107.04,137.37 TP13415.1
  BOTTOM w0.102: U6539.CD39 106.97,137.37 v1(107.22,137.37)
N34070840: length 5
  TOP w0.114: v1(115.29,158.65) 114.83,158.19 114.83,157.48 114.47,157.12 114.47,155.09 TP13416.1
  BOTTOM w0.102: v1(115.29,158.65) 115.23,158.65 114.85,158.26 U6539.U21
N34070855: length 1.4
  TOP w0.114: v1(118.48,146.99) 118.89,146.99 TP13417.1
  BOTTOM w0.102: v1(118.48,146.99) 118.5,146.96 U6539.BB12
