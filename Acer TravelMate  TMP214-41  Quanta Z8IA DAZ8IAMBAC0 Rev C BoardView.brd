# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R68490  10K_1%_2  [R0201]  91.87 104.42 90 top
R68491  1K_1%_2  [R0201]  126.94 143.35 90 bottom
R68492  100K_1%_2  [R0201]  91.1 104.42 90 top
R68493  60.4_1%_2  [R0201]  127.05 144.22 180 bottom
R68494  100K_1%_2  [R0201]  88.79 105.31 270 top
R68495  *0_5%_6  [R0603]  113.71 110.51 0 top
R68496  *Short_0603  [S0603]  115.62 108.35 180 top
R68497  *Short_0402  [S0402]  119.04 118.39 180 top
R68498  *1K_1%_2  [R0201]  123.74 128.88 270 top
R68499  *100K_1%_2  [R0201]  124.89 129.56 0 top
R68500  *Short_0402  [S0402]  106.09 109.62 180 top
R68501  *Short_0402  [S0402]  103.47 109.37 90 top
R68502  *Short_0201  [S0201]  100.5 109.24 90 top
R68503  *0_5%_4  [R0402]  104.31 111.27 180 top
R68504  *Short_0201  [S0201]  102.64 109.24 90 top
R68505  *Short_0201  [S0201]  116.89 115.21 270 top
R68506  *0_5%_2  [R0201]  115.21 115.16 180 top
R68507  *Short_0402  [S0402]  112.87 113.64 180 top
R68508  *0_5%_4  [R0402]  112.87 112.67 180 top
R68509  100K_1%_2  [R0201]  101.21 109.24 90 top
R68510  100K_1%_2  [R0201]  101.93 109.24 90 top
R68511  *Short_0805  [S0805]  102.53 109.5 270 bottom
R68513  100K_1%_2  [R0201]  91.36 128.29 90 top
R68514  *0_5%_2  [R0201]  87.93 124.02 180 top
R68515  14@10K_1%_2  [R0201]  126 117.24 270 top
R68516  15@10K_1%_2  [R0201]  126 116.23 270 top
R68517  CRT@10K_1%_2  [R0201]  122.35 117.24 270 top
R68518  CRT_N@10K_1%_2  [R0201]  122.35 116.23 270 top
R68519  NFC@10K_1%_2  [R0201]  120.82 117.24 270 top
R68520  NFC_N@10K_1%_2  [R0201]  120.82 116.23 270 top
R68521  FTPM@10K_1%_2  [R0201]  125.24 117.24 270 top
R68522  DTPM@10K_1%_2  [R0201]  125.24 116.23 270 top
R68524  *10K_1%_2  [R0201]  124.18 117.24 270 top
R68525  10K_1%_2  [R0201]  124.18 116.23 270 top
R68526  SM@10K_1%_2  [R0201]  123.44 117.24 270 top
R68527  SM_N@10K_1%_2  [R0201]  123.44 116.23 270 top
R68528  *10K_1%_2  [R0201]  121.58 117.24 270 top
R68529  10K_1%_2  [R0201]  121.58 116.23 270 top
R68530  LTE@10K_1%_2  [R0201]  118.21 118.13 270 bottom
R68531  LTE_N@10K_1%_2  [R0201]  118.84 116.74 270 bottom
R68536  *4.7K_1%_2  [R0201]  119.17 115.21 270 top
R68537  *4.7K_1%_2  [R0201]  108.96 111.02 270 bottom
R68538  *4.7K_1%_2  [R0201]  109.22 114.02 90 bottom
R68539  *4.7K_1%_2  [R0201]  122.47 114.83 0 top
R68540  *20K_1%_2  [R0201]  119.17 114.2 270 top
R68541  *20K_1%_2  [R0201]  108.96 110 270 bottom
R68542  *20K_1%_2  [R0201]  109.67 116.35 180 bottom
R68543  *20K_1%_2  [R0201]  123.49 114.83 0 top
R68544  *4.7K_1%_2  [R0201]  117.14 117.6 0 bottom
R68545  *4.7K_1%_2  [R0201]  119.55 116.74 90 bottom
R68546  *20K_1%_2  [R0201]  117.14 118.31 180 bottom
R68547  *20K_1%_2  [R0201]  118.92 118.13 90 bottom
R68550  *HUB@Short_0402  [S0402]  76.75 115.85 0 top
R68551  HUB@10K_1%_2  [R0201]  83.87 116.74 90 top
R68552  *HUB@10K_1%_2  [R0201]  76.68 112.32 180 top
R68553  *HUB@10K_1%_2  [R0201]  76.68 113.05 180 top
R68554  *HUB@10K_1%_2  [R0201]  78.33 117.47 90 top
R68556  HUB@10K_1%_2  [R0201]  75.86 114.96 180 top
R68557  HUB@10K_1%_2  [R0201]  80.56 116.79 90 top
R68558  *HUB@47K_1%_2  [R0201]  83.13 116.74 270 top
R68559  *HUB@Short_0402  [S0402]  81.55 117.12 270 top
R68560  HUB@100K_1%_2  [R0201]  76.68 113.76 0 top
R68561  HUB@680_5%_2  [R0201]  83.99 108.86 90 top
R68562  *HUB@Short_0603  [S0603]  85.01 107.59 0 top
R68563  *HUB@0_5%_4  [R0402]  85.52 108.86 0 top
R68564  *HUB@Short_0201  [S0201]  79.17 108.23 90 top
R68565  *HUB@Short_0201  [S0201]  79.93 108.23 90 top
R68567  TSN@10K_1%_2  [R0201]  75.61 188.87 0 top
R68568  debug@0_5%_4  [R0402]  203.37 97.56 90 top
R68570  debug@0_5%_4  [R0402]  170.73 111.78 180 top
R68571  *Short_0201  [S0201]  118.28 105.56 0 bottom
R68572  15_1%_2  [R0201]  120.06 105.31 180 bottom
R68573  *Short_0201  [S0201]  118.03 103.78 0 bottom
R68574  15_1%_2  [R0201]  120.57 102.13 90 bottom
R68575  *Short_0201  [S0201]  134.56 107.54 270 bottom
R68576  15_1%_2  [R0201]  133.27 106.45 0 bottom
R68577  *Short_0201  [S0201]  131.24 104.67 90 bottom
R68578  49.9_1%_2  [R0201]  132.13 105.43 0 bottom
R68579  *Short_0201  [S0201]  118.16 108.48 270 bottom
R68580  49.9_1%_2  [R0201]  118.16 107.46 270 bottom
R68581  *Short_0201  [S0201]  131.24 109.88 90 bottom
R68582  *Short_0201  [S0201]  132 109.88 270 bottom
R68583  15_1%_2  [R0201]  118.28 104.8 180 bottom
R68584  100_1%_2  [R0201]  120.06 104.29 180 bottom
R68585  15_1%_2  [R0201]  119.04 102.13 270 bottom
R68586  100_1%_2  [R0201]  119.81 102.13 90 bottom
R68587  15_1%_2  [R0201]  132 103.27 270 bottom
R68588  100_1%_2  [R0201]  133.78 105.56 180 bottom
R68589  *Short_0201  [S0201]  132.81 109.12 270 bottom
R68591  *1K_1%_2  [R0201]  132 104.42 90 bottom
R68592  *1K_1%_2  [R0201]  119.04 107.97 90 bottom
R68593  *Short_0201  [S0201]  108.12 109.62 90 top
R68594  2.2_5%_2  [R0201]  16.43 66.32 180 top
R68595  100_1%_2  [R0201]  26.84 61.74 90 top
R68596  2.2_5%_2  [R0201]  16.43 65.55 180 top
R68597  10K_1%_2  [R0201]  16.81 59.2 180 top
R68598  2.2_5%_2  [R0201]  16.43 64.74 180 top
R68599  2.2_5%_2  [R0201]  16.43 64.03 180 top
R68600  2.2_5%_2  [R0201]  16.43 60.98 180 top
R68601  2.2_5%_2  [R0201]  16.43 61.74 180 top
R68602  10K_1%_2  [R0201]  19.78 59.2 180 top
R68603  *10K_1%_2  [R0201]  18.79 59.2 180 top
R68604  2.2_5%_2  [R0201]  16.42 62.53 180 top
R68605  2.2_5%_2  [R0201]  16.42 63.25 180 top
R68606  *Short_0201  [S0201]  23.29 69.11 270 top
R68607  10K_1%_2  [R0201]  17.8 59.2 180 top
R68608  *Short_0201  [S0201]  22.52 69.11 270 top
R68609  *10K_1%_2  [R0201]  16.68 60.09 270 top
R68610  *1M_1%_2  [R0201]  24.18 68.98 180 top
R68611  *1M_1%_2  [R0201]  17.62 68.09 0 top
R68612  *1M_1%_2  [R0201]  16.94 69.24 0 top
R68613  10K_1%_2  [R0201]  15.92 60.09 270 top
R68614  *10K_1%_2  [R0201]  28.62 61.49 270 top
R68616  *10K_1%_2  [R0201]  20.77 59.2 180 top
R68617  *10K_1%_2  [R0201]  23.74 59.2 0 top
R68620  *10K_1%_2  [R0201]  21.76 59.2 0 top
R68621  10K_1%_2  [R0201]  27.1 60.73 0 top
R68622  10K_1%_2  [R0201]  23.79 59.33 270 bottom
R68623  10K_1%_2  [R0201]  29.51 60.22 0 top
R68624  10K_1%_2  [R0201]  22.02 60.86 180 bottom
R68625  *10K_1%_2  [R0201]  16.43 70.25 270 top
R68626  100K_1%_2  [R0201]  21 73.05 270 top
R68628  *0_5%_2  [R0201]  16.81 72.41 180 top
R68630  *Short_0201  [S0201]  16.81 71.65 180 top
R68631  *10K_1%_2  [R0201]  28.62 60.47 90 top
R68632  4.75K_0.5%_2  [R0201]  21.51 66.19 180 bottom
R68633  *Short_0402  [S0402]  15.92 67.21 270 bottom
R68634  10K_1%_2  [R0201]  32.18 62.76 0 top
R68635  0_5%_6  [R0603]  32.05 67.59 0 top
R68636  3.32K_1%_2  [R0201]  31.67 70.25 0 top
R68637  2.2K_5%_2  [R0201]  31.16 80.54 90 top
R68638  3.32K_1%_2  [R0201]  30.27 80.54 90 top
R68639  2.2K_5%_2  [R0201]  32.81 80.54 90 top
R68666  221K_1%_2  [R0201]  10.59 70.38 270 top
R68667  221K_1%_2  [R0201]  10.59 69.36 90 top
R68668  221K_1%_2  [R0201]  10.59 62.15 90 bottom
R68669  221K_1%_2  [R0201]  10.59 63.14 270 bottom
R68670  221K_1%_2  [R0201]  10.59 70.38 270 bottom
R68671  221K_1%_2  [R0201]  10.59 69.36 90 bottom
R68672  221K_1%_2  [R0201]  10.59 62.15 90 top
R68673  221K_1%_2  [R0201]  10.59 63.14 270 top
R68677  1M_1%_2  [R0201]  4.72 47.62 90 bottom
R68680  *470K_5%_2  [R0201]  3.98 43.58 270 bottom
R68681  57.6K_1%_2  [R0201]  5.89 53.74 180 bottom
R68683  *Short_0201  [S0201]  95.42 108.48 90 bottom
R68684  *100K_1%_2  [R0201]  95.42 107.34 270 bottom
R68685  *0_5%_2  [R0201]  99.11 107.59 90 bottom
R68686  *Short_0201  [S0201]  92.25 126.87 0 top
R68687  *Short_0603  [S0603]  27.94 38.93 0 bottom
R68690  *Short_0201  [S0201]  196.9 108.35 0 bottom
R68691  *Short_0201  [S0201]  196.01 107.34 270 bottom
R68692  *0_5%_2  [R0201]  195.91 108.35 270 bottom
R68693  *0_5%_2  [R0201]  195.24 107.34 270 bottom
R68694  *0_6/S  [S0603]  23.64 43.96 270 bottom
R68695  *1K_1%_2  [R0201]  20.87 55.01 0 bottom
R68696  *100K_1%_2  [R0201]  21.64 44.98 90 bottom
R68697  100K_1%_2  [R0201]  22.4 44.98 90 bottom
R68700  *1K_1%_2  [R0201]  20.87 54.25 180 bottom
R68711  4.7K_1%_2  [R0201]  22.27 46 180 bottom
R68712  *0_5%_4  [R0402]  20.87 56.28 270 bottom
R68713  *Short_0402  [S0402]  18.46 56.28 270 bottom
R68714  *Short_0402  [S0402]  19.43 56.28 270 bottom
R68715  *Short_0402  [S0402]  16.53 56.28 270 bottom
R68716  *Short_0402  [S0402]  17.5 56.28 270 bottom
R68718  *Short_0402  [S0402]  19.73 44.9 180 bottom
R68719  *0_5%_4  [R0402]  28.62 41.93 270 bottom
R68720  2.2K_5%_2  [R0201]  11.55 44.6 90 bottom
R68721  2.2K_5%_2  [R0201]  11.55 46.63 90 bottom
R68722  *Short_0402  [S0402]  20.26 43.61 0 bottom
R68723  *Short_0402  [S0402]  18.54 43.61 0 bottom
R68724  *Short_0402  [S0402]  16.71 43.2 270 bottom
R68725  *2.2K_5%_2  [R0201]  16.3 44.98 270 bottom
R68726  *2.2K_5%_2  [R0201]  17.32 44.98 270 bottom
R68727  *2.2K_5%_2  [R0201]  18.33 44.98 270 bottom
R68728  2.2K_5%_2  [R0201]  92.37 128.8 180 top
R68729  *0_5%_4  [R0402]  24.81 52.47 270 bottom
R68730  2.2K_5%_2  [R0201]  22.65 51.89 0 bottom
R68731  2.2K_5%_2  [R0201]  22.65 52.65 0 bottom
R68732  *0_5%_4  [R0402]  24.81 54.76 270 bottom
R68733  2.2K_5%_2  [R0201]  22.65 53.87 0 bottom
R68734  *0_5%_4  [R0402]  24.81 50.19 270 bottom
R68736  *0_5%_4  [R0402]  134.41 102 0 top
R68737  2.2K_5%_2  [R0201]  113.71 113.43 270 bottom
R68738  2.2K_5%_2  [R0201]  116 113.43 270 bottom
R68739  2.2K_5%_2  [R0201]  116.76 113.43 270 bottom
R68740  2.2K_5%_2  [R0201]  67.61 102.38 180 top
R68741  2.2K_5%_2  [R0201]  67.23 103.15 0 top
R68742  2.2K_5%_2  [R0201]  112.06 114.7 270 top
R68743  2.2K_5%_2  [R0201]  111.3 113.53 270 top
R68744  *SPIN_INT@2.2K_5%_2  [R0201]  92.25 127.58 180 top
R68745  *SPIN_INT@2.2K_5%_2  [R0201]  94.91 127.28 180 bottom
R68747  2.2K_5%_2  [R0201]  114.42 113.43 270 bottom
R68750  *Short_0201  [S0201]  146.1 95.02 0 top
R68751  **10K_1%_2  [R0201]  206.55 116.35 90 bottom
R68752  **10K_1%_2  [R0201]  205.79 116.35 90 bottom
R68755  **75K_1%_2  [R0201]  203.12 117.88 270 bottom
R68756  *0_5%_8  [R0805]  199.05 118.89 0 bottom
R68757  **100K_1%_2  [R0201]  203.12 115.34 90 bottom
R68758  *10K_1%_2  [R0201]  203.12 116.84 270 bottom
R68759  *0_5%_4  [R0402]  24.81 46.25 270 bottom
R68760  *0_5%_4  [R0402]  15.92 59.71 270 bottom
R68761  *Short_0402  [S0402]  24.81 48.03 270 bottom
R68764  *0_5%_4  [R0402]  172.66 111.6 180 top
R68765  *0_5%_4  [R0402]  150.16 107.92 90 top
R68769  *0_5%_4  [R0402]  174.04 122.2 90 top
R68771  *10K_1%_2  [R0201]  107.87 111.91 90 top
R68772  10K_1%_2  [R0201]  108.38 113.94 270 top
R68773  *10K_1%_2  [R0201]  109.27 114.96 270 top
R68774  10K_1%_2  [R0201]  109.27 113.94 270 top
R68775  SPIN@10K_1%_2  [R0201]  107.03 112.19 90 bottom
R68776  SPIN_N@10K_1%_2  [R0201]  107.89 112.65 0 bottom
R68777  SPIN@10K_1%_2  [R0201]  107.23 114.96 270 bottom
R68778  SPIN_N@10K_1%_2  [R0201]  107.23 113.94 270 bottom
R68779  EV@100K_1%_2  [R0201]  103.42 129.18 0 top
R68780  IV@1K_1%_2  [R0201]  103.42 127.78 0 top
R68789  *Short_0603  [S0603]  117.77 107.85 270 top
R68790  *TSN@Short_0603  [S0603]  72.31 187.86 90 top
R68791  *SM@Short_0603  [S0603]  226.49 97.3 270 top
R68792  SM@10K_1%_2  [R0201]  230.55 93.88 270 top
R68793  IR@10K_1%_2  [R0201]  108 111.88 0 bottom
R68794  IR_N@10K_1%_2  [R0201]  107.59 109.8 270 bottom
R68795  *EX-IO@Short_0603  [S0603]  134.54 126.39 180 bottom
R68796  *EX-IO@0_5%_4  [R0402]  136.85 118.56 90 bottom
R68799  EX-IO@10K_1%_2  [R0201]  140.63 120.8 0 bottom
R68802  *EX-IO@4.7K_1%_2  [R0201]  140.63 124.23 180 bottom
R68803  EX-IO@4.7K_1%_2  [R0201]  140.63 123.09 180 bottom
R68804  *EX-IO@4.7K_1%_2  [R0201]  140.63 121.97 180 bottom
R68806  EX-IO@4.7K_1%_2  [R0201]  139.49 124.25 0 bottom
R68807  *EX-IO@4.7K_1%_2  [R0201]  139.49 123.09 0 bottom
R68808  EX-IO@4.7K_1%_2  [R0201]  139.49 121.97 0 bottom
R68812  *Short_0805  [S0805]  128.32 118.01 270 bottom
R68813  *EX-IO@2.2K_5%_2  [R0201]  139.24 128.04 90 bottom
R68814  *EX-IO@2.2K_5%_2  [R0201]  135.17 129.56 180 bottom
R68815  *Short_0201  [S0201]  24.3 69.87 270 top
R68816  *Short_0201  [S0201]  25.06 69.87 270 top
R68828  *0_5%_2  [R0201]  204.39 108.73 270 top
R68829  *866_1%_4  [R0402]  208.38 115.72 180 top
R68830  *Short_0805  [S0805]  204.62 124.61 90 top
R68831  866_1%_2  [R0201]  208.45 114.7 0 top
R68832  *Short_0201  [S0201]  208.2 113.81 0 top
R68833  22_5%_8  [R0805]  202.48 124.61 90 top
R68834  *Short_0201  [S0201]  207.36 108.23 90 top
R68835  1M_1%_2  [R0201]  203.63 118.13 180 top
R68836  2M_1%_2  [R0201]  202.1 118.77 180 top
R68837  *debug2@0_5%_4  [R0402]  208.38 116.74 180 top
R68838  *0_5%_2  [R0201]  203.5 106.83 180 top
R68839  *0_5%_4  [R0402]  27.83 40.15 0 bottom
R68840  *debug2@47K_1%_2  [R0201]  170.73 139.85 90 top
R68841  *debug2@0_5%_2  [R0201]  169.08 136.45 270 top
R68842  *Short_0805  [S0805]  157.12 140.69 180 top
R68843  100K_1%_2  [R0201]  173.4 148.99 90 bottom
R68844  *Short_0402  [S0402]  170.61 146.2 180 top
R68845  100K_1%_2  [R0201]  172.64 150.52 270 top
R68846  *Short_0201  [S0201]  169.21 146.2 0 top
R68847  *22_5%_8  [R0805]  159.53 137.18 180 top
R68848  *Short_0201  [S0201]  167.43 148.64 0 top
R68849  *Short_0201  [S0201]  173.4 148.36 180 top
R68850  *Short_0201  [S0201]  166.9 149.77 0 top
R68851  100K_1%_2  [R0201]  167.89 149.37 180 top
R68852  *0_5%_2  [R0201]  173.4 149.12 180 top
R68853  *0_5%_4  [R0402]  167.05 142.26 0 top
R68854  *1M_1%_2  [R0201]  166.16 140.74 180 top
R68855  *2M_1%_2  [R0201]  166.16 139.98 0 top
R68856  *0_5%_2  [R0201]  169.84 146.2 0 bottom
R68857  *debug2@0_5%_4  [R0402]  210.49 114.32 270 top
R68858  P2@10K_1%_2  [R0201]  108.15 114.96 270 bottom
R68859  N1@10K_1%_2  [R0201]  108.15 113.94 270 bottom
R68864  *100K_1%_2  [R0201]  149.04 100.28 90 top
R68865  EX-IO@0_5%_4  [R0402]  136.95 126.46 90 bottom
R68866  EX-IO@0_5%_4  [R0402]  137.33 130.32 180 bottom
R68867  *EX-IO@0_5%_4  [R0402]  131.62 126.26 90 bottom
R68868  *0_5%_4  [R0402]  171.29 107.36 270 top
R68870  *0_5%_4  [R0402]  172 122.2 90 top
R68871  *Short_0402  [S0402]  149.14 107.92 90 top
R68872  *Short_0201  [S0201]  188.89 114.2 90 top
R68873  *Short_0201  [S0201]  186.1 114.2 90 top
R68874  *1M_1%_2  [R0201]  25.19 68.98 0 top
R68875  *10K_1%_2  [R0201]  29.51 59.46 0 top
R68876  10K_1%_2  [R0201]  29.51 61.74 180 top
R68877  *10K_1%_2  [R0201]  22.75 59.2 0 top
R68878  *Short_0201  [S0201]  25.06 58.2 0 bottom
R68879  *0_5%_4  [R0402]  24.43 67.08 0 bottom
R68880  *0_5%_6  [R0603]  32.05 69.03 0 top
R68881  *EX-IO@0_5%_4  [R0402]  132.63 126.26 90 bottom
R68883  *0_5%_4  [R0402]  172.92 115.36 0 top
R68884  *10K_1%_2  [R0201]  21 74.32 270 top
R68885  *10K_1%_2  [R0201]  14.45 56.66 0 bottom
R68887  *Short_0201  [S0201]  11.55 43.58 270 bottom
R68888  *Short_0201  [S0201]  11.55 45.62 270 bottom
R68893  *Short_0201  [S0201]  73.2 95.7 0 top
R68894  *Short_0201  [S0201]  73.58 92.35 180 top
R68895  *2.2K_5%_2  [R0201]  18.71 59.33 270 bottom
R68896  *2.2K_5%_2  [R0201]  19.48 59.2 270 bottom
R68897  *2.2K_5%_2  [R0201]  17.95 59.33 270 bottom
R68898  *2.2K_5%_2  [R0201]  20.24 59.2 270 bottom
R68899  *2.2K_5%_2  [R0201]  21 59.2 270 bottom
R68902  57.6K_1%_2  [R0201]  5.89 54.73 180 bottom
R68903  100K_1%_2  [R0201]  8.94 59.08 90 bottom
R68906  *0_4/S  [S0402]  22.4 134.13 180 top
R68907  *0_4/S  [S0402]  24.18 134.01 0 top
R68908  *Short_0201  [S0201]  112.57 118.64 270 top
R68909  *Short_0201  [S0201]  113.46 118.64 90 top
R68910  *0_5%_2  [R0201]  83.61 123.09 90 top
R68911  *0_5%_2  [R0201]  84.5 123.09 90 top
R68913  *Short_0201  [S0201]  88.82 123.85 270 top
R68914  *Short_0402  [S0402]  201.34 120.29 90 bottom
R68915  *0_5%_4  [R0402]  202.74 119.91 0 bottom
R68916  *Short_0402  [S0402]  210.48 118.39 90 bottom
R68917  *0_5%_4  [R0402]  211.88 118.01 0 bottom
R68918  100K_1%_2  [R0201]  110.66 109.62 90 top
R68919  *0_5%_4  [R0402]  96.95 104.16 180 bottom
R68920  *Short_0402  [S0402]  96.95 105.18 180 bottom
R68921  *Short_0201  [S0201]  82.72 99.59 90 top
R68924  10K_1%_2  [R0201]  28.37 162.96 0 top
R68925  *0_5%_4  [R0402]  24.76 162.33 270 top
R68927  *10K_1%_2  [R0201]  92.25 119.91 180 top
R68929  10K_1%_2  [R0201]  13.63 164.36 90 top
R68932  *0_5%_4  [R0402]  13.63 162.96 270 top
R68933  100K_1%_2  [R0201]  90.6 120.8 90 top
R68934  100K_1%_2  [R0201]  92.55 122.22 90 top
R68935  *100K_1%_2  [R0201]  111.81 117.24 90 top
R68936  100K_1%_2  [R0201]  119.3 115.08 90 bottom
R68937  100K_1%_2  [R0201]  121.23 120.19 90 top
R68938  *100K_1%_2  [R0201]  105.58 115.97 270 bottom
R68939  *100K_1%_2  [R0201]  106.34 115.97 90 bottom
R68940  10K_1%_2  [R0201]  86.79 170.84 270 top
R68941  *Short_0201  [S0201]  202.23 118.39 270 bottom
R68942  *0_5%_2  [R0201]  201.47 118.39 270 bottom
R68943  *0_2/S  [S0201]  196.26 113.69 0 bottom
R68944  *0_2/S  [S0201]  194.61 113.69 0 bottom
R68945  *0_2/S  [S0201]  196.26 112.67 0 bottom
R68946  *0_5%_2  [R0201]  194.48 112.67 180 bottom
R68947  *0_5%_2  [R0201]  196.26 111.66 0 bottom
R68948  *0_5%_2  [R0201]  194.61 111.66 0 bottom
R68949  *debug2@0_5%_2  [R0201]  168.32 136.45 270 top
R68950  *0_5%_2  [R0201]  205.15 107.08 270 top
R68951  *0_5%_2  [R0201]  204.39 107.08 270 top
R68952  *Short_0201  [S0201]  205.91 107.08 90 top
R68953  *0_5%_2  [R0201]  206.8 107.08 270 top
R68954  *Short_0201  [S0201]  86.28 119.53 90 top
R68955  *2M_1%_2  [R0201]  11.86 71.91 90 bottom
R68956  *2M_1%_2  [R0201]  12.24 67.98 270 bottom
R68957  *Short_0201  [S0201]  108.38 114.96 270 top
R68968  10K_1%_2  [R0201]  28.75 44.85 90 bottom
R68969  *Short_0402  [S0402]  29.64 40.79 90 bottom
R68970  *0_5%_4  [R0402]  13.46 55.27 270 bottom
R68971  *Short_0402  [S0402]  30.02 42.19 180 bottom
R68972  *Short_0402  [S0402]  27.22 42.57 180 bottom
R68974  *Short_0402  [S0402]  13.81 43.2 270 bottom
R68975  0_5%_4  [R0402]  15.29 43.58 0 bottom
R68976  1K_1%_2  [R0201]  28.87 43.96 0 bottom
R68982  *0_5%_2  [R0201]  12.36 41.93 270 bottom
R68984  *100K_1%_2  [R0201]  12.36 42.95 270 bottom
R68985  *SPIN@Short_0603  [S0603]  80.51 97.81 180 top
R68986  *SPIN@0_5%_6  [R0603]  80.51 99.34 180 top
R68987  *SPIN_EXT@0_5%_6  [R0603]  154.73 209.32 0 top
R68988  *SPIN_EXT@Short_0603  [S0603]  154.73 207.79 180 top
R68989  *SPIN_EXT@100K_1%_2  [R0201]  154.86 217.07 0 top
R68990  *SPIN_EXT@100K_1%_2  [R0201]  158.16 216.05 90 top
R68992  SPIN_EXT@4.7K_1%_2  [R0201]  149.91 212.49 90 bottom
R68993  SPIN_EXT@4.7K_1%_2  [R0201]  149.91 211.48 270 bottom
R68994  SPIN_EXT@2K_1%_2  [R0201]  156.13 217.07 180 top
R68995  SPIN_EXT@2K_1%_2  [R0201]  145.97 216.43 180 top
R68998  *SPIN_INT@0_5%_4  [R0402]  143.05 212.37 270 top
R69002  *HUB@10K_1%_2  [R0201]  79.85 116.79 90 top
R69003  *HUB@10K_1%_2  [R0201]  77.11 114.75 90 top
R69004  54.9K_1%_2  [R0201]  7.16 53.74 90 bottom
R69005  *100K_1%_2  [R0201]  3.98 52.35 180 bottom
R69006  *Short_0402  [S0402]  3.55 47.37 270 bottom
R69008  1M_1%_2  [R0201]  3.98 49.3 180 bottom
R69009  1M_1%_2  [R0201]  3.98 50.03 180 bottom
R69010  10K_1%_2  [R0201]  3.98 50.85 0 bottom
R69011  *Short_0402  [S0402]  22.65 49.68 0 bottom
R69012  EX-IO@2.2K_5%_2  [R0201]  137.94 119.1 90 bottom
R69014  *0_5%_2  [R0201]  147.09 102.94 90 top
R69016  *SPIN_INT@4.7K_1%_2  [R0201]  124.63 114.2 90 bottom
R69017  *SPIN_INT@4.7K_1%_2  [R0201]  124.63 112.93 270 bottom
R69018  8111K@0_5%_6  [R0603]  14.9 158.14 180 bottom
R69019  4.7K_1%_2  [R0201]  23.03 136.17 90 top
R69020  *0_4/S  [S0402]  23.79 132.23 270 top
R69021  *0_4/S  [S0402]  22.78 132.23 270 top
R69022  *0_5%_2  [R0201]  56.38 148.49 270 top
R69023  *0_5%_2  [R0201]  44.37 147.98 270 top
R69024  240_1%_2  [R0201]  56.94 138.07 90 top
R69025  *10K_1%_2  [R0201]  53.41 142.54 0 top
R69026  *10K_1%_2  [R0201]  94.03 180.18 270 top
R69027  *10K_1%_2  [R0201]  89.66 177.7 90 bottom
R69028  *Short_0201  [S0201]  109.8 116.1 270 top
R69029  *Short_0201  [S0201]  183.94 112.16 90 top
R69030  *0_5%_2  [R0201]  189.43 122.42 90 top
R69031  *0_5%_2  [R0201]  191.36 121.69 270 top
R69032  *0_5%_2  [R0201]  189.68 120.32 180 top
R69033  *0_5%_2  [R0201]  116.5 112.54 90 top
R69034  10K_1%_2  [R0201]  116.12 113.56 90 top
R69035  *0_5%_4  [R0402]  133.52 123.59 270 top
R69042  *HDD_MS@100K_1%_2  [R0201]  229.03 127.66 180 top
R69043  *HDD_MS@100K_1%_2  [R0201]  232.07 126.51 0 top
R69044  **HDD_MS@10K_1%_2  [R0201]  230.3 127.66 180 top
R69045  *HDD_MS@0_5%_4  [R0402]  234.06 118.64 90 top
R69046  *HDD_MS@0_5%_4  [R0402]  218.99 106.58 180 top
R69047  *HDD_MS@100K_1%_2  [R0201]  216.2 105.43 180 top
R69048  **HDD_MS@10K_1%_2  [R0201]  211.25 104.8 270 top
R69049  *HDD_MS@100K_1%_2  [R0201]  211.25 103.65 270 top
R69050  *IR@Short_0603  [S0603]  34.39 191.87 0 bottom
R69051  *CRT@Short_0402  [S0402]  28.49 148.36 0 top
R69054  *Short_0603  [S0603]  132.51 99.77 180 top
R69055  *Short_0603  [S0603]  218.84 123.01 270 bottom
R69056  *Short_0603  [S0603]  12.62 44.85 270 bottom
R69057  *Short_0603  [S0603]  10.38 48.28 90 bottom
R69058  *0_5%_4  [R0402]  126.79 171.85 180 bottom
R69059  33_1%_2  [R0201]  25.06 31.39 0 bottom
R69062  *33_1%_2  [R0201]  53.51 191.92 270 bottom
R69063  *33_1%_2  [R0201]  53.51 190.9 90 bottom
R69064  *Short_0201  [S0201]  96.95 119.15 0 bottom
R69065  10K_1%_2  [R0201]  226.36 126.26 270 top
R69066  ViKi@0_5%_6  [R0603]  42.31 94.38 270 top
R69067  ViKi@0_5%_6  [R0603]  39.36 94.38 270 top
R69068  ViKi@0_5%_6  [R0603]  48.94 94.48 270 top
R69069  ViKi@0_5%_6  [R0603]  45.28 94.4 270 top
R69070  ViKi@0_5%_4  [R0402]  225.22 122.07 0 top
R69071  ViKi@0_5%_4  [R0402]  225.22 121.05 0 top
R69072  HUB@10K_1%_2  [R0201]  78.86 116.56 180 top
R69073  *22_5%_8  [R0805]  56.26 174.14 180 top
R69075  *Short_0402  [S0402]  12.62 38.63 180 bottom
R69076  *0_5%_2  [R0201]  30.78 28.47 90 bottom
R69077  *Short_0201  [S0201]  30.78 27.45 270 bottom
R69078  EV@10K_1%_2  [R0201]  111.83 186.33 180 bottom
R69079  *0_5%_2  [R0201]  93.64 128.29 180 bottom
R69080  *EX-IO@0_5%_4  [R0402]  136.67 105.18 270 top
R69081  0_5%_4  [R0402]  21.25 57.68 180 bottom
R69082  *SPIN_INT@0_5%_4  [R0402]  51.61 192.94 0 bottom
R69083  *0_5%_4  [R0402]  150.34 113.69 180 top
R69084  *Short_0402  [S0402]  152.7 112.8 180 top
R69085  *0_5%_4  [R0402]  170.3 106.73 90 top
R69086  *0_5%_2  [R0201]  156.61 113.38 180 top
R69087  *0_5%_2  [R0201]  155.57 114.4 0 top
R69088  *0_5%_2  [R0201]  169.08 110.18 270 top
R69089  *0_5%_2  [R0201]  149.52 102.56 180 top
R69090  *0_5%_2  [R0201]  148.51 101.98 180 top
R69091  *4.7K_1%_2  [R0201]  109.01 111.88 180 bottom
R69092  *SSD_MS@0_5%_4  [R0402]  23.67 78.13 180 top
R69093  *SSD_MS@100K_1%_2  [R0201]  17.19 78.89 90 top
R69094  **SSD_MS@10K_1%_2  [R0201]  26.72 82.19 180 top
R69096  *SSD_MS@100K_1%_2  [R0201]  26.72 83.72 0 top
R69097  *Short_0201  [S0201]  22.91 75.71 270 top
R69098  *0_5%_2  [R0201]  17.06 69.24 180 bottom
R69099  *0_5%_2  [R0201]  21.51 80.79 90 top
R69100  *0_5%_2  [R0201]  26.72 82.95 180 top
R69101  *LTE@Short_0402  [S0402]  135.17 103.15 180 top
R69102  *LTE@Short_0402  [S0402]  135.17 105.79 180 top
R69103  *Short_0402  [S0402]  156.94 114.8 0 top
R69104  EV@10K_1%_2  [R0201]  121.74 117.34 180 bottom
R69105  *1M_5%_6  [R0603]  61.21 181.38 90 top
R69106  *1M_5%_6  [R0603]  60.6 177.54 0 top
R69107  *Short_0201  [S0201]  171.34 105.91 90 top
R69109  *EV@Short_0201  [S0201]  112.57 178.84 90 top
R69110  *EV@0_5%_2  [R0201]  109.7 179.52 90 bottom
R69111  *EV@0_5%_2  [R0201]  107.56 173.91 90 bottom
R69112  *EV@0_5%_2  [R0201]  111.5 175.69 180 bottom
RG67  *EV@10K_1%_2  [R0201]  114.88 176.37 270 bottom
RG77  EV@10K_1%_2  [R0201]  111.45 177.47 180 bottom
RG79  *EV@10K_1%_2  [R0201]  113.81 178.43 270 bottom
S1  -  [CLIP-39X35-100X18-3P]  93.33 105.9 270 bottom
S2  -  [CLIP-39X35-100X18-3P]  21.2 99.1 180 bottom
SW2  *NDT016-G1A-KKKT  [SW-NDT016-G1A-KKKT-4P]  14.12 152.24 180 bottom
SW4  TME-532W-Q-T/R_439  [SW-TME-532-V-6P]  65.8 183 270 bottom
SW5  debug@T3AL-23S-Q-T/R  [SW-T3AL-23-Q-TR-4P]  231.87 112.45 180 bottom
T1  *PAD  [TP2050]  58.77 128.8 0 top
T2  *PAD  [TP2050]  61.44 128.89 0 top
T3  *PAD  [TP2675]  29.84 122.91 180 top
TP2  *PAD  [TP2650]  34.08 157.12 180 top
TP65  *PAD  [TP2050]  113.96 181.45 0 top
TP66  *PAD  [TP2050]  128.16 186.08 0 top
TP67  *PAD  [TP2050]  132.18 177.44 0 top
TP68  *PAD  [TP2050]  129.66 185.37 0 top
TP69  *PAD  [TP2050]  131.31 178.43 0 top
TP70  *PAD  [TP2050]  116.41 202.89 180 bottom
TP71  *PAD  [TP2050]  116.38 199.34 180 bottom
TP72  *PAD  [TP2050]  116.38 200.63 180 bottom
TP73  *PAD  [TP2050]  116.43 204.2 180 bottom
TP96  *PAD  [TP2050]  24.15 63.01 0 bottom
TP97  *PAD  [TP2050]  27.48 57.81 0 bottom
TP98  *PAD  [TP2050]  25.06 60.22 0 bottom
TP99  *PAD  [TP2050]  33 63.46 0 bottom
TP100  *PAD  [TP2050]  32.94 61.74 0 bottom
TP101  *PAD  [TP2050]  32.94 59.08 0 bottom
TP102  *PAD  [TP2050]  29.99 57.38 0 bottom
TP103  *PAD  [TP2050]  28.87 56.54 0 bottom
TP104  *PAD  [TP2050]  28.75 57.81 0 bottom
TP1310  *TP  [TP2675]  143.3 215.54 0 top
TP2092  *PAD  [TP2050]  31.58 71.16 180 bottom
TP7000  *  [TP2050]  168.19 135.33 180 bottom
TP9000  *TP  [TP2050]  97.33 198.27 0 top
TP9023  *PAD  [TP2050]  23.87 37.59 90 bottom
TP9029  *PAD  [TP2050]  187.62 124.23 0 top
TP9030  *PAD  [TP2050]  116.38 198.04 180 bottom
TP9031  *PAD  [TP2050]  117.11 196.22 180 bottom
TP9032  *PAD  [TP2050]  117.09 194.91 180 bottom
TP9033  *PAD  [TP2050]  117.05 193.58 180 bottom
TP9046  *PAD  [TP2050]  30.14 157.38 180 top
TP9063  *PAD  [TP2650]  10.18 152.09 180 bottom
TP9064  *PAD  [TP2650]  30.65 156.11 180 top
TP9066  *TP  [TP2675]  157.83 211.35 0 top
TP9067  *TP  [TP2675]  152.06 213.64 0 top
TP9068  *TP  [TP2675]  156.64 209.62 0 top
TP9069  *TP  [TP2675]  159.56 212.24 0 top
TP9070  *TP  [TP2675]  157.53 207.92 0 top
TP9071  *TP  [TP2675]  152.45 211.22 0 top
TP9072  *TP  [TP2675]  159.43 207.92 0 top
TP9073  *TP  [TP2675]  153.21 217.07 0 top
TP9074  *TP  [TP2675]  161.34 207.92 0 top
TP13152  *PAD  [TP2050]  16.43 170.46 0 top
TP13153  *PAD  [TP2050]  15.92 173.25 0 top
TP13154  *PAD  [TP2050]  15.16 171.6 0 top
TP13155  *PAD  [TP2050]  14.9 167.28 0 top
TP13158  *PAD  [TP2050]  15.62 166.14 180 bottom
TP13159  *PAD  [TP2050]  16.09 163.73 0 top
TP13160  *PAD  [TP2050]  16.07 165.01 0 top
TP13161  *PAD  [TP2050]  16.14 162.26 0 top
TP13162  *PAD  [TP2050]  14.9 166.01 0 top
TP13163  *PAD  [TP2050]  57.96 92.73 0 top
TP13164  *PAD  [TP2050]  65.7 97.3 0 top
TP13169  *PAD  [TP2050]  107.87 182.27 180 bottom
TP13179  *PAD  [TP2050]  62.28 191.28 180 bottom
TP13180  *PAD  [TP2050]  165.13 111.91 180 bottom
TP13181  *PAD  [TP2050]  166.4 111.91 180 bottom
TP13238  *PAD  [TP2050]  110.64 116.38 0 top
TP13239  *PAD  [TP2050]  111.25 118.87 0 top
TP13240  *PAD  [TP2050]  93.26 123.85 180 bottom
TP13241  *PAD  [TP2050]  128.16 139.19 90 bottom
TP13242  *PAD  [TP2050]  124 162.33 0 top
TP13243  *PAD  [TP2050]  119.86 169.24 180 bottom
TP13244  *PAD  [TP2050]  117.57 170.84 180 bottom
TP13245  *PAD  [TP2050]  118.16 169.39 180 bottom
TP13246  *PAD  [TP2050]  121.99 171.6 180 bottom
TP13247  *PAD  [TP2050]  120.7 171.6 180 bottom
TP13249  *PAD  [TP2050]  119.07 171.6 180 bottom
TP13250  *PAD  [TP2050]  119.1 170.25 180 bottom
TP13251  *PAD  [TP2050]  115.01 120.06 0 top
TP13252  *PAD  [TP2050]  114.19 121.33 0 top
TP13253  *PAD  [TP2050]  126.03 169.31 180 bottom
TP13254  *PAD  [TP2050]  124.76 169.31 180 bottom
TP13255  *PAD  [TP2050]  95.42 119.15 180 bottom
TP13256  *PAD  [TP2050]  93.39 165 180 bottom
TP13257  *PAD  [TP2050]  94.66 123.85 180 bottom
TP13258  *PAD  [TP2050]  93.39 166.27 180 bottom
TP13259  *PAD  [TP2050]  106.57 131.98 0 top
TP13260  *PAD  [TP2050]  94.41 118.39 180 bottom
TP13261  *PAD  [TP2050]  106.22 130.71 0 top
TP13262  *PAD  [TP2050]  108.94 116.63 0 top
TP13263  *PAD  [TP2050]  125.52 117.24 180 bottom
TP13264  *PAD  [TP2050]  125.52 115.97 180 bottom
TP13265  *PAD  [TP2050]  121.31 169.34 180 bottom
TP13266  *PAD  [TP2050]  122.12 170.33 180 bottom
TP13267  *PAD  [TP2050]  128.57 120.29 180 bottom
TP13268  *PAD  [TP2050]  131.36 155.34 0 top
TP13269  *PAD  [TP2050]  129.84 120.04 180 bottom
TP13270  *PAD  [TP2050]  126.79 116.1 180 bottom
TP13271  *PAD  [TP2050]  126.79 117.37 180 bottom
TP13272  *PAD  [TP2050]  127.3 170.71 180 bottom
TP13273  *PAD  [TP2050]  127.3 169.31 180 bottom
TP13274  *PAD  [TP2050]  131.24 120.93 180 bottom
TP13275  *PAD  [TP2050]  129.71 121.31 180 bottom
TP13276  *PAD  [TP2050]  134.89 152.37 0 top
TP13277  *PAD  [TP2050]  134.54 151.13 0 top
TP13278  *PAD  [TP2050]  93.21 118.92 180 bottom
TP13279  *PAD  [TP2050]  132.56 152.73 0 top
TP13280  *PAD  [TP2050]  124.15 117.37 180 bottom
TP13281  *PAD  [TP2050]  133.4 151.76 0 top
TP13282  *PAD  [TP2050]  127.1 150.14 180 bottom
TP13283  *PAD  [TP2050]  93.11 115.59 180 bottom
TP13284  *PAD  [TP2050]  93.11 116.86 180 bottom
TP13285  *PAD  [TP2050]  121.71 127.91 270 top
TP13286  *PAD  [TP2050]  123.49 172.36 180 bottom
TP13290  *PAD  [TP2050]  113.71 117.24 180 bottom
TP13294  *PAD  [TP2050]  119.83 149.65 0 top
TP13303  *PAD  [TP2050]  77.54 111.22 0 top
TP13304  *PAD  [TP2050]  76.27 111.27 0 top
TP13311  *PAD  [TP2675]  131.97 108.89 180 bottom
TP13312  *PAD  [TP2675]  118.82 106.45 180 bottom
TP13313  *PAD  [TP2675]  120.95 99.97 180 bottom
TP13314  *PAD  [TP2675]  133.4 107.59 180 bottom
TP13315  *PAD  [TP2675]  131.95 106.32 180 bottom
TP13316  *PAD  [TP2675]  119.93 108.02 180 bottom
TP13340  *PAD  [TP2050]  27.35 62.89 90 top
TP13341  *PAD  [TP2050]  23.67 60.47 90 bottom
TP13342  *PAD  [TP2050]  31.29 60.98 90 top
TP13343  *PAD  [TP2050]  21.99 61.69 270 bottom
TP13344  *PAD  [TP2050]  15.51 66.9 90 top
TP13345  *PAD  [TP2050]  32.68 71.14 180 top
TP13346  *PAD  [TP2050]  31.41 71.14 90 top
TP13347  *PAD  [TP2050]  30.27 79.65 90 top
TP13348  *PAD  [TP2050]  28.87 71.14 90 top
TP13349  *PAD  [TP2050]  31.54 79.65 90 top
TP13350  *PAD  [TP2050]  32.81 79.65 90 top
TP13351  *PAD  [TP2050]  30.14 71.14 90 top
TP13352  *PAD  [TP2050]  123.36 124.89 0 top
TP13353  *PAD  [TP2050]  124.25 116.07 180 bottom
TP13354  *PAD  [TP2050]  193.72 106.32 180 bottom
TP13360  *PAD  [TP2050]  14.65 54.38 270 bottom
TP13361  *PAD  [TP2050]  9.95 50.19 270 bottom
TP13362  *PAD  [TP2050]  20.62 46.76 270 bottom
TP13363  *PAD  [TP2050]  23.92 56.41 270 bottom
TP13364  *PAD  [TP2050]  21.38 50.19 270 bottom
TP13365  *PAD  [TP2050]  120.24 125.78 0 top
TP13366  *PAD  [TP2050]  91.92 123.21 0 top
TP13367  *PAD  [TP2050]  121.53 123.82 0 top
TP13368  *PAD  [TP2050]  111.04 117.6 0 top
TP13369  *PAD  [TP2050]  110.33 115.47 180 bottom
TP13370  *PAD  [TP2050]  109.98 117.32 180 bottom
TP13371  *PAD  [TP2050]  116.63 115.34 180 bottom
TP13372  *PAD  [TP2050]  116.25 118.26 180 bottom
TP13375  *PAD  [TP2050]  25.7 71.02 180 bottom
TP13376  *PAD  [TP2050]  18.08 83.21 180 bottom
TP13384  *TP  [TP2050]  39.67 98.96 0 top
TP13391  *PAD  [TP2050]  120.65 122.68 0 top
TP13392  *PAD  [TP2050]  123.31 126.84 0 top
TP13393  *PAD  [TP2050]  112.39 119.78 0 top
TP13394  *PAD  [TP2050]  128.57 142.26 180 bottom
TP13395  *PAD  [TP2050]  127.81 143.41 180 bottom
TP13396  *PAD  [TP2050]  127.17 136.83 180 bottom
TP13397  *PAD  [TP2050]  128.44 136.72 180 bottom
TP13398  *PAD  [TP2050]  107.49 115.08 0 top
TP13399  *PAD  [TP2050]  114.6 118.26 0 bottom
TP13400  *PAD  [TP2050]  115.49 122.7 180 top
TP13401  *PAD  [TP2050]  121.81 122.07 0 top
TP13402  *PAD  [TP2050]  120.44 116.48 180 bottom
TP13403  *PAD  [TP2050]  117.65 122.58 0 top
TP13407  *PAD  [TP2050]  20.49 53.49 180 bottom
TP13408  *PAD  [TP2050]  19.48 54.89 180 bottom
TP13410  *PAD  [TP2050]  123.74 170.08 180 bottom
TP13411  *PAD  [TP2050]  119.17 145.31 0 top
TP13412  *PAD  [TP2050]  116.25 151.91 0 top
TP13413  *PAD  [TP2050]  115.74 153.18 0 top
TP13414  *PAD  [TP2050]  109.09 158.52 0 top
TP13415  *PAD  [TP2050]  106.6 137.82 0 top
TP13416  *PAD  [TP2050]  114.09 154.71 0 top
TP13417  *PAD  [TP2050]  119.17 146.71 0 top
TP13418  *PAD  [TP2050]  107.61 157.38 0 top
TP13419  *PAD  [TP2050]  119.17 148.1 0 top
TP13420  *PAD  [TP2050]  107.72 156.11 0 top
TP13421  *PAD  [TP2050]  108.38 159.66 0 top
TP13422  *PAD  [TP2050]  127.68 122.07 180 bottom
TP13423  *PAD  [TP2050]  104.72 127.58 0 top
TP13424  *PAD  [TP2050]  109.77 117.65 0 top
TP13425  *PAD  [TP2050]  123.11 119.53 0 top
TP13426  *PAD  [TP2050]  123.92 130.17 0 top
TP13427  *PAD  [TP2050]  124.18 125.9 0 top
TP13428  *PAD  [TP2050]  125.14 122.07 0 top
TP13429  *PAD  [TP2050]  108.71 130.97 0 top
U2  G781P8  [MSOP8-4_9-65-G547]  90.09 186.53 270 bottom
U8  EV@N17S-G1-A1  [BGA595-NVIDIA-N13P-GV2-S-A2]  131.02 193.15 90 bottom
U9  EV@NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  107.74 185.19 180 bottom
U11  EV@NL17SZ32DFT2G  [SOT353-2_1-65-5P]  128.77 210.72 180 bottom
U14  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  19.45 96.97 180 top
U15  G524B2T11U  [SOT23-5-2_8-95-5P-G708]  19.91 93.67 180 bottom
U18  G524B2T11U  [SOT23-5-2_8-95-5P-G708]  217.85 107.59 270 bottom
U19  APL3512ABI-TRG  [SOT23-5-2_8-95-5P-G708]  74.85 194.97 0 top
U20  ALC255-CG  [QFN48-6X6-4-49P-ALC280]  20.11 32.41 270 bottom
U25  XX@Transformer  [TRF-N1010G-25P]  33 184 180 bottom
U33  NPCT750AABYX  [QFN32-5X5-5-33P-0_85H]  88.19 98.07 90 top
U35  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  188.89 116.61 270 top
U36  *NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  186.35 116.61 270 top
U37  IT5571E-128/DX  [LQFP128-16X16-4-1_6H]  159.66 103.34 270 top
U40  RTS5170-GRT  [QFN24-4X4-5-25P-ALC5629]  29.51 61.24 0 bottom
U42  HDD@SN75LVCP601RTJR  [PWQFN20-4X4-5-26P-0_8H]  229.92 115.72 180 top
U67  CRT@RTD2166-CGT  [QFN32-4X4-4-33P-0_9H]  30.78 152.68 90 top
U6509  SM@AU9560B62-GBS-GR  [SSOP28-7_8-65-2H]  217.47 95.91 90 top
U6515  SPIN@BMA253  [LGA12-2X2-5-1H]  141.4 215.16 0 top
U6516  SPIN_EXT@IT8353VG-128/BX  [BGA25-ITE-IT8353VG]  155.11 214.14 0 top
U6517  G781-1P8  [MSOP8-4_9-65]  197.66 124.86 270 bottom
U6521  XX@I219_8111K  [QFN48-6X6-4-49P-ALC280]  20.49 166.01 90 top
U6525  SPIN@HGDEDM013A  [SENSOR-1_3X0_9-5-4P]  139.2 211.7 180 top
U6530  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  18.32 91.62 90 top
U6531  AZ1045-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  19.27 107.26 90 top
U6537  XX@PS8209_8409  [QFN48-6X6-4-49P-PS8409]  25.7 125.75 180 top
U6539  TGL_U_IP_EXT/BGA  [BGA1449-INTEL-TIGERL-U]  112.05 143.42 270 bottom
U6544  HUB@GL850G-OHY50  [QFN28-5X5-5-29P-GL850G]  81.33 112.67 0 top
U6546  XX@vpro_32M/non-vpro_16M  [SOIC8-7_9-1_27-2_16H]  125.82 106.96 270 bottom
U6547  *50960-0084N-001  [50960-0084N-001-8P-SOCKET]  125.92 106.96 90 bottom
U6548  *W25Q64FVSSIQ  [50951-0084N-001-8P-SOCKET]  125.77 104.96 270 bottom
U6549  JHL8040R QURW  [BGA105-INTEL-DELTABRIDGE-0_5S]  20.64 63.88 90 top
U6550  TPS22924CYZPR  [BGA6-TEXAS-CD3271-6P]  31.06 64.92 270 top
U6551  W25Q80DVSNIG  [SOIC8-6-1_27-PM25LV010A]  30.91 75.46 180 top
U6553  DPS1113FIA-13  [QFN17-4X4-5-14P]  7.03 50.7 180 bottom
U6554  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  97.38 107.72 90 bottom
U6555  CYPD5126-40LQXIT  [QFN40-6X6-5-41P-0_6H]  16.56 50.06 270 bottom
U6556  EX-IO@IT8013FN/CX  [QFN20-4X4-5-21P-IT8013FN]  135.94 122.45 270 bottom
U6557  *M74VHC1GT08DFT2G  [SC70-2_1-65-5P]  205.15 111.4 270 top
U6558  74AUP1G32SE-7  [SC70-2_1-65-5P]  207.44 111.4 270 top
U6559  *74AUP1G32SE-7  [SC70-2_1-65-5P]  209.72 111.4 270 top
U6560  *debug2@M74VHC1GT08DFT2G  [SC70-2_1-65-5P]  169.08 138.96 270 top
U6561  74AUP1G32SE-7  [SC70-2_1-65-5P]  170.48 147.98 0 top
U6562  *74AUP1G32SE-7  [SC70-2_1-65-5P]  169.21 143.66 90 top
U6563  *74AUP1G32SE-7  [SC70-2_1-65-5P]  169.21 143.66 270 bottom
U6564  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  26.46 44.35 0 bottom
U6565  *M74VHC1GT08DFT2G  [SC70-2_1-65-5P]  26.08 77.87 90 top
VC2  TVM0G5R5M220R_22p  [R0402]  16.52 133.83 0 bottom
VRAM1  EV@K4G80325FB-HC28_GDDR5_170P  [BGA170-HYNIX-H5GQ1H24MJR]  159.4 178.02 180 bottom
VRAM2  EV@K4G80325FB-HC28_GDDR5_170P  [BGA170-HYNIX-H5GQ1H24MJR]  159.4 200.42 0 bottom
Y3  EV@27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7-0_8H]  126.66 175.79 0 bottom
Y4  25MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7]  32.1 169.57 90 top
Y5  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-SMT]  104.64 114.4 0 bottom
Y6  38.4MHZ/20ppm  [XTL-2_05X1_65-1_4X1_1-0_6H]  130.44 123.4 270 bottom
Y7  HUB@12MHz  [XTL-3_2X2_5-2_2X1_8-4P]  88.23 111.86 0 top
Y8  25MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7]  19.74 70.17 180 top

## Library data of the parts
C202 C203 C212 C249-C280 C347-C360 C362-C384 C386-C389 C391-C403 C406-C433 C438-C462 C471-C506 C508-C513 C515-C524 C526-C533 C536 C537 C542 C545-C548 C550-C562 C566 C567 C595 C613 C614 C616 C631-C636 C641 C642 C645 C646 C695-C699 C706-C709 C711 C713-C733 C736 C770-C772 C785 C786 C788-C795 C800-C802 C804 C841 C842 C890 C900 C1189 C1190 C1211 C1214 C1217 C1643-C1653 C2609 C2616 C6554-C6557 C6565 C6569 C6570 C6573-C6575 C6577 C6578 C6586-C6589 C6594-C6602 C6607 C6615 C20000 C20003 C20008-C20023 C20039-C20051 C20053 C20130-C20134 C96247-C96249 C96265-C96269 C96271 C96300-C96313 C96319 C96320 C96343 C96344 C96545-C96572 C96574 C96649 C96652 C96701-C96711 C96713 C96721 C96725 C96730 C96737 C96766 C96769 C96770 C96773 C96774 C96788 C96789 C96791 C96792 C96794 C96796 C96798-C96815 C96823 C96828 C96851-C96859 C96870-C96873 C96876 C96879-C96887 C96891-C96893 C96895 C96901 C96903 C96905 C96907 C96909-C96913 C96918-C96924 C96929 C96930 EC5 EC6 EC11 PC1-PC12 PC15-PC19 PC25 PC35-PC37 PC51 PC73 PC164-PC168 PC170 PC172 PC229 PC242 PC551 PC561-PC563 PC571 PC572 PC574 PC581 PC756 PC5000-PC5004 PC5007 PC5009 PC5013 PC5014 PC5023 PC6000-PC6059 PC6228-PC6231 PC7001-PC7028 PC7033 PC7038-PC7044 PC7046-PC7052 PC7055 PC7056 PC7058-PC7069 PC8000-PC8003 PC8005-PC8007 PC8009 PC9000-PC9006 PC9008 PC9009 PC9012-PC9020 PC9022-PC9030 PC9053-PC9060 PC9062-PC9069 PC9071-PC9091 PC9097-PC9099 VC2 = CAP_NON-POL_BGM
C385 PC7000 PC7029 PC7030 PC9007 PC9010 PC9011 PC9021 = CAP_POL_BGM
C463 C464 C543 C544 C563-C565 C568 C569 C572-C578 C580 C581 C583-C594 C596-C599 C601-C604 C638 C639 C669 C670 C680 C689 C734 C737 C740-C745 C749 C750 C752 C753 C805 C844-C846 C1044 C1208 C1210 C2374 C6560 C6562-C6564 C6566 C6568 C6571 C6572 C6580 C6610 C6616 C20001 C20002 C20099-C20129 C20135 C20138 C20140-C20143 C96242 C96270 C96272 C96346 C96575-C96648 C96650 C96651 C96653-C96696 C96700 C96716-C96720 C96722-C96724 C96726-C96729 C96731-C96736 C96738-C96765 C96767 C96768 C96771 C96772 C96790 C96793 C96795 C96797 C96816-C96822 C96824-C96827 C96829-C96837 C96861-C96869 C96878 C96888-C96890 C96894 C96896-C96898 C96902 C96904 C96906 C96908 C96925-C96928 C96931 EC9 EC10 PC5005 PC5006 PC5008 PC5010-PC5012 PC5015 PC5017-PC5022 PC5024 PC7034-PC7037 PC7045 PC7053 PC7054 PC7070 PC8008 PC8010 PC8011 = CAP NON-POL_BGM
C856-C861 C20004-C20006 C96776 C96780 C96781 C96784 C96786 = C
C96777 C96778 = C_0
C96779 = CAP_NON-POL_BGM: tolerance: CH5102K9B06
C96782 C96783 C96785 = CAP NP
CN1 CN46 = Header_2P_BGM
CN2 CN3 = USB3_USB-097-1R09HG_9P_BGM
CN4 = CON12X1_2
CN8 = RJ45_8P_4fix_V3_BGM
CN10 = USB3_1_24P_8F_V3_BGM
CN11 = Housing_20P_FIX6P_BGM
CN13 = FFCFPC_4P_2F_BGM
CN14 CN33 = FFCFPC_8P_BGM
CN16 = NGFF_79P_MKEY_NAME_BGM
CN17 = NGFF_79P_EKEY_NAME_BGM
CN18 CN19 = FFCFPC_28P_BGM
CN21 = Dsub_17P_V02_BGM
CN29 = FFCFPC_40P_BGM
CN37 = HDMI_19P_10444-19001_BGM
CN48 = FFCFPC_22P_BGM
CN49 = FFCFPC_30P_BGM
CN50 CN67 = Housing_6P_BGM
CN51 = AUDIO_2SJ3127-023111F_6P_BGM
CN52 CN55 = FFCFPC_16P_BGM
CN53 = FFCFPC_10P_2F_BGM
CN58 = FFCFPC_15P_BGM
CN62 = SDCARD_15P_BGM
CN63 CN64 = HEADER_4P_2F_BGM_0
CN66 = FFCFPC_6P_BGM: tolerance: DFFC06FR198
D3 D11 D6543 PD9001 = DIODE_BGM
D4 D12 D13 D51 D60 D62-D64 D13093 D13106-D13108 D13110 D13148 D13160 D13161 PD1 PD8004 PD8005 = Schottky_DIODE_BGM
D10 D22 D33 D50 D13081-D13092 D13094 D13095 D13111-D13114 D13118 D13119 D13142-D13147 D13151-D13158 D13162-D13165 EC7 EC8 EC16 EC17 = TVS_DIODE_BGM
D65 = Varistor_BGM
D72 = DIODE SCHOTTKY_1
D13096 PD3 PD4 PD8000 PD8001 = ZENER_DIODE_BGM
D13101 D13102 = VARISTOR_BGM
D13149 D13150 PD9002 = BAT54C_BGM
DG4 = BAT54A_BGM
ESD3 ESD4 U6530 U6531 = AZ1045-04F_BGM
F1 F2 = FUSE_BGM
FAN3 = Header_4P_BGM
HE1 = HALL_IC_3P_BGM
HOLE2-HOLE6 HOLE12-HOLE18 HOLE21-HOLE24 HOLE27 HOLE28 HOLE31-HOLE35 = 3x2_1.1
J9007 = OPEN
JDIM1 JDIM02 = DDR4_DIMM_260P_BGM
L4-L8 L11-L13 L15-L17 L22-L24 L27-L31 L4002 L4003 = BEAD_BGM
L4000 L4001 PL5 PL14 PL551 PL5000 PL5001 PL6000 PL6001 PL9000-PL9002 = INDUCTOR_BGM
LH1 = BW_BGM
PC5016 PC7031 PC7032 PC7057 = CAP POL_BGM
PD8002 PD8003 PD8006 PD8007 = DIODE SCHOTTKY
PJ1 = HEADER_8P_2F_BGM
PJ3008 PR3 PR209 R25625 R68987 R69018 = R_Current_SEN_BGM
PJ5000-PJ5002 PJ6001 PJ6003 PJ7000 PJ7001 PJ9002 PJ9003 PJ9005 PJ9008-PJ9010 PR1 PR2 PR5 PR6 PR8 PR17 PR19 PR25 PR26 PR30 PR32 PR566 PR569 PR3022 PR5002 PR5004 PR5011 PR5012 PR5014 PR5016 PR5020-PR5022 PR5024 PR5025 PR6002 PR6004 PR6005 PR6008 PR6013 PR6015 PR6016 PR6020 PR6022 PR6023 PR6025-PR6028 PR6414 PR7041-PR7043 PR7046 PR7049 PR7051 PR7056 PR7057 PR7074 PR7076 PR7077 PR7080 PR7088 PR7090 PR8010 PR8013-PR8015 PR8020 PR8026 PR8033 PR8034 PR8041 PR9008 PR9015-PR9017 PR9028 PR9029 PR9034 PR9067-PR9069 PR9085 PR9244 PR9245 PR9248 PR9249 PR9256 PR9263 PR9275 PR9276 PR9278-PR9281 PR9285 PR9287 PR9288 R455 R462 R575 R614 R753 R1239 R2661 R2667 R25288 R25289 R25295 R25321 R25344 R25347 R25458 R25459 R25462 R25468 R25617 R25622 R67359 R67414 R67415 R67447 R67448 R67551 R67560 R67565 R67855 R67886 R68221 R68228-R68233 R68236 R68237 R68253 R68265 R68267-R68269 R68271 R68280-R68282 R68285-R68287 R68323 R68344 R68345 R68360 R68362 R68370 R68381 R68429 R68431 R68433 R68435 R68438 R68444 R68447 R68478 R68479 R68496 R68497 R68500-R68502 R68504 R68505 R68507 R68511 R68550 R68559 R68562 R68564 R68565 R68571 R68573 R68575 R68577 R68579 R68581 R68582 R68589 R68593 R68606 R68608 R68630 R68633 R68683 R68686 R68687 R68690 R68691 R68713-R68716 R68718 R68722-R68724 R68750 R68761 R68789-R68791 R68795 R68812 R68815 R68816 R68830 R68832 R68834 R68842 R68844 R68846 R68848-R68850 R68871-R68873 R68878 R68887 R68888 R68893 R68894 R68908 R68909 R68913 R68914 R68916 R68920 R68921 R68941 R68952 R68954 R68957 R68969 R68971 R68972 R68974 R68985 R68988 R69006 R69011 R69028 R69029 R69050 R69051 R69054-R69057 R69064 R69075 R69077 R69084 R69097 R69101-R69103 R69107 R69109 = SHORTPAD_V01_BGM
PJ8000 = DCJACK_30706-00042-001_BGM
PL7000-PL7002 = INDUCTOR_BGM_0
PQ1 PQ7002 PQ9008 PQ9054 = MOS-N_8P_BGM
PQ2 PQ29 PQ30 PQ5000 PQ5001 PQ7003 = MOS-N_8P_V3_BGM
PQ6 PQ12 PQ17 PQ19 PQ6000 PQ6001 PQ8000 PQ8015 PQ8019 PQ9009-PQ9011 PQ9050 PQ9084-PQ9086 PQ9088 Q9 Q14-Q16 Q20-Q22 Q33 Q63 Q81 Q85 Q6509 Q6512 Q6520 Q6531 Q6540 Q6555-Q6559 Q6565 Q6570 Q6583 Q6588 Q6593 Q6602 Q6603 Q6610 Q6612 Q6617-Q6629 Q6632 Q6633 Q6637 Q6643 Q6645 Q6646 Q6649 Q6652-Q6654 Q6656 QG15 = MOS-N_3P_ESD_BGM
PQ9 Q6607 Q6609 = MOS-N_3P_BGM
PQ16 PQ9083 Q31 Q6522 Q6592 Q6605 Q6611 Q6657 = DTC144EU_BGM
PQ7000 PQ7001 PQ9000 PQ9001 = MOS-N-Dual_10P_BGM
PQ8001 PQ8002 PQ8006 PQ8007 = MOS-P_8P_BGM
PQ8003 PQ8004 PQ8009 PQ8010 PQ8014 PQ8017 Q23 Q30 Q32 Q6591 Q6600 Q6604 Q6642 Q6644 Q6655 = MOS-P_3P_BGM
PQ8005 Q62 Q6521 Q6554 Q6564 Q6567 Q6585 Q6597 Q6598 Q6601 Q6606 Q6608 Q6616 Q6631 Q6638 Q6651 QG17 = MOS-N_Dual_6P_ESD_BGM
PQ8008 PQ8011 = PNP_BGM
PQ8012 PQ8013 PQ8016 PQ8018 = PNP_Dual_6P_BGM_2
PQ9087 = MOS-N_3P_ESD_V3_BGM
PR4 PR7 PR9-PR16 PR18 PR22 PR23 PR28 PR29 PR31 PR33 PR39 PR40 PR59 PR106 PR116 PR118 PR120 PR126 PR204-PR208 PR210 PR211 PR230 PR235 PR283 PR284 PR551 PR567 PR568 PR3020 PR3021 PR5000 PR5001 PR5003 PR5005-PR5010 PR5013 PR5015 PR5017-PR5019 PR5023 PR5026 PR5027 PR6000 PR6001 PR6003 PR6006 PR6007 PR6009-PR6012 PR6014 PR6017-PR6019 PR6021 PR6024 PR6029-PR6031 PR6416-PR6418 PR7000 PR7002-PR7010 PR7013-PR7021 PR7023-PR7029 PR7032-PR7040 PR7044 PR7045 PR7047 PR7048 PR7050 PR7052-PR7055 PR7058 PR7059 PR7061 PR7062 PR7064-PR7068 PR7070-PR7073 PR7075 PR7078 PR7082-PR7087 PR7089 PR7091 PR8000-PR8009 PR8011 PR8012 PR8016-PR8019 PR8021-PR8025 PR8027-PR8032 PR8035-PR8040 PR8042-PR8064 PR9000-PR9002 PR9004 PR9006 PR9009 PR9011 PR9013 PR9014 PR9018 PR9019 PR9021-PR9027 PR9030-PR9033 PR9070 PR9072-PR9082 PR9086-PR9105 PR9227 PR9255 PR9268-PR9271 PR9277 PR9284 PR9286 PR9289 R36 R61 R101 R224-R227 R231-R244 R296 R297 R299 R305-R307 R310-R326 R329-R332 R338 R339 R341-R359 R361-R370 R372-R374 R376 R378 R380 R382-R386 R391 R394-R399 R402-R407 R409-R411 R414-R418 R439-R443 R446 R447 R449 R451 R452 R454 R458 R460 R461 R464 R465 R468 R469 R471-R479 R490 R491 R495 R497-R500 R503-R506 R509 R510 R516-R519 R566 R567 R574 R576 R579 R580 R583 R586 R588 R589 R592 R593 R600 R601 R608 R609 R646 R647 R651 R652 R665 R667 R670-R672 R676 R678 R720 R732 R734 R735 R752 R803 R825 R849 R850 R894 R895 R953 R956 R960 R971 R978 R979 R1234-R1238 R1250 R1616 R1684 R2652-R2659 R2665 R2666 R4009 R4023 R4024 R9340 R25270 R25271 R25282-R25284 R25298 R25300 R25303 R25304 R25306-R25310 R25312 R25314-R25318 R25322 R25323 R25330 R25346 R25348 R25367-R25373 R25445 R25446 R25456 R25467 R25469 R25482 R25487-R25490 R25492 R25519 R25524 R25526-R25535 R25554-R25560 R25596-R25612 R25614 R25615 R25618-R25620 R25623 R25624 R25630 R25632 R25635-R25639 R25641 R67358 R67360-R67362 R67367-R67370 R67422 R67461 R67462 R67474-R67477 R67492 R67493 R67496 R67497 R67504-R67514 R67524-R67526 R67532 R67539 R67555-R67557 R67561-R67564 R67566-R67575 R67598 R67599 R67604 R67606 R67857 R67858 R67861 R67864-R67866 R67871 R67873 R67875 R67887 R67888 R67895-R67899 R68199-R68204 R68210 R68211 R68215-R68219 R68227 R68242 R68243 R68245-R68252 R68254-R68257 R68259-R68264 R68266 R68270 R68274-R68279 R68283 R68284 R68290-R68314 R68317 R68320-R68322 R68324-R68336 R68339-R68343 R68346-R68359 R68361 R68363-R68369 R68371-R68380 R68382-R68392 R68395 R68396 R68400 R68401 R68405 R68406 R68408-R68413 R68418-R68424 R68426-R68428 R68430 R68432 R68434 R68436 R68437 R68439-R68443 R68446 R68451-R68455 R68458-R68461 R68463 R68466-R68477 R68480-R68495 R68498 R68499 R68503 R68506 R68508-R68510 R68513-R68522 R68524-R68531 R68536-R68547 R68563 R68567 R68568 R68570 R68572 R68574 R68576 R68578 R68580 R68583-R68588 R68591 R68592 R68594-R68605 R68607 R68609-R68614 R68616 R68617 R68620-R68626 R68628 R68631 R68632 R68634-R68639 R68666-R68673 R68677 R68680 R68681 R68684 R68685 R68692-R68697 R68700 R68711 R68712 R68719-R68721 R68725-R68734 R68736-R68745 R68747 R68751 R68752 R68755-R68760 R68764 R68765 R68769 R68771-R68779 R68792-R68794 R68796 R68799 R68802-R68804 R68806-R68808 R68813 R68814 R68828 R68829 R68831 R68833 R68835-R68841 R68843 R68845 R68847 R68851-R68859 R68865-R68868 R68870 R68874-R68877 R68879-R68881 R68883-R68885 R68895-R68899 R68902 R68910 R68911 R68915 R68917-R68919 R68924 R68925 R68927 R68929 R68932-R68940 R68942-R68951 R68953 R68955 R68956 R68968 R68970 R68975 R68976 R68982 R68984 R68986 R68994 R68995 R68998 R69004 R69008-R69010 R69012 R69014 R69019 R69022-R69027 R69030-R69035 R69042-R69049 R69058 R69059 R69062 R69063 R69065-R69071 R69073 R69076 R69078-R69083 R69085-R69094 R69096 R69098-R69100 R69104-R69106 R69110-R69112 RG67 RG77 RG79 = RES_BGM
PR7001 PR7063 PR7079 PR7081 R228-R230 R421 R422 R424-R430 R432 R436 R445 R459 R463 R467 R470 R511 R512 R558 R560 R572 R573 R736 R738 R25297 R25365 R25366 R25473 R25495 R25517 R25518 R68906 R68907 R69020 R69021 = RES_BGM: tolerance: CS00002JB38
PR7011 PR7012 PR7030 PR7031 = SHORTPAD_BGM
PR7022 PR7060 PR9274 = Thermistor_BGM
PU1 = BQ24780SRUYR_BGM
PU3002 = TMP708_BGM
PU3003 = JW5222RSOTB#TRPBF_6P_V1_BGM
PU3004 = JW5213DFND_8P_BGM
PU5000 = G5719CTB1U_BGM
PU5001 = RT8231BGQW_BGM
PU6000 = RT6256BGQUF_12P_BGM
PU6001 PU6002 PU9002 = AOZ1331ADI_14P_BGM
PU6003 = RT6258CGQUF_12P_BGM
PU7000 = RT3612EBGQW-02_32P_BGM
PU7001 = RT6543BGQW_20P_BGM
PU8000 PU8001 = AP2204K-ADJTRG1_BGM
PU9000 = RT8813DGQW_BGM
PU9003 = G9336ADJTP1U_BGM
PU9004 = G5335QT2U_V1_BGM
PU9005 U6557 U6560 U6565 = M74VHC1GT08DFT2G_5P_BGM
PU9006 U6554 U6564 = MC74VHC1G08DFT2G_5P_BGM
Q13 = 2N7002_3
Q28 Q124 Q6523 Q6589 Q6639 Q6640 = NPN_BGM
Q86 Q6582 = NPN_0
Q6508 = AP2331SA-7-01_BGM
Q6534 = G5250Q1T73U_BGM
Q6544 = NPN_V2_BGM
R450 = RES_BGM: tolerance: CS00003J951
R821 R822 R68556 R68780 R69003 = R_3
R890 R25311 R25320 R67484-R67487 R68864 = RES_S_BGM
R4008 = R_1
R25629 R25631 R25633 R25634 R68989 R68990 R68992 R68993 R69016 R69017 = RES_B_BGM
R68551 = R-0603
R68552 R68553 = R_5
R68554 = R_4
R68557 R69002 R69072 = R_2
R68558 = R_9
R68560 R68903 R69005 = RESISTOR
R68561 = R_8
S1 S2 = HOLE 1_1
SW2 = SW_6P_R_BGM
SW4 = SW_6P_BGM
SW5 = SW_4P_BGM
T1-T3 TP2 TP65-TP73 TP96-TP104 TP1310 TP2092 TP7000 TP9000 TP9023 TP9029-TP9033 TP9063 TP9064 TP9066-TP9074 TP13152-TP13155 TP13158-TP13164 TP13169 TP13179-TP13181 TP13238-TP13247 TP13249-TP13286 TP13290 TP13294 TP13303 TP13304 TP13340-TP13354 TP13365-TP13372 TP13375 TP13376 TP13384 TP13391-TP13403 TP13410-TP13429 = TP_BGM
TP9046 TP13311-TP13316 = PAD_0
TP13360-TP13364 TP13407 TP13408 = PAD_3
U2 U6517 = G781_BGM
U8 = GPU_N16S-GTR_595P_BGM
U9 = Logic_AND_BGM
U11 = NL17SZ32DFT2G_BGM
U14 = SLGC55544VTR_BGM
U15 U18 = MAX8863_2
U19 = APL3512ABI-TRG_BGM
U20 = ALC255-CG_BGM_0
U25 = NS680016_0
U33 = NPCT750AABYX_32P_BGM
U35 U36 = NL17SZ08DFT2G_5P_BGM
U37 = IT5571E-I-128/CX_128P_BGM: tolerance: AJ055710F01
U40 = RTS5170-GRT_BGM
U42 = SN75LVCP601RTJR_BGM
U67 = RTD2166-CG_BGM
U6509 = AU9560B62-GBS-GR_28P_BGM
U6515 = BMA253_12P_BGM
U6516 = IT8353VG-128/BX_25P_BGM
U6521 = RTL8111K-CG_48P_BGM
U6525 = ME268-002_0
U6537 = PS8209AQFN48GTR2-A2_48P_BGM
U6539 = TGL_U_IP_EXT/BGA_0
U6544 = CY7C65632-QFN28_2
U6546 = W25Q128JVSIQ_8P_BGM
U6547 = SPISOCKET_8P_BGM
U6548 = SPI_WND_8P_BGM_1
U6549 = Burnside_Bridge_105P_BGM
U6550 = TPS22924CYZPR_6P_BGM
U6551 = W25Q80DVSNIG_8P_BGM
U6553 = DPS1113FIA-13_17P_BGM
U6555 = CCG5_1
U6556 = IT8013FN_QFN-20_1
U6558 U6559 U6561-U6563 = 7SH08_0
VRAM1 VRAM2 = GDDR5_170P_BGM
Y3 Y6 = CRYSTAL_4P_BGM
Y4 = CRYSTAL2_2
Y5 = CRYSTAL_2P_BGM
Y7 = XTAL TSX-3225 EPSONTOYO _0
Y8 = CRYSTAL2_4

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
50208-00601-V02-6P-L
  rect 0.508x0.991 smd: 1(-2,1.95) 2(-1.2,1.95) 3(-0.4,1.95) 4(0.4,1.95) 5(1.2,1.95) 6(2,1.95)
  rect 1.194x1.702 smd: 7(-3.3,0) 8(3.3,0)
50271-0040N-V01-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
