# Allegro board Acer TravelMate  TMP214-41  Quanta Z8IA DAZ8IAMBAC0 Rev C BoardView.brd (continued)
## Nets (continued)
GND: C212.2 C249.1 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C347.1 C348.1 C349.1 C350.1 C351.1 C352.1 C353.1 C354.2 C355.1 C356.1 C357.1 C359.1 C360.1 C362.2 C363.1 C364.2 C365.1 C366.2 C367.1 C368.1 C369.1 C371.2 C372.1 C373.1 C374.1 C375.1 C376.2 C377.1 C378.2 C379.1 C380.1 C381.1 C383.1 C385.2 C386.1 C387.1 C388.1 C389.1 C391.1 C392.2 C393.1 C394.2 C395.2 C396.1 C397.1 C398.2 C399.2 C400.1 C401.2 C402.2 C403.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.2 C414.2 C415.1 C416.2 C417.2 C418.1 C419.2 C420.2 C421.1 C422.1 C423.1 C424.1 C425.1 C426.1 C427.1 C428.1 C429.1 C430.1 C431.1 C432.1 C433.1 C438.1 C439.1 C440.1 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.2 C457.1 C458.1 C459.1 C460.1 C461.2 C462.2 C463.2 C464.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.1 C478.1 C479.1 C480.1 C481.1 C482.1 C483.1 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.2 C491.1 C492.1 C493.1 C494.1 C495.1 C496.1 C497.1 C498.1 C499.1 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C508.2 C509.1 C510.1 C511.1 C512.2 C513.1 C515.1 C516.1 C517.1 C518.1 C521.2 C522.2 C523.1 C524.2 C526.1 C527.1 C528.1 C529.1 C532.2 C533.2 C536.2 C537.2 C542.2 C543.1 C544.2 C545.2 C546.1 C547.2 C548.2 C550.2 C551.2 C558.2 C559.1 C560.2 C561.2 C562.2 C565.2 C567.2 C574.2 C575.2 C576.2 C577.2 C578.2 C580.2 C581.2 C583.1 C584.2 C585.2 C586.2 C587.1 C588.2 C595.2 C596.2 C597.1 C601.2 C602.2 C603.2 C604.2 C613.2 C614.2 C616.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C638.1 C639.1 C641.2 C642.2 C645.2 C646.1 C669.2 C670.2 C680.2 C689.2 C695.2 C696.2 C697.2 C698.2 C699.2 C706.2 C707.2 C708.2 C709.2 C711.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.1 C736.2 C737.1 C740.2 C741.2 C742.2 C743.1 C744.2 C745.1 C749.1 C750.1 C752.1 C753.1 C770.2 C771.2 C772.2 C785.1 C786.1 C800.2 C801.2 C802.2 C804.2 C805.1 C841.2 C842.2 C844.1 C856.1 C857.1 C858.1 C859.1 C860.1 C861.1 C890.1 C900.1 C1044.2 C1189.2 C1190.2 C1208.1 C1210.2 C1211.2 C1214.2 C1217.2 C1643.2 C1644.2 C1645.2 C1646.2 C1647.2 C1648.2 C1649.1 C1650.2 C1651.2 C1652.1 C1653.1 C2374.2 C2609.2 C2616.1 C6560.2 C6562.1 C6563.2 C6565.2 C6568.1 C6569.2 C6570.2 C6571.2 C6572.2 C6573.2 C6574.2 C6575.2 C6577.2 C6578.2 C6580.1 C6598.2 C6599.2 C6600.2 C6601.2 C6602.2 C6607.2 C6610.1 C6615.1 C6616.1 C20000.2 C20001.1 C20002.1 C20003.1 C20004.2 C20005.1 C20006.1 C20008.1 C20009.2 C20010.1 C20011.1 C20012.2 C20013.1 C20020.1 C20021.1 C20022.1 C20023.1 C20039.2 C20040.2 C20041.2 C20042.2 C20043.2 C20044.2 C20045.1 C20046.2 C20047.1 C20048.2 C20049.1 C20050.1 C20051.2 C20053.2 C20099.1 C20100.2 C20101.1 C20102.2 C20103.2 C20104.2 C20105.2 C20106.1 C20107.2 C20108.2 C20109.1 C20110.2 C20111.2 C20112.2 C20113.2 C20114.2 C20115.2 C20116.2 C20117.2 C20118.2 C20119.2 C20120.2 C20121.2 C20122.2 C20123.2 C20124.2 C20125.2 C20126.2 C20127.2 C20128.2 C20129.2 C20131.1 C20132.1 C20133.2 C20134.1 C20135.2 C20138.2 C20140.1 C20141.2 C20142.2 C20143.2 C96242.2 C96247.2 C96248.2 C96249.1 C96269.2 C96271.2 C96300.2 C96301.2 C96302.1 C96303.1 C96304.2 C96305.2 C96308.2 C96309.2 C96310.2 C96311.1 C96312.1 C96313.2 C96319.2 C96320.2 C96343.2 C96344.2 C96346.2 C96554.1 C96555.1 C96556.1 C96557.1 C96558.1 C96559.1 C96560.1 C96561.2 C96562.1 C96563.1 C96564.1 C96565.2 C96566.1 C96567.1 C96568.1 C96569.1 C96570.1 C96571.1 C96572.2 C96574.1 C96575.2 C96576.2 C96577.2 C96578.2 C96579.2 C96580.2 C96581.2 C96582.2 C96583.2 C96584.2 C96585.2 C96586.2 C96587.2 C96588.2 C96589.1 C96590.2 C96591.2 C96592.2 C96593.2 C96594.2 C96595.2 C96596.2 C96597.2 C96598.2 C96599.2 C96600.2 C96601.1 C96602.2 C96603.2 C96604.2 C96605.2 C96606.2 C96607.2 C96608.2 C96609.2 C96610.2 C96611.2 C96612.2 C96613.2 C96614.2 C96615.2 C96616.2 C96617.2 C96618.2 C96619.2 C96620.2 C96621.2 C96622.2 C96623.2 C96624.2 C96625.1 C96626.2 C96627.2 C96628.2 C96629.2 C96630.2 C96631.2 C96632.2 C96633.2 C96634.2 C96635.2 C96636.2 C96637.2 C96638.2 C96639.2 C96640.2 C96641.2 C96642.2 C96643.1 C96644.2 C96645.2 C96646.2 C96647.2 C96648.2 C96649.2 C96650.2 C96651.2 C96652.2 C96653.2 C96654.2 C96655.2 C96656.2 C96657.2 C96658.2 C96659.2 C96660.2 C96661.2 C96662.2 C96663.2 C96664.2 C96665.2 C96666.2 C96667.2 C96668.2 C96669.2 C96670.2 C96671.2 C96672.2 C96673.2 C96674.2 C96675.2 C96676.2 C96677.2 C96678.2 C96679.2 C96680.2 C96681.2 C96682.2 C96683.2 C96684.2 C96685.2 C96686.2 C96687.2 C96688.2 C96689.2 C96690.2 C96691.2 C96692.2 C96693.2 C96694.2 C96695.2 C96696.2 C96700.1 C96709.1 C96710.1 C96711.1 C96713.1 C96716.2 C96717.2 C96718.1 C96719.2 C96720.2 C96721.2 C96722.2 C96723.2 C96724.1 C96725.2 C96726.2 C96727.2 C96728.2 C96729.2 C96730.2 C96731.2 C96732.2 C96733.1 C96734.2 C96735.2 C96736.2 C96737.2 C96738.2 C96739.2 C96740.2 C96741.2 C96742.2 C96743.2 C96744.2 C96745.2 C96746.2 C96747.2 C96748.2 C96749.2 C96750.2 C96751.2 C96752.2 C96753.2 C96754.2 C96755.2 C96756.2 C96757.2 C96758.1 C96759.2 C96760.2 C96761.1 C96762.2 C96763.2 C96764.1 C96765.2 C96766.1 C96767.2 C96768.1 C96769.1 C96770.1 C96771.1 C96772.1 C96773.1 C96774.1 C96776.1 C96777.2 C96778.2 C96779.2 C96780.1 C96781.1 C96782.1 C96783.1 C96784.1 C96785.1 C96786.1 C96788.1 C96789.1 C96790.1 C96793.1 C96794.2 C96795.1 C96796.1 C96814.1 C96815.1 C96816.2 C96817.2 C96818.2 C96819.1 C96820.2 C96821.1 C96822.1 C96823.1 C96824.1 C96825.1 C96826.1 C96827.2 C96828.1 C96829.2 C96830.1 C96831.1 C96832.1 C96833.1 C96834.1 C96835.2 C96836.1 C96837.2 C96851.2 C96852.2 C96853.2 C96854.1 C96855.1 C96856.1 C96857.1 C96858.1 C96859.1 C96861.2 C96862.2 C96863.2 C96864.2 C96865.2 C96866.2 C96867.1 C96868.1 C96869.2 C96870.1 C96871.1 C96872.1 C96873.1 C96876.1 C96878.1 C96879.1 C96880.1 C96881.2 C96882.2 C96883.2 C96884.2 C96885.2 C96887.2 C96888.2 C96889.2 C96890.2 C96891.2 C96892.2 C96893.2 C96894.2 C96895.2 C96896.2 C96897.2 C96898.2 C96901.1 C96902.1 C96903.2 C96904.2 C96905.2 C96906.1 C96907.2 C96908.2 C96909.2 C96910.1 C96911.1 C96912.1 C96913.1 C96919.1 C96921.1 C96922.2 C96923.2 C96924.2 C96925.2 C96926.2 C96927.2 C96928.2 C96930.1 C96931.1 CN1.2 CN2.4 CN2.7 CN2.10 CN2.11 CN2.12 CN2.13 CN3.4 CN3.7 CN3.10 CN3.11 CN3.12 CN3.13 CN4.1 CN4.7 CN4.8(G2) CN8.9 CN8.10 CN8.11 CN8.12(GND#4) CN10.1 CN10.2 CN10.3 CN10.4 CN10.5 CN10.6 CN10.A1 CN10.A12 CN10.B1 CN10.B12 CN11.8 CN11.9 CN11.10 CN11.14 CN11.17 CN11.20 CN11.21 CN11.22 CN11.23 CN11.24 CN13.1 CN13.5 CN13.6 CN14.5 CN14.9 CN14.10 CN16.1 CN16.3 CN16.9 CN16.15 CN16.21 CN16.27 CN16.33 CN16.39 CN16.45 CN16.51 CN16.57 CN16.71 CN16.73 CN16.75 CN16.76 CN16.77 CN17.1 CN17.7 CN17.13 CN17.18 CN17.19 CN17.33 CN17.39 CN17.45 CN17.51 CN17.57 CN17.63 CN17.69 CN17.75 CN17.76 CN17.77 CN18.2 CN18.29 CN18.30 CN19.2 CN19.29 CN19.30 CN21.5 CN21.6 CN21.7 CN21.8 CN21.10 CN21.16 CN21.17(GND#2) CN29.3 CN29.6 CN29.9 CN29.12 CN29.15 CN29.18 CN29.21 CN29.41 CN29.42 CN33.4 CN33.9 CN33.10 CN37.2 CN37.5 CN37.8 CN37.11 CN37.17 CN37.20 CN37.21 CN37.22 CN37.23 CN46.2 CN46.3 CN46.4 CN48.8 CN48.11 CN48.12 CN48.15 CN48.16 CN48.19 CN48.23 CN48.24 CN49.18 CN49.21 CN49.24 CN49.27 CN49.31 CN49.32 CN50.1 CN50.2 CN50.7 CN50.8 CN52.9 CN52.16 CN52.17 CN52.18 CN53.1 CN53.9 CN53.11 CN53.12 CN55.6 CN55.9 CN55.14 CN55.17 CN55.18 CN58.1 CN58.7 CN58.14 CN58.16 CN58.17 CN62.4 CN62.7 CN62.12 CN63.5 CN63.6 CN64.5 CN64.6 CN66.1 CN66.7 CN66.8 CN67.1 CN67.7 CN67.8 D10.2 D22.1 D33.1 D50.1 D65.2 D13081.1 D13082.1 D13083.1 D13084.1 D13085.1 D13086.1 D13087.1 D13088.1 D13089.1 D13090.1 D13091.1 D13092.1 D13094.2 D13095.2 D13096.2 D13101.2 D13102.2 D13111.1 D13112.1 D13113.1 D13114.1 D13118.2 D13119.2 D13142.2 D13143.2 D13144.2 D13145.2 D13146.2 D13147.2 D13151.2 D13152.2 D13153.2 D13154.2 D13155.2 D13156.2 D13157.2 D13158.2 D13162.2 D13163.2 D13164.2 D13165.2 EC5.1 EC6.1 EC7.1 EC8.2 EC9.1 EC10.2 EC11.2 EC16.1 EC17.2 ESD3.3 ESD4.3 FAN3.4 FAN3.5 FAN3.6 HE1.3 HOLE2.1 HOLE3.1 HOLE4.1 HOLE5.1 HOLE6.1 HOLE12.1 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 HOLE21.1 HOLE22.1 HOLE23.1 HOLE24.1 HOLE27.1 HOLE32.1 J9007.2 JDIM1.1 JDIM1.2 JDIM1.5 JDIM1.6 JDIM1.9 JDIM1.10 JDIM1.14 JDIM1.15 JDIM1.18 JDIM1.19 JDIM1.22 JDIM1.23 JDIM1.26 JDIM1.27 JDIM1.30 JDIM1.31 JDIM1.35 JDIM1.36 JDIM1.39 JDIM1.40 JDIM1.43 JDIM1.44 JDIM1.47 JDIM1.48 JDIM1.51 JDIM1.52 JDIM1.56 JDIM1.57 JDIM1.60 JDIM1.61 JDIM1.64 JDIM1.65 JDIM1.68 JDIM1.69 JDIM1.72 JDIM1.73 JDIM1.77 JDIM1.78 JDIM1.81 JDIM1.82 JDIM1.85 JDIM1.86 JDIM1.89 JDIM1.90 JDIM1.93 JDIM1.94 JDIM1.98 JDIM1.99 JDIM1.102 JDIM1.103 JDIM1.106 JDIM1.107 JDIM1.167 JDIM1.168 JDIM1.171 JDIM1.172 JDIM1.175 JDIM1.176 JDIM1.180 JDIM1.181 JDIM1.184 JDIM1.185 JDIM1.188 JDIM1.189 JDIM1.192 JDIM1.193 JDIM1.196 JDIM1.197 JDIM1.201 JDIM1.202 JDIM1.205 JDIM1.206 JDIM1.209 JDIM1.210 JDIM1.213 JDIM1.214 JDIM1.217 JDIM1.218 JDIM1.222 JDIM1.223 JDIM1.226 JDIM1.227 JDIM1.230 JDIM1.231 JDIM1.234 JDIM1.235 JDIM1.238 JDIM1.239 JDIM1.243 JDIM1.244 JDIM1.247 JDIM1.248 JDIM1.251 JDIM1.252 JDIM1.261 JDIM1.262 JDIM02.1 JDIM02.2 JDIM02.5 JDIM02.6 JDIM02.9 JDIM02.10 JDIM02.14 JDIM02.15 JDIM02.18 JDIM02.19 JDIM02.22 JDIM02.23 JDIM02.26 JDIM02.27 JDIM02.30 JDIM02.31 JDIM02.35 JDIM02.36 JDIM02.39 JDIM02.40 JDIM02.43 JDIM02.44 JDIM02.47 JDIM02.48 JDIM02.51 JDIM02.52 JDIM02.56 JDIM02.57 JDIM02.60 JDIM02.61 JDIM02.64 JDIM02.65 JDIM02.68 JDIM02.69 JDIM02.72 JDIM02.73 JDIM02.77 JDIM02.78 JDIM02.81 JDIM02.82 JDIM02.85 JDIM02.86 JDIM02.89 JDIM02.90 JDIM02.93 JDIM02.94 JDIM02.98 JDIM02.99 JDIM02.102 JDIM02.103 JDIM02.106 JDIM02.107 JDIM02.167 JDIM02.168 JDIM02.171 JDIM02.172 JDIM02.175 JDIM02.176 JDIM02.180 JDIM02.181 JDIM02.184 JDIM02.185 JDIM02.188 JDIM02.189 JDIM02.192 JDIM02.193 JDIM02.196 JDIM02.197 JDIM02.201 JDIM02.202 JDIM02.205 JDIM02.206 JDIM02.209 JDIM02.210 JDIM02.213 JDIM02.214 JDIM02.217 JDIM02.218 JDIM02.222 JDIM02.223 JDIM02.226 JDIM02.227 JDIM02.230 JDIM02.231 JDIM02.234 JDIM02.235 JDIM02.238 JDIM02.239 JDIM02.243 JDIM02.244 JDIM02.247 JDIM02.248 JDIM02.251 JDIM02.252 JDIM02.261 JDIM02.262 L11.2 PC4.1 PC5.2 PC6.1 PC7.2 PC8.1 PC9.2 PC10.2 PC11.2 PC12.2 PC16.2 PC18.1 PC19.2 PC35.2 PC36.1 PC37.1 PC51.2 PC73.1 PC164.2 PC165.2 PC166.2 PC167.1 PC168.2 PC170.2 PC172.2 PC229.2 PC242.2 PC551.1 PC561.2 PC562.2 PC563.2 PC571.2 PC572.2 PC581.2 PC756.2 PC5000.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5005.2 PC5006.2 PC5007.2 PC5009.2 PC5010.2 PC5011.2 PC5012.2 PC5013.2 PC5014.2 PC5015.2 PC5016.2 PC5017.2 PC5018.2 PC5019.2 PC5020.2 PC5021.2 PC5022.2 PC5023.2 PC5024.1 PC6000.2 PC6002.1 PC6003.1 PC6004.2 PC6005.2 PC6006.2 PC6007.1 PC6008.2 PC6009.2 PC6010.2 PC6011.2 PC6012.2 PC6013.2 PC6014.2 PC6015.2 PC6016.2 PC6017.1 PC6018.2 PC6019.2 PC6020.2 PC6021.2 PC6022.2 PC6023.2 PC6025.2 PC6026.2 PC6027.2 PC6028.2 PC6029.2 PC6030.2 PC6031.1 PC6032.2 PC6033.2 PC6034.1 PC6036.2 PC6037.2 PC6038.2 PC6039.1 PC6040.2 PC6041.2 PC6042.2 PC6043.2 PC6044.2 PC6045.2 PC6046.2 PC6047.2 PC6048.2 PC6049.2 PC6050.2 PC6051.2 PC6052.2 PC6053.2 PC6054.2 PC6055.1 PC6056.2 PC6057.2 PC6058.2 PC6228.2 PC6229.1 PC6230.2 PC6231.2 PC7000.2 PC7001.1 PC7002.2 PC7003.1 PC7004.2 PC7005.2 PC7006.2 PC7007.2 PC7008.2 PC7009.1 PC7010.2 PC7011.2 PC7013.2 PC7014.2 PC7015.2 PC7016.2 PC7017.2 PC7018.1 PC7019.1 PC7020.2 PC7021.2 PC7022.2 PC7023.2 PC7024.2 PC7025.1 PC7026.2 PC7028.2 PC7029.2 PC7030.2 PC7031.2 PC7032.2 PC7033.1 PC7035.2 PC7037.2 PC7038.1 PC7039.2 PC7042.1 PC7044.2 PC7045.1 PC7046.2 PC7047.2 PC7048.2 PC7049.2 PC7050.2 PC7051.1 PC7052.2 PC7054.2 PC7055.2 PC7056.2 PC7057.2 PC7058.2 PC7059.2 PC7060.2 PC7061.1 PC7062.2 PC7063.2 PC7064.2 PC7065.2 PC7066.1 PC7070.1 PC8001.2 PC8002.2 PC8005.2 PC8006.2 PC8007.2 PC8008.1 PC8009.2 PC8010.2 PC8011.2 PC9000.2 PC9001.2 PC9002.2 PC9003.2 PC9004.2 PC9005.2 PC9006.2 PC9007.2 PC9009.2 PC9010.2 PC9011.2 PC9012.2 PC9013.2 PC9014.1 PC9015.2 PC9016.2 PC9017.2 PC9018.2 PC9019.2 PC9021.2 PC9022.2 PC9023.2 PC9024.2 PC9025.2 PC9026.2 PC9027.2 PC9029.2 PC9030.2 PC9053.2 PC9054.2 PC9055.2 PC9056.2 PC9057.2 PC9058.2 PC9059.2 PC9060.2 PC9062.2 PC9063.2 PC9064.2 PC9065.2 PC9066.2 PC9067.2 PC9068.2 PC9069.2 PC9071.2 PC9072.2 PC9073.2 PC9074.2 PC9075.2 PC9076.2 PC9077.2 PC9078.2 PC9080.2 PC9081.2 PC9082.2 PC9083.2 PC9084.2 PC9085.2 PC9086.2 PC9087.2 PC9088.2 PC9098.2 PC9099.2 PD3.2 PD4.2 PD8000.2 PJ1.1 PJ1.2 PJ1.9 PJ1.10 PJ8000.2 PJ8000.4 PJ8000.5(SPRING & SHELL(-) #3) PQ6.1(S) PQ12.1(S) PQ16.1(EMITTER) PQ17.1(S) PQ19.1(S) PQ29.1 PQ29.2 PQ29.3(S_3) PQ5000.1 PQ5000.2 PQ5000.3(S_3) PQ6000.1(S) PQ6001.1(S) PQ7000.10(S2) PQ7001.10(S2) PQ7003.1 PQ7003.2 PQ7003.3(S_3) PQ8005.1(S) PQ8005.4 PQ8015.1(S) PQ8019.1(S) PQ9000.10(S2) PQ9001.10(S2) PQ9009.1(S) PQ9010.1(S) PQ9011.1(S) PQ9050.1(S) PQ9083.1(EMITTER) PQ9084.1(S) PQ9085.1(S) PQ9086.1(S) PQ9088.1(S) PR10.2 PR23.2 PR40.2 PR118.2 PR120.2 PR205.1 PR206.2 PR207.2 PR211.1 PR230.2 PR283.2 PR567.1 PR3021.1 PR5005.1 PR5014.2 PR5017.1 PR5019.2 PR5027.2 PR6007.2 PR6012.2 PR6014.1 PR6024.2 PR6031.1 PR7032.1 PR7033.2 PR7034.2 PR7035.2 PR7053.2 PR7058.1 PR7067.2 PR7068.2 PR7070.1 PR7089.1 PR7091.2 PR8000.1 PR8008.2 PR8009.2 PR8016.2 PR8017.1 PR8022.2 PR8023.1 PR8024.2 PR8027.2 PR8028.2 PR8029.2 PR8030.1 PR8031.2 PR8032.2 PR8039.2 PR8040.1 PR8042.2 PR8043.2 PR8044.2 PR8055.2 PR8056.2 PR8057.2 PR8059.2 PR8064.2 PR9011.2 PR9022.1 PR9030.1 PR9031.1 PR9032.1 PR9034.2 PR9077.2 PR9082.1 PR9098.2 PR9101.2 PR9104.2 PR9105.2 PR9274.2 PR9289.2 PU1.22 PU1.29 PU1.30 PU1.31 PU1.32 PU1.33 PU1.34 PU1.35 PU1.36 PU1.37 PU1.38 PU3002.2 PU3002.4 PU3003.2 PU3004.4 PU3004.8 PU3004.9 PU5000.2 PU5001.1 PU5001.14 PU5001.21 PU6000.4 PU6000.8 PU6001.11 PU6001.15 PU6002.11 PU6002.15 PU6003.4 PU6003.8 PU7000.33 PU7001.14 PU7001.21 PU8000.2 PU8001.2 PU9000.25 PU9002.11 PU9002.15 PU9003.2 PU9004.12 PU9004.13 PU9004.14 PU9004.15 PU9004.19 PU9005.3 PU9006.3 Q14.1(S) Q16.1(S) Q20.1(S) Q22.1(S) Q31.1(EMITTER) Q81.1(S) Q6508.2 Q6509.1(S) Q6520.1(S) Q6521.1(S) Q6521.4 Q6522.1(EMITTER) Q6534.2 Q6565.1(S) Q6570.1(S) Q6582.1(EMITTER) Q6583.1(S) Q6588.1(S) Q6589.1(EMITTER) Q6592.1(EMITTER) Q6593.1(S) Q6597.4 Q6598.1(S) Q6601.4 Q6605.1(EMITTER) Q6608.1(S) Q6608.4 Q6610.1(S) Q6611.1(EMITTER) Q6617.1(S) Q6643.1(S) Q6645.1(S) Q6646.1(S) Q6651.1(S) Q6651.4 Q6656.1(S) Q6657.1(EMITTER) QG17.1(S) QG17.4 R228.2 R229.2 R230.2 R243.2 R244.1 R306.1 R311.2 R312.1 R313.2 R315.1 R317.2 R319.1 R320.2 R325.1 R331.2 R332.2 R338.2 R350.1 R351.1 R352.1 R353.1 R354.1 R355.1 R356.1 R357.1 R358.1 R394.2 R396.2 R398.1 R405.1 R406.1 R409.1 R410.2 R414.1 R415.1 R416.2 R442.2 R446.1 R463.1 R464.2 R465.2 R467.1 R469.2 R470.1 R479.2 R497.1 R499.1 R504.1 R506.1 R510.1 R588.2 R589.2 R676.2 R678.2 R734.1 R752.1 R803.2 R825.1 R849.2 R850.2 R890.2 R1234.1 R1235.1 R1236.1 R1250.1 R4008.2 R4009.2 R25270.2 R25282.2 R25298.1 R25303.2 R25311.2 R25316.2 R25320.2 R25369.2 R25495.1 R25527.2 R25534.2 R25556.1 R25599.1 R25600.2 R25601.1 R25614.1 R25615.2 R25624.2 R67362.2 R67476.2 R67477.1 R67513.1 R67524.1 R67555.2 R67569.2 R67866.2 R68199.2 R68200.1 R68201.1 R68202.2 R68211.2 R68215.2 R68227.1 R68243.1 R68245.2 R68246.2 R68249.2 R68255.1 R68256.1 R68262.1 R68264.1 R68274.2 R68275.2 R68276.2 R68279.1 R68290.2 R68305.2 R68312.1 R68313.1 R68317.2 R68320.2 R68321.2 R68322.2 R68324.2 R68325.2 R68326.2 R68327.2 R68328.2 R68329.2 R68330.2 R68331.2 R68332.2 R68333.2 R68334.2 R68335.2 R68336.2 R68352.1 R68353.2 R68354.1 R68371.2 R68372.2 R68373.2 R68374.2 R68375.2 R68376.2 R68383.2 R68384.2 R68385.2 R68386.2 R68387.2 R68395.2 R68396.2 R68405.2 R68406.2 R68411.2 R68412.2 R68413.2 R68422.1 R68423.1 R68424.2 R68427.2 R68432.1 R68443.1 R68455.2 R68458.2 R68470.1 R68471.1 R68472.1 R68473.1 R68474.1 R68475.1 R68477.2 R68480.1 R68481.2 R68482.2 R68483.2 R68484.2 R68486.2 R68492.2 R68494.2 R68498.2 R68499.2 R68515.1 R68517.1 R68519.1 R68521.1 R68524.1 R68526.1 R68528.1 R68530.1 R68540.2 R68541.2 R68542.2 R68543.2 R68546.2 R68547.2 R68557.2 R68558.1 R68559.2 R68560.1 R68561.1 R68595.2 R68597.2 R68603.2 R68610.2 R68611.2 R68612.2 R68613.2 R68620.2 R68626.2 R68666.1 R68667.1 R68668.1 R68669.1 R68670.1 R68671.1 R68672.1 R68673.1 R68680.2 R68681.2 R68684.2 R68700.2 R68755.2 R68771.1 R68773.1 R68775.1 R68777.1 R68779.1 R68793.1 R68806.2 R68807.2 R68808.2 R68836.2 R68851.1 R68855.2 R68858.1 R68864.2 R68874.2 R68876.1 R68877.1 R68878.2 R68903.2 R68918.1 R68933.1 R68934.1 R68935.1 R68936.1 R68937.1 R68938.2 R68939.1 R68955.2 R68956.2 R68989.2 R68990.2 R69003.1 R69004.2 R69005.2 R69006.2 R69008.2 R69009.2 R69042.2 R69049.2 R69064.2 R69072.2 R69096.2 R69104.1 R69106.2 S1.1 S1.2 S1.3 S2.1 S2.2 S2.3 SW4.1 SW4.2 SW4.5 SW4.6 SW5.3 SW5.4 TP13361.1 U2.5 U8.A2 U8.A26 U8.AA7 U8.AB7 U8.AB11 U8.AB14 U8.AB17 U8.AB20 U8.AB24 U8.AC2 U8.AC5 U8.AC8 U8.AC22 U8.AC26 U8.AD12 U8.AD13 U8.AD15 U8.AD16 U8.AD18 U8.AD19 U8.AD21 U8.AD22 U8.AE11 U8.AE14 U8.AE17 U8.AE20 U8.AF1 U8.AF5 U8.AF8 U8.AF11 U8.AF14 U8.AF17 U8.AF20 U8.AF23 U8.AG2 U8.AG26 U8.B1 U8.B5 U8.B8 U8.B11 U8.B14 U8.B17 U8.B20 U8.B23 U8.B27 U8.E2 U8.E5 U8.E8 U8.E11 U8.E14 U8.E17 U8.E20 U8.E22 U8.E25 U8.H2 U8.H5 U8.H23 U8.H25 U8.K11 U8.K13 U8.K15 U8.K17 U8.L2 U8.L5 U8.L10 U8.L12 U8.L14 U8.L16 U8.L18 U8.L23 U8.L25 U8.M11 U8.M13 U8.M15 U8.M17 U8.N10 U8.N12 U8.N14 U8.N16 U8.N18 U8.P2 U8.P5 U8.P11 U8.P13 U8.P15 U8.P17 U8.P23 U8.P26 U8.R10 U8.R12 U8.R14 U8.R16 U8.R18 U8.T11 U8.T13 U8.T15 U8.T17 U8.U2 U8.U5 U8.U10 U8.U12 U8.U14 U8.U16 U8.U18 U8.U23 U8.U26 U8.V11 U8.V13 U8.V15 U8.V17 U8.Y2 U8.Y5 U8.Y23 U8.Y26 U9.3 U11.3 U14.14 U14.17 U15.2 U18.2 U19.2 U20.49 U25.25 U33.16 U33.23 U33.33 U35.3 U36.3 U37.1 U37.27 U37.49 U37.91 U37.104 U40.25 U42.3 U42.13 U42.18 U42.21 U42.22 U42.23 U42.24 U42.25 U42.26 U67.24 U67.33 U6509.12 U6515.4 U6515.8 U6515.9 U6516.C3 U6517.5 U6521.49 U6525.2 U6530.3 U6531.3 U6537.49 U6539.A27 U6539.A32 U6539.A45 U6539.A49 U6539.AA41 U6539.AA48 U6539.AB5 U6539.AB7 U6539.AB8 U6539.AC44 U6539.AC49 U6539.AD4 U6539.AD8 U6539.AD48 U6539.AF4 U6539.AF8 U6539.AG41 U6539.AG42 U6539.AG44 U6539.AG45 U6539.AG47 U6539.AG48 U6539.AG53 U6539.AH4 U6539.AH8 U6539.AK4 U6539.AK5 U6539.AK7 U6539.AK8 U6539.AK12 U6539.AK48 U6539.AM1 U6539.AM2 U6539.AM4 U6539.AM8 U6539.AN41 U6539.AN42 U6539.AN44 U6539.AN45 U6539.AN47 U6539.AN48 U6539.AN53 U6539.AP4 U6539.AP8 U6539.AT4 U6539.AT8 U6539.AT48 U6539.AT51 U6539.AV4 U6539.AV5 U6539.AV7 U6539.AV8 U6539.AV12 U6539.AV39 U6539.AW1 U6539.AW2 U6539.AW48 U6539.AY4 U6539.AY8 U6539.AY9 U6539.AY41 U6539.AY42 U6539.AY44 U6539.AY45 U6539.AY47 U6539.B2 U6539.B8 U6539.B13 U6539.B19 U6539.B23 U6539.B27 U6539.B32 U6539.B36 U6539.B39 U6539.B42 U6539.B48 U6539.B52 U6539.BA48 U6539.BA53 U6539.BB4 U6539.BB8 U6539.BC1 U6539.BC2 U6539.BD4 U6539.BD8 U6539.BD12 U6539.BD48 U6539.BF4 U6539.BF5 U6539.BF7 U6539.BF8 U6539.BF39 U6539.BF41 U6539.BF42 U6539.BF44 U6539.BF45 U6539.BF47 U6539.BG48 U6539.BG53 U6539.BH1 U6539.BH2 U6539.BH4 U6539.BH8 U6539.BK4 U6539.BK8 U6539.BK12 U6539.BK48 U6539.BL49 U6539.BM1 U6539.BM4 U6539.BM8 U6539.BM41 U6539.BM42 U6539.BM44 U6539.BM45 U6539.BM47 U6539.BN48 U6539.BP5 U6539.BP7 U6539.BP41 U6539.BP49 U6539.BP50 U6539.BT44 U6539.BT48 U6539.BU49 U6539.BV3 U6539.BV5 U6539.BV48 U6539.BW10 U6539.BY9 U6539.BY41 U6539.BY42 U6539.BY44 U6539.BY45 U6539.BY47 U6539.BY49 U6539.C13 U6539.C19 U6539.C23 U6539.CA48 U6539.CB41 U6539.CC3 U6539.CC5 U6539.CC10 U6539.CD7 U6539.CD44 U6539.CD48 U6539.CE49 U6539.CG9 U6539.CG48 U6539.CG51 U6539.CG52 U6539.CH41 U6539.CH42 U6539.CH44 U6539.CH45 U6539.CH47 U6539.CJ3 U6539.CJ5 U6539.CJ9 U6539.CK39 U6539.CK48 U6539.CK53 U6539.CL9 U6539.CN9 U6539.CN12 U6539.CN48 U6539.CN51 U6539.CN52 U6539.CP3 U6539.CP5 U6539.CP41 U6539.CP42 U6539.CP44 U6539.CP45 U6539.CR9 U6539.CR48 U6539.CR53 U6539.CT5 U6539.CU4 U6539.CU9 U6539.CV5 U6539.CV10 U6539.CV48 U6539.CV51 U6539.CV52 U6539.CY5 U6539.CY17 U6539.CY22 U6539.CY35 U6539.CY41 U6539.CY42 U6539.CY44 U6539.CY45 U6539.CY47 U6539.D5 U6539.D27 U6539.D32 U6539.D36 U6539.D42 U6539.D49 U6539.DA30 U6539.DA33 U6539.DA53 U6539.DC17 U6539.DD15 U6539.DD24 U6539.DD26 U6539.DD28 U6539.DD31 U6539.DD33 U6539.DD35 U6539.DD39 U6539.DD45 U6539.DD51 U6539.DD52 U6539.DE3 U6539.DE5 U6539.DF19 U6539.DF37 U6539.DG5 U6539.DG6 U6539.DG15 U6539.DG21 U6539.DG27 U6539.DG33 U6539.DG39 U6539.DG45 U6539.DG53 U6539.DJ1 U6539.DJ2 U6539.DJ4 U6539.DK51 U6539.DL3 U6539.DL5 U6539.DM4 U6539.DM10 U6539.DM15 U6539.DM21 U6539.DM27 U6539.DM33 U6539.DM39 U6539.DM45 U6539.DN1 U6539.DN2 U6539.DP53 U6539.DR11 U6539.DR16 U6539.DR22 U6539.DR28 U6539.DR34 U6539.DR40 U6539.DR46 U6539.DT4 U6539.DT50 U6539.DU11 U6539.DU16 U6539.DU22 U6539.DU28 U6539.DU34 U6539.DU40 U6539.DU46 U6539.DV1 U6539.DV40 U6539.DV52 U6539.DW51 U6539.E13 U6539.E19 U6539.E35 U6539.E48 U6539.G22 U6539.G28 U6539.G34 U6539.G39 U6539.G48 U6539.G51 U6539.G52 U6539.H8 U6539.H12 U6539.H22 U6539.H28 U6539.H34 U6539.J39 U6539.J49 U6539.K5 U6539.K16 U6539.K18 U6539.K20 U6539.K22 U6539.K28 U6539.K34 U6539.K48 U6539.L22 U6539.L28 U6539.L34 U6539.L39 U6539.L41 U6539.L42 U6539.L44 U6539.L45 U6539.L47 U6539.L49 U6539.M1 U6539.M2 U6539.M50 U6539.N22 U6539.N28 U6539.N34 U6539.N39 U6539.N41 U6539.N48 U6539.P4 U6539.P8 U6539.P11 U6539.P14 U6539.P16 U6539.P18 U6539.P20 U6539.P22 U6539.P33 U6539.P35 U6539.P49 U6539.R39 U6539.R44 U6539.T4 U6539.T8 U6539.T19 U6539.T29 U6539.T33 U6539.T48 U6539.U19 U6539.U25 U6539.U39 U6539.U49 U6539.V4 U6539.V8 U6539.V19 U6539.W1 U6539.W16 U6539.W26 U6539.W30 U6539.W39 U6539.W41 U6539.W42 U6539.W44 U6539.W45 U6539.W47 U6539.W48 U6539.Y4 U6539.Y8 U6539.Y49 U6539.Y50 U6544.29 U6546.4 U6547.4 U6548.4 U6549.A11 U6549.B1 U6549.B2 U6549.B11 U6549.B12 U6549.D1 U6549.D2 U6549.D11 U6549.D12 U6549.F1 U6549.F2 U6549.F3 U6549.F5 U6549.F7 U6549.F9 U6549.F11 U6549.F12 U6549.G5 U6549.G7 U6549.H1 U6549.H2 U6549.H11 U6549.H12 U6549.J9 U6549.K1 U6549.K2 U6549.K11 U6549.K12 U6549.L12 U6549.M2 U6549.M3 U6549.M12 U6550.C1 U6551.4 U6553.6 U6554.3 U6555.41 U6556.17 U6556.21 U6557.3 U6558.3 U6559.3 U6560.3 U6561.3 U6562.3 U6563.3 U6564.3 U6565.3 VC2.2 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J1 VRAM1.J10 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM2.A1 VRAM2.A3 VRAM2.A12 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C3 VRAM2.C4 VRAM2.C11 VRAM2.C12 VRAM2.C14 VRAM2.D10 VRAM2.E1 VRAM2.E3 VRAM2.E12 VRAM2.E14 VRAM2.F5 VRAM2.F10 VRAM2.G5 VRAM2.G10 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J1 VRAM2.J10 VRAM2.K1 VRAM2.K2 VRAM2.K13 VRAM2.K14 VRAM2.L5 VRAM2.L10 VRAM2.M5 VRAM2.M10 VRAM2.N1 VRAM2.N3 VRAM2.N12 VRAM2.N14 VRAM2.P10 VRAM2.R1 VRAM2.R3 VRAM2.R4 VRAM2.R11 VRAM2.R12 VRAM2.R14 VRAM2.T5 VRAM2.T10 VRAM2.U1 VRAM2.U3 VRAM2.U12 VRAM2.U14 Y3.2 Y3.4 Y4.2 Y4.4 Y6.2 Y6.4 Y7.2 Y7.4 Y8.2 Y8.4
V1P05_CTRL: TP13403.1 U6539.DT12
V3A_BOOT: PR6000.2 PU6000.1
V3A_BOOT_R: PC6001.1 PR6000.1
V3A_EN: PC6007.2 PR6002.2 PR6006.2 PU6000.6
V3A_PWRGD: PR6005.2 PU6000.7
V3A_VBYP: PC6023.1 PR6009.2 PR6017.2 PR8034.2 PR8046.2 PU6000.11
V3A_VOUT: PC6017.2 PR6008.1 PR6010.2 PR6011.2 PU6000.10(VOUT)
V5P5A_BOOT: PR6018.2 PU6003.1
V5P5A_BOOT_R: PC6035.1 PR6018.1
V5P5A_EN: PC6039.2 PR6020.2 PR6021.2 PU6003.6
V5P5A_PWRGD: PR6022.2 PU6003.7
V5P5A_VOUT: PC6055.2 PR6026.1 PR6029.2 PR6030.2 PU6003.10(VOUT)
V18: C1649.2 U40.24
VCC3V3_FLASH: C96835.1 C96837.1 C96901.2 Q6621.2 Q6623.2 Q6629.2 R68607.2 R68634.2 R68635.1 R68636.2 R68637.2 R68638.2 R68639.2 R68875.2 R68880.1 R68895.2 R68896.2 R68897.2 R68898.2 R68899.2 R68984.1 TP13345.1 U6550.A2 U6550.B2 U6551.8
VCC_AUX_SENSE: PR7088.2 U6539.AT9
VCCA_CLKLDO_1V8: C96766.2 R68497.1 U6539.DC15 U6539.DV16
VCCAUX_VID: C96904.1 R68856.2 U6559.1 U6562.1
VCCAUX_VID0: D13150.2 PR7064.2 PR7067.1 PR7077.1 R68502.1 U6563.2
VCCAUX_VID0_R: R68502.2 R68509.2 U6539.DB37
VCCAUX_VID1: D13150.1 PR7065.2 PR7068.1 PR7076.1 R68504.1 U6563.1
VCCAUX_VID1_R: R68504.2 R68510.2 U6539.DB38
VCCD_SP: C96866.1 U6555.33
VCCDSW_3P3: C96772.2 R68501.1 R68503.1 U6539.DD37
VCCK_V12: C20020.2 C20021.2 C20022.2 U67.4 U67.25
VCCRTC_3: Q28.3 R310.2
VCCRTC_4: R310.1 R67360.2
VCCSENSE: PR7052.2 PR7056.2 U6539.R38
VCCST_DIS1: Q6597.5 Q6598.6 R68854.2 R68855.1
VCCST_DIS2: Q6597.3 R68847.2
VCCST_EN_1: C96893.1 Q6598.2 Q6609.2 R68840.2 R68844.2 R68853.2
VCCST_EN_2: R68841.1 R68949.1 U6560.1 U6560.2
VCCST_OVERRIDE: R68848.1 U6539.BP9
VCCST_OVERRIDE_EN: D13149.2 Q6610.3 R68843.1 U6558.2 U6561.2
VCCST_PWRGD_TCSS: R68850.1 U6539.CE5
VCCSTG_DIS1: Q6608.5 Q6608.6 R68835.2 R68836.1
VCCSTG_EN: C96884.1 R68828.1 U6557.1 U6557.2
VCCSTG_EN_1: R68829.1 U6557.4(Y)
VCCSTG_EN_2: C96885.1 C96886.1 Q6607.2 Q6608.2 R68829.2 R68831.2 R68837.2 R68857.2
VDD_SUPPLY_1P: C96861.1 C96863.1 C96864.1 R68695.1 R68711.1 R68720.2 R68721.2 R68725.2 R68726.2 R68727.2 R68730.2 R68731.2 R68733.2 R68885.2 R68968.2 TP13360.1 U6555.31 U6555.32 U6564.1 U6564.5(VCC)
VSS_AUX_SENSE: PR7090.2 U6539.AV9
VSSSENSE: PR7057.2 PR7058.2 U6539.R37
1.03_GFX_PGD: PR9076.1 PR9078.1 PR9096.1
1P35V_BOOT: PR5008.2 PU5001.18
1P35V_CS: PR5005.2 PU5001.13
1P35V_FB: PR5018.1 PR5019.1 PU5001.6
1P35V_LGATE: PQ5000.4 PU5001.15
1P35V_PGOOD: PR5002.1 PU5001.10
1P35V_PHASE: PC5008.1 PL5000.1 PQ5000.5 PQ5001.1 PQ5001.2 PQ5001.3(S_3) PR5010.1 PU5001.16
1P35V_S3: PC5000.1 PR5006.2 PR5013.1 PR5015.2 PU5001.7
1P35V_S5: PC5001.1 PR5003.2 PR5004.1 PR5013.2 PU5001.8
1P35V_TON: PR5007.2 PU5001.9
1P35V_UGATE: PQ5001.4 PU5001.17
1P35V_VDD: PC5019.1 PR5011.2 PU5001.12
1P35V_VDDQ: PR5012.2 PR5018.2 PU5001.5
1P35V_VID: PR5016.1 PR5017.2 PU5001.11
2ND_MBCLK: CN49.22 Q6564.3 Q6606.1(S) R383.1 R67448.1 R68866.2 U37.115
2ND_MBDATA: CN49.23 Q6564.6 Q6606.4 R25304.1 R67447.1 R68865.2 U37.116
27M_XTAL_IN: C463.1 U8.C11 Y3.3
27M_XTAL_OUT: C464.1 U8.B10 Y3.1
80PORT_CLK: CN66.3 R68570.2
80PORT_DAT: CN66.4 R68568.1
5213EN_1.8V: PC581.1 PR566.1 PU3004.7 PU9005.4(Y)
5213FB_1.8V: PC574.2 PR567.2 PR568.2 PU3004.1
5213FB_1.8V_S: PC574.1 PR568.1 PR569.1
5213LX_1.8V: PL551.1 PR551.1 PU3004.6
5213PG_1.8V: PR9256.2 PU3004.2
8813BOOT1: PC9008.2 PU9000.1
8813BOOT2: PC9020.2 PU9000.18
8813EN: PC9013.1 PD1.2 PR9085.2 PR9284.1 PU9000.3
8813ILIM: PC9030.1 PR9032.2 PU9000.12
8813ISEN1: PC9014.2 PR9013.2 PU9000.15
8813ISEN2: PR9025.2 PU9000.14
8813LGAT1: PQ9000.8 PR9011.1 PU9000.23
8813LGAT2: PQ9001.8 PU9000.20
8813PG: PR9008.2 PR9009.2 PU9000.16
8813PHASE1: PC9008.1 PL9001.1 PQ9000.5 PQ9000.6 PQ9000.7 PR9004.2 PU9000.24
8813PHASE2: PC9020.1 PL9000.1 PQ9001.5 PQ9001.6 PQ9001.7 PR9019.2 PU9000.19
8813PSI: PR9016.2 PR9018.2 PR9022.2 PU9000.4
8813PVCC: PC9000.1 PR9001.2 PU9000.21
8813REFADJ: PR9023.2 PU9000.6
8813REFIN: PC9026.1 PR9024.2 PR9027.1 PU9000.7
8813RGN: PC9028.2 PC9029.1 PR9029.1 PU9000.10
8813TON: PR9002.1 PU9000.9
8813UGATE1: PR9006.1 PU9000.2
8813UGATE1_1: PQ9000.1 PR9006.2
8813UGATE2: PR9014.1 PU9000.17
8813UGATE2_1: PQ9001.1 PR9014.2
9336ADJ: PR9081.2 PR9082.2 PU9003.5
9336DRV: PD9001.1(CATHODE) PQ9008.4 PR9080.1 PU9003.6
24780_ACDET: PR31.2 PR211.2 PR9275.2 PU1.6
24780_ACDRV: PR29.2 PU1.4
24780_ACN: PC25.2 PC35.1 PR2.1 PU1.1
24780_ACP: PC25.1 PC36.2 PR1.1 PU1.2
24780_BATDRV: PR4.2 PU1.18
24780_BATSRC: PR7.2 PU1.17
24780_BM#: PR9.1 PU1.16
24780_BST: PR11.1 PU1.25
24780_CMPIN: PR207.1 PU1.13
24780_CMPOUT: PR15.1 PU1.14
24780_CMSRC: PR28.2 PU1.3
24780_DH: PQ30.4 PU1.26
24780_DL: PQ29.4 PU1.23
24780_ILIM: PC8.2 PR204.1 PR206.1 PU1.21
24780_LX: PC15.1 PL5.1 PQ29.5 PQ30.1 PQ30.2 PQ30.3(S_3) PR33.1 PU1.27
24780_SRN: PC3.1 PC4.2 PR6.2 PR208.1
24780_SRP: PC3.2 PC6.2 PR5.2 PR210.2
24780_VCC: PC16.1 PR16.1 PU1.28(VCC)
+1.03_GFX: C347.2 C348.2 C349.2 C350.2 C354.1 C363.2 C366.1 PJ9003.2 PR9081.1 U8.AA22 U8.AB23 U8.AC24 U8.AD25 U8.AE26 U8.AE27
+601_VCC: C6598.1 C6599.1 C6600.1 C6601.1 C6602.1 C6607.1 R495.2 R498.2 R500.2 R503.2 R505.2 R1237.2 R1238.2 R1239.2 R69045.2 U42.10 U42.20(VCC#2)
+AZA_VDD: C580.1 C581.1 R455.2 R478.2 U20.1
+CRT_AVCC_33: C20023.2 L4003.2 U67.1
+CRT_VDDA33: C20010.2 C20012.1 L17.2 R458.1 R1616.1 R25533.1 U67.20
+FB_PLLAVDD: C453.2 C454.2 C455.2 C456.1 L5.2 L6.2 U8.F16 U8.H22 U8.P22
+MOD_VUP: CN58.12 R67565.2
+PBA_PWR: C749.2 Q32.1(S) R25295.2
+PBA_PWR_C: CN14.8 CN52.1 R614.2
+PBA_PWR_R: C752.2 C753.2 Q32.3 R608.2 R614.1
+PSWOUT: C20042.1 C20050.2 C20051.1 F2.1 R25554.2 U6509.11
+SENSOR_POWER: C20133.1 C20134.2 C20135.1 C20138.1 C96907.1 CN67.6 D13093.1(CATHODE) Q6540.2 Q6567.2 Q6567.5 Q6631.2 Q6631.5 Q6632.2 Q6633.2 Q6637.2 Q6653.2 R25622.2 R25623.1 R25625.1 R25629.1 R25631.1 R25633.1 R25634.1 R25635.1 R25636.1 R68992.1 R68993.1 R68994.1 R68995.1 U6515.3(VDDIO) U6515.7 U6515.11 U6516.C2
+SMDDR_VREF_DIMM: C264.1 C265.1 JDIM1.164 R241.2 R242.2 R243.1 R67574.1
+SMDDR_VREF_DQ1_M1: C20101.2 C20102.1 JDIM02.164 R25612.2 R25615.1 R67514.2 R67575.1
+TS_PWR: CN29.30 CN29.31 R25462.2
+USBPWR0: C515.2 C516.2 C517.2 CN2.1(VBUS) D13101.1 U15.1(OUT)
+USBPWR1: C509.2 C510.2 C511.2 CN3.1(VBUS) D13102.1 U14.12(VOUT)
+USBPWRD2: C527.2 C528.2 C529.2 CN48.1 CN48.2 CN48.3 CN48.4 CN55.1 CN55.2 CN55.3 CN55.4 U18.1(OUT)
+VAC_IN: PC8001.1 PC8002.1 PC8003.1 PD8000.1 PD8002.2 PD8006.2 PJ8000.1 PQ8001.1 PQ8001.2 PQ8001.3(S3) PQ8003.1(S) PR235.1 PR8001.1 PR8002.1 PR8018.1
+VCONN_5V_3: R68694.2 U6555.8
+VGPU_CORE: C351.2 C352.2 C353.2 C355.2 C356.2 C357.2 C359.2 C365.2 C367.2 C368.2 C369.2 C372.2 C373.2 C374.2 C385.1 C387.2 C388.2 C389.2 C391.2 C393.2 C396.2 C397.2 C400.2 C403.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.1 C414.1 C415.2 C416.1 C417.1 C418.2 C419.1 C420.1 C421.2 C422.2 C423.2 C424.2 C426.2 C427.2 C428.2 C430.2 C432.2 PC9009.1 PC9010.1 PC9011.1 PC9021.1 PC9022.1 PL9000.2 PL9001.2 PR9026.1 U8.K10 U8.K12 U8.K14 U8.K16 U8.K18 U8.L11 U8.L13 U8.L15 U8.L17 U8.M10 U8.M12 U8.M14 U8.M16 U8.M18 U8.N11 U8.N13 U8.N15 U8.N17 U8.P10 U8.P12 U8.P14 U8.P16 U8.P18 U8.R11 U8.R13 U8.R15 U8.R17 U8.T10 U8.T12 U8.T14 U8.T16 U8.T18 U8.U11 U8.U13 U8.U15 U8.U17 U8.V10 U8.V12 U8.V14 U8.V16 U8.V18
+VNN_EXT: R68498.1 U6539.DD17 U6539.DD18
+VREF06_RT3612: PR7013.1 PR7014.1 PR7015.1 PR7016.1 PR7017.1 PR7059.1 PR7062.1 PU7000.12
A_A0: R68804.2 R68808.1 U6556.3
A_A1: R68803.2 R68807.1 U6556.2
A_A2: R68802.2 R68806.1 U6556.1
A_INT: R69012.1 R69080.2 U6556.7
A_SCL: C96913.2 Q6606.6 R68814.1 R68866.1 U6556.19
A_SDA: C96912.2 Q6606.3 R68813.1 R68865.1 U6556.20
AC_PRESENT_EC: R68461.2 R68471.2 U37.84 U6539.DK43
ACCEL_INTA: Q6540.3 R25639.1 R68747.1 U6539.DV21
ACIN: PR30.2 PR39.2 PR40.1 U37.72
ACZ_BCLK: R68451.1 R68938.1 U6539.DR38
ACZ_RST#: R68454.1 R68455.1 U6539.DV41
ACZ_SDOUT: Q6649.1(S) R68453.1 U6539.DT37
ACZ_SPKR: D11.2 R68364.2 R68371.1 R69103.1 U6539.DC50
ACZ_SYNC: R68452.1 U6539.DU37
ADDR_SEL: R25623.2 R25624.1 U6515.1
ADOGND: C563.1 C564.2 C568.2 C569.2 C572.1 C573.2 C586.1 C588.1 C590.1 C591.1 C592.1 C593.1 C598.1 C599.2 C845.2 C96265.2 C96266.2 C96267.2 C96268.2 CN51.5 R447.1 R463.2 R464.1 R465.1 R467.2 R469.1 R470.2 R474.2 R475.2 R588.1 R589.1 U20.25 U20.38
ADP_DET: PR8025.1 PR8026.2 Q6602.1(S) R68760.2
ADP_EN: PR8013.2 R68761.2
ADP_ID: PJ8000.3 PR9276.1
ADP_IN_CCG5: Q6602.3 R68974.2
ADP_IN_EN_CCG5: Q6603.1(S) R69081.2
ADP_IN_EN_EC: R68759.1 R69083.1
ALERT: R397.1 U8.F8
AMP_MUTE#: D13.1(CATHODE) U37.108
AN_RBIAS: R68632.1 U6549.L4
AN_RSENSE: R68632.2 U6549.L5
AP12: TP13294.1 U6539.AP12
AUX_PWRGD: PR7074.1 TP7000.1
BAT-V: PC164.1 PC165.1 PC166.1 PC167.2 PC168.1 PD9002.1 PJ1.7 PJ1.8 PR208.2 PR209.2
BATLED0#: CN48.22 CN52.14 CN55.12 R67487.1 U37.29
BATLED1#: CN48.7 CN52.15 CN55.13 R67485.1 U37.25
BATLOW#: R68459.1 R68460.1 U6539.DN41
BI: PJ1.6 PR10.1 R25321.1 SW2.1 SW2.2
BIOS_WP#: R68578.2 R68591.2 TP13315.1(TP) U6546.3(W\P\(IO2)) U6547.3(W\P\(IO2)) U6548.3
BL#: Q6521.2 Q6521.3 R25368.1
BL_ON: CN29.26 D3.2 Q6521.6 Q6522.3 R25367.1
BOARD_ID0: R68515.2 R68516.1 U6539.DN10
BOARD_ID1: R68517.2 R68518.1 U6539.DN15
BOARD_ID2: R68519.2 R68520.1 U6539.DJ15
BOARD_ID3: R68521.2 R68522.1 U6539.DN13
BOARD_ID4_TSN: C20001.2 CN29.24 R68524.2 R68525.1 U6539.DM13
BOARD_ID5: R68526.2 R68527.1 U6539.DK13
BOARD_ID6_MIC_SINGLE: C20002.2 CN29.29 R68528.2 R68529.1 U6539.DK15
BOARD_ID7: R68530.2 R68531.1 U6539.DV14
BOARD_ID8: R68771.2 R68772.1 R68957.2
BOARD_ID8_SIM_TYPE1: CN49.25 R68957.1 R69101.2 U6539.DK33
BOARD_ID9: R68773.2 R68774.1 R69028.2
BOARD_ID9_SIM_TYPE2: CN49.26 R69028.1 R69102.2 U6539.DK31
BOARD_ID10: R68775.2 R68776.1 U6539.DW35
BOARD_ID11: R68777.2 R68778.1 U6539.DV35
BOARD_ID12: R68793.2 R68794.1 U6539.DT32
BOARD_ID13: R68858.2 R68859.1 U6539.DR35
BRIGHT: R439.2 R441.1 R443.2
BT_EN: R960.2 R68690.2
BT_OFF#: CN17.54(W_DISABLE2#) R671.1 R68690.1 R68692.1
BXTALOUT: R330.1 R332.1 U8.C10
C_IN_CLK: C96553.2 CN37.10 D13088.2 LH1.2
C_IN_CLK#: C96553.1 CN37.12 D13087.2 LH1.3
C_TX0_HDMI+: CN37.7 D13082.2 R68232.2
C_TX0_HDMI-: CN37.9 D13081.2 R68233.2
C_TX1_HDMI+: CN37.4 D13084.2 R68230.2
C_TX1_HDMI-: CN37.6 D13083.2 R68231.2
C_TX2_HDMI+: CN37.1 D13086.2 R68228.2
C_TX2_HDMI-: CN37.3 D13085.2 R68229.2
CCG5_SWD_CLK_SP: R68695.2 R68700.1 TP13363.1 U6555.2
CCG5_SWD_IO_RST#_SP: R69011.2 TP13364.1 U6555.6
CCG5_VBUS: R69057.2 U6555.22
CCG5_VBUS_C_CTRL_P1: PR8014.2 R68696.2 U6555.12
CCG5_VBUS_P_CTRL_P1: Q6593.2 R68697.2 U6555.11
CCG5_VSYS: C96862.1 C96865.1 R69056.2 U6555.19
CCG5_XRES_SP: C96869.1 R68711.2 TP13362.1 U6555.10(XRES)
CFG_RCOMP: R68305.1 U6539.B5
CHA_SA0: JDIM1.256 R225.2 R228.1
CHA_SA1: JDIM1.260 R226.2 R229.1
CHA_SA2: JDIM1.166 R227.2 R230.1
CHB_SA0: JDIM02.256 R25596.2 R25599.2
CHB_SA1: JDIM02.260 R25597.1 R25600.1
CHB_SA2: JDIM02.166 R25598.2 R25601.2
CL_CLK: R68945.2 U6539.DH3
CL_DATA: R68944.2 U6539.DH4
CL_RST#: R68943.2 U6539.DF2
CLK_BIASREF: R68443.2 U6539.DJ5
CLK_PCIE_LANN: U6521.45 U6539.CL8
CLK_PCIE_LANP: U6521.44 U6539.CL7
CLK_PCIE_SSDN: R2658.1 U6539.CB5
CLK_PCIE_SSDN_C: CN16.53 R2658.2
CLK_PCIE_SSDP: R2659.1 U6539.CB4
CLK_PCIE_SSDP_C: CN16.55 R2659.2
CLK_PCIE_WLANN: CN17.49 U6539.BY3
CLK_PCIE_WLANP: CN17.47 U6539.BY4
CLK_VGA_N: U8.AD8 U6539.CN8
CLK_VGA_P: U8.AE8 U6539.CN7
CLR_CMOS: Q22.2 Q6520.2 R409.2 U37.19
CNV_BRI_DT: CN17.36 R68431.2
CNV_BRI_DT_R: R68409.2 R68412.1 R68431.1 U6539.DF17
CNV_BRI_RSP: R665.2 R68428.2 U6539.DF15
CNV_BRI_RSP_L: CN17.22 R665.1
CNV_MFUART2_RXD: CN17.48 R68948.1
CNV_MFUART2_TXD: CN17.46 R68947.1
CNV_PA_BLANKING: CN17.44 R68946.2
CNV_RF_RESET#: R68477.1 R68872.2 U35.1 U35.2 U6539.DG51
CNV_RF_RESET#_L: CN17.10 R676.1 R68872.1 U35.4
CNV_RGI_DT: CN17.32 R68379.1 R68385.1 R68429.2
CNV_RGI_DT_R: R68429.1 U6539.DG13
CNV_RGI_RSP: R667.2 R68430.2 U6539.DJ13
CNV_RGI_RSP_L: CN17.34 R667.1
CNV_WR_CLK_DN: CN17.21 U6539.DW44
CNV_WR_CLK_DP: CN17.23 U6539.DV44
CNV_WR_LANE0_DN: CN17.15 U6539.DT43
CNV_WR_LANE0_DP: CN17.17 U6539.DR44
CNV_WR_LANE1_DN: CN17.9 U6539.DV43
CNV_WR_LANE1_DP: CN17.11 U6539.DU43
CNV_WT_CLK_DN: CN17.71 U6539.DN47
CNV_WT_CLK_DP: CN17.73 U6539.DN45
CNV_WT_LANE0_DN: CN17.65 U6539.DR49
CNV_WT_LANE0_DP: CN17.67 U6539.DN49
CNV_WT_LANE1_DN: CN17.59 U6539.DM47
CNV_WT_LANE1_DP: CN17.61 U6539.DK47
CNV_WT_RCOMP: R68427.1 U6539.DN51
CNVI_EN: R68941.1 U6539.DC53
CODEC_VREF: C563.2 U20.28(VREF)
CPU_C10_GATE#: R68468.2 R68935.2 R68952.1 U6539.DN27
CPU_EAR: R68277.1 R68279.2 U6539.G1
CPU_POPI_RCOMP: R68262.2 U6539.CT39
CPU_PRDY#: TP13250.1 U6539.D11
CPU_PREQ#: R68270.1 TP13249.1 U6539.C11
CPU_SVID_CLK: R68286.1 U6539.M11
CPU_SVID_DAT: R68287.1 U6539.M12
CPU_VIDALERT#: R68285.1 U6539.P12
CPVDD_CODEC: C565.1 R68687.2 R68839.2 U20.36
CRT_11: CN21.11 TP9063.1
CRT_B: C858.2 L31.1 R850.1 U67.21
CRT_B1: C859.2 CN21.3 ESD3.4 ESD3.7 L31.2
CRT_G: C857.2 L27.1 R849.1 U67.22
CRT_G1: C860.2 CN21.2 ESD3.2 ESD3.9 L27.2
CRT_R: C856.2 L22.1 R803.1 U67.23
CRT_R1: C861.2 CN21.1 ESD3.1 ESD3.10(NC#4) L22.2
CRT_VCC_R: C551.1 C890.2 C900.2 C20005.2 C20009.1 C20013.2 CN21.9 ESD3.5 ESD3.6 Q6534.1(OUT) U67.17
CRTHSYNC: C20008.2 CN21.13 ESD4.2 ESD4.9 R25532.1
CRTHSYNC_R: R25532.2 U67.19
CRTVSYNC: C20003.2 CN21.14 ESD4.4 ESD4.7 R25535.1
CRTVSYNC_R: R25535.2 U67.18(VSYNC)
CSCL: R68217.2 U6537.29
CSDA: R68218.2 U6537.28
CSI_RCOMP: R68432.2 U6539.K14
CTL2: R418.2 U14.7
CTL3: R417.2 U14.8
DB_GSENSOR_INT: CN67.2 Q6653.1(S) R68995.2 R69082.2 U6516.A5
DBG_PMODE: R68400.1 R68405.1 U6539.DF4
DC-DET: R732.1 R25495.2 U20.4
DCIN_ENB: R68199.1 U6537.3
DCPRTC: C96931.2 U6539.DV34
DDPC_CLK: R68910.2 U6539.DG47
DDPC_DATA: R68911.2 U6539.DJ47
DDR4_DRAMRST#: C249.2 C20103.1 C96574.2 JDIM1.108 JDIM02.108 R68253.2
DDR4_SUSON_2V5: CN49.6 PR5003.1 PR5025.2 U37.122
DDR_RCOMP0: R68249.1 U6539.C49
DDR_VTT_CTRL: R68254.1 U6539.E52
DDR_VTTT_PG_CTRL: PR5015.1 Q6583.3 R68251.2 R68255.2 R68940.2
DDSP_HPD1: TP13366.1 U6539.DF45
DE1: R503.1 R1235.2 U42.9
DE2: R504.2 R505.1 U42.8
DEVSLP0: R67358.2 U6539.DG8
DEVSLP0_R: CN11.1 R67358.1
DEVSLP1: TP13367.1 U6539.DN6
DEVSLP#: CN16.38 TP13375.1
DEW1: R499.2 R500.1 U42.16
DEW2: R506.2 R1237.1 U42.6
DGPU_EDIDCLK: R363.1 U8.A9
DGPU_EDIDDATA: R366.1 U8.B9
DGPU_HOLD_RST#: R68352.2 U9.1 U6539.DK6
DGPU_OPP#: Q6512.3 R378.1 U37.71
DGPU_OVT#_EC: Q15.3 R385.1 TP13169.1
DGPU_PROCHOT_EC#: Q6512.1(S) R25322.1 U8.D7
DGPU_PSI: PR9016.1 R376.2 R391.1
DGPU_PW_CTRL#: R68779.2 R68780.2 U6539.DG41
DGPU_PWR_EN: PR9070.2 R323.1 R68358.2 R69104.2 U6539.DW9
DGPU_PWROK: R25468.2 R68357.2 R69110.2 U6539.DM6
DGPU_PWROK_1.8V: D13161.2 Q9.2 Q6652.1(S) QG17.6 R69078.2 RG67.2
DISP_ON: Q6657.2 R445.1 R446.2 U19.3
DISP_UTILS: TP13241.1 U6539.CE4
DMIC_CLK: R461.2 U20.3
DMIC_CLK_L: C583.2 L12.2 R461.1
DMIC_CLK_L_C: C548.1 CN29.1 L12.1 R69062.2
DMIC_CLK_PCH: R69062.1 U6539.DN31
DMIC_DAT: R459.1 U20.2
DMIC_DAT_L: L13.2 R459.2
DMIC_DAT_L_C: C547.1 CN29.2 L13.1 R69063.2
DMIC_DAT_PCH: R69063.1 U6539.DM31
DNBSWON#: U37.123 U6539.DK41
DP_AUXN: C20014.1 U6539.AD9
DP_AUXP: C20015.1 U6539.AB9
DP_D0N: C20017.1 U6539.V9
DP_D0P: C20016.1 U6539.V11
DP_D1N: C20019.1 U6539.P9
DP_D1P: C20018.1 U6539.T9
DP_HPD: R61.1 U6539.DG43
DP_HPD_R: R61.2 R25534.1 U67.32
DP_RCOMP: R68245.1 U6539.AB1
DPWROK_EC: C96717.1 R68479.1 R68481.1 U37.15
DRAM_RESET#: R68252.2 R68253.1 U6539.DV47
DSI_DE_TE_2: R68246.1 U6539.M8
DWL_REQ: Q6558.3 R67556.2 R67567.1 R67569.1 U6539.DN25
EC_CCG1_I2C_INT_D: Q6626.3 R68722.2 R68727.1 U6555.15
EC_CCG_I2C_INT#: Q6626.1(S) R67604.1 R68722.1 U37.125
EC_CCG_I2C_SCL: Q6628.1(S) R67448.2 R68724.1
EC_CCG_I2C_SCL_D: Q6628.3 R68724.2 R68725.1 U6555.17
EC_CCG_I2C_SDA: Q6627.1(S) R67447.2 R68723.1
EC_CCG_I2C_SDA_D: Q6627.3 R68723.2 R68726.1 U6555.16
EC_FPBACK#: Q6522.2 U37.86
EC_PECI: R380.2 U6539.BK9
EC_PECR_R: R380.1 U37.117
EC_PWROK: R68467.2 R68478.2 R68484.1 U37.33
EC_SIM_DET: CN49.12 U37.94
EC_SIM_SW#: CN49.13 U37.3
EC_VOLDN_BTN_ODL: CN52.6 R69088.1 U6556.10
EC_VOLUP_BTN_ODL: CN52.5 R69090.2 U6556.9
EC_VSTBY_FSPI: PC8006.1 PD8004.2 PR8036.2 PU8000.5
ECAGND: C6564.1 C6566.2 C96797.2 L11.1 U37.75
EEDI: R4008.1 TP13155.1 U6521.30
EEPROM_SCL: R68559.1 U6544.18
EEPROM_SDA: TP13304.1 U6544.26
EN: R1236.2 R1238.1 U42.7
EN_3V_DX_LTE: CN49.7 R67871.2 U37.77
ENSWREG: R67475.2 R67476.1 R67513.2 U6521.6
EQ1: R497.2 R498.1 U42.17
EQ2: R495.1 R1234.2 U42.19
EQ_SEL_A0: R68210.2 R68211.1 U6537.5
ESPI_0: R68343.2 U37.10
ESPI_0_R: R68343.1 U6539.DP52
ESPI_1: R68342.2 U37.9
ESPI_1_R: R68342.1 U6539.DP50
ESPI_2: R68341.2 U37.8
ESPI_2_R: R68341.1 U6539.DH50
ESPI_3: R68340.2 U37.7
ESPI_3_R: R68340.1 U6539.DJ53
ESPI_CLK: C96700.2 R402.2 R68339.2 U37.13
ESPI_CLK_R: R68339.1 U6539.DN53
ESPI_CS#: R68344.2 R68353.1 U37.6
ESPI_CS#_R: R68344.1 U6539.DK52
ESPI_RESET#: R894.2 R68345.2 R68354.2
ESPI_RESET#_EC: C2374.1 R894.1 R68864.1 U37.22
ESPI_RESET#_R: R68345.1 U6539.DL50
FAN1_RPM: FAN3.2 R25372.2 U37.47
FAN_PWM: Q6523.1(EMITTER) U37.32
FAN_PWM_C: FAN3.3 Q6523.3 R25373.2
FB_CAL_PD_VDDQ: R318.2 U8.D22
FB_CAL_PU_GND: R319.2 U8.C24
FB_CAL_TERM_GND: R320.1 U8.B25
FBA_CMD0: U8.C27 VRAM1.G12
FBA_CMD1: U8.C26 VRAM1.H10
FBA_CMD2: U8.E24 VRAM1.H11
FBA_CMD3: U8.F24 VRAM1.K11
FBA_CMD4: U8.D27 VRAM1.K10
FBA_CMD5: U8.D26 VRAM1.L12
FBA_CMD6: U8.F25 VRAM1.K4
FBA_CMD7: U8.F26 VRAM1.K5
FBA_CMD8: U8.F23 VRAM1.J4
FBA_CMD9: U8.G22 VRAM1.J5
FBA_CMD10: U8.G23 VRAM1.H4
FBA_CMD11: U8.G24 VRAM1.H5
FBA_CMD12: U8.F27 VRAM1.G3
FBA_CMD13: R315.2 U8.G25 VRAM1.J2
FBA_CMD14: R316.2 U8.G27 VRAM1.J3
FBA_CMD15: U8.G26 VRAM1.L3
FBA_CMD16: U8.M24 VRAM2.G12
FBA_CMD17: U8.M23 VRAM2.H10
FBA_CMD18: U8.K24 VRAM2.H11
FBA_CMD19: U8.K23 VRAM2.K11
FBA_CMD20: U8.M27 VRAM2.K10
FBA_CMD21: U8.M26 VRAM2.L12
FBA_CMD22: U8.M25 VRAM2.K4
FBA_CMD23: U8.K26 VRAM2.K5
FBA_CMD24: U8.K22 VRAM2.J4
FBA_CMD25: U8.J23 VRAM2.J5
FBA_CMD26: U8.J25 VRAM2.H4
FBA_CMD27: U8.J24 VRAM2.H5
FBA_CMD28: U8.K27 VRAM2.G3
FBA_CMD29: R317.1 U8.K25 VRAM2.J2
FBA_CMD30: R314.1 U8.J27 VRAM2.J3
FBA_CMD31: U8.J26 VRAM2.L3
FBA_DBI0: U8.D19 VRAM1.D2
FBA_DBI1: U8.D14 VRAM1.D13
FBA_DBI2: U8.C17 VRAM1.P13
FBA_DBI3: U8.C22 VRAM1.P2
FBA_DBI4: U8.P24 VRAM2.P13
FBA_DBI5: U8.W24 VRAM2.P2
FBA_DBI6: U8.AA25 VRAM2.D2
FBA_DBI7: U8.U25 VRAM2.D13
FBA_EDC0: U8.E19 VRAM1.C2
FBA_EDC1: U8.C15 VRAM1.C13
FBA_EDC2: U8.B16 VRAM1.R13
FBA_EDC3: U8.B22 VRAM1.R2
FBA_EDC4: U8.R25 VRAM2.R13
FBA_EDC5: U8.W23 VRAM2.R2
FBA_EDC6: U8.AB26 VRAM2.C2
FBA_EDC7: U8.T26 VRAM2.C13
FBA_VREFC_1: C505.1 R407.2 R410.1 R411.1 VRAM1.J14
FBA_VREFC_2: C506.1 R25282.1 R25283.1 R25284.2 VRAM2.J14
FBVDD_EN: R325.2 R25469.1 U11.4(Y)
FBVDDQ_EN: PR9095.2 R25469.2
FOST1: R68975.2 R69006.1 U6553.5
G5335-AGND-2: PC9090.2 PC9091.2 PR9093.1 PR9097.2 PR9098.1 PU9004.4
G5335-BST-2: PR9089.2 PU9004.20
G5335-EN-2: PC9090.1 PQ9086.2 PR9095.1 PR9096.2 PU9004.2
G5335-FB-2: PC9089.1 PR9094.2 PR9097.1 PU9004.5
G5335-LX-2: PC9079.1 PL9002.1 PR9092.1 PU9004.10 PU9004.11 PU9004.16 PU9004.17 PU9004.18 PU9004.25
G5335-PFM-2: PR9091.1 PR9093.2 PU9004.3
G5335-PWRGD-2: PR9090.2 PU9004.1
G5335-SS-2: PC9091.1 PU9004.23
G5335-TON-2: PR9086.1 PU9004.6
G5335-VCC-2: PC9075.1 PR9087.2 PU9004.21(VCC)
G5719LX1.5V: PL14.1 PU3003.3
G5719LX2.5V: PL5001.1 PU5000.3
GC6_FB_EN: Q16.2 R372.2 R394.1
GC6_FB_EN_N17: R372.1 U8.B2
GC6_FB_EN_Q: Q14.3 R68356.2 U11.1 U6539.DR9
GPD2: R68990.1 U6516.D4
GPIO0: TP104.1 U40.17
GPIO10_VREF: Q20.2 R398.2 U8.C5
GPO: Q6619.1(S) R67474.2 R67504.1 R67524.2 U6521.3
GPP_B18: R68377.2 R68383.1 U6539.DA51
GPP_B23: R68382.2 R68387.1 U6539.CY50
GPP_E2: R68359.2 U6539.DN5
GPP_F7: R68544.2 R68546.1 U6539.DT15
GPP_F10: R68545.2 R68547.1 U6539.DT14
GPP_F20: R68937.2 U6539.DR12
GPP_F21: R68936.2 U6539.DW12
GPP_H0: R68537.2 R68541.1 U6539.DW32
GPP_H1: R68538.2 R68542.1 U6539.DV32
GPP_H2: R68539.2 R68543.1 U6539.DF31
GPP_RCOMP: R68290.1 U6539.DR51
GPPC_D19: TP13290.1 U6539.DW24
GPPC_E6: R68390.1 R68391.1 R68396.1 U6539.DT8
GPU_CHOKE_THERMAL: PR9025.1 R68867.1 R68870.2
GPU_CLK#_C: C96552.1 U6537.48
GPU_CLK_C: C96551.1 U6537.47
GPU_D0#_C: C96550.1 U6537.45
GPU_D0_C: C96549.1 U6537.44
GPU_D1#_C: C96548.1 U6537.42
GPU_D1_C: C96547.1 U6537.41
GPU_D2#_C: C96546.1 U6537.39
GPU_D2_C: C96545.1 U6537.38
GPU_EVENT#: D4.1(CATHODE) R25482.2 R68278.2 U6539.DU5
GPU_EVENT#_GPU: D4.2 R373.2 R25490.1
GPU_GPIO0: R370.1 U8.C6
GPU_GPIO2: R373.1 U8.D6
GPU_GPIO6: R376.1 U8.A4
GPU_GPIO21: R404.1 U8.C4
GPU_PEX_RST_HOLD#: R399.1 U8.D5
GPU_PWR_GD: PR9008.1 PR9079.1 R324.1 R69111.1
GPUT_CLK_L: Q13.4(S2) R365.1 U8.D9
GPUT_DATA_L: Q13.1 R362.1 U8.D8
GS_HUB_INT1#: Q6637.3 R68998.1 U6539.DV27
GS_HUB_INT2#: Q6653.3 R69082.1 U6539.DT27
H_CATERR#: R68257.2 U6539.M7
H_PROCHOT#: PR22.1 PR7007.1 PR7042.1 PU1.10 Q6509.3 Q6654.1(S) R68259.1 R68260.1 R68514.2
H_PROCHOT#_CCG5: R68712.2 R68913.2
H_THRMDA1: C96270.1 Q6544.2 Q6544.3 U2.2
H_THRMDC1: C96270.2 Q6544.1(EMITTER) U2.3
H_VCCST_PWRGD: R68493.2 U6539.BP8
H_VCCST_PWRGD_R: C96718.2 D13106.2 D13107.2 R68491.2 R68493.1
HDD_MS_PWR_EN: Q6643.2 Q6645.2 R68736.2 R69035.1 R69042.1 R69044.2 R69048.2 R69049.1 R69079.2
HDD_MS_PWR_EN_36079458: Q6656.2 R69094.2 R69096.1 R69100.2
HDD_MS_PWR_EN_GPPB4: R69079.1 U6539.DB42
HDMI_DDCCLK: Q62.4 R68909.1 R68910.1 R69019.2
HDMI_DDCCLK_DDP3: R68909.2 U6539.DN23
HDMI_DDCDATA: Q62.1(S) R68908.1 R68911.1
HDMI_HPD: R1250.2 R25297.1 U6537.21 VC2.1
HDMI_HPD_C: C616.1 CN37.19 R25297.2
HDMI_HPD_DC: R68219.1 R68221.2 U6537.40
HDMI_HPD_PCH: R68221.1 R68227.2 R68247.2 U6539.DH52
HDMI_RST#: C96554.2 R68216.2 U6537.35
HDMI_SCLK: C614.1 CN37.15 D13089.2 R490.2 R68907.2 R69020.2
HDMI_SCLK_R1: R69020.1 U6537.7
HDMI_SDATA: C613.1 CN37.16 D13090.2 R491.2 R68906.2 R69021.2
HDMI_SDATA_R2: R69021.1 U6537.8
HDMI_SEL#_A1: R68204.2 U6537.32
HDMI_TXCN: C96552.2 U6539.BF2
HDMI_TXCP: C96551.2 U6539.BF1
HDMI_TXDN0: C96550.2 U6539.BD5
HDMI_TXDN1: C96548.2 U6539.BE1
HDMI_TXDN2: C96546.2 U6539.AY7
HDMI_TXDP0: C96549.2 U6539.BD7
HDMI_TXDP1: C96547.2 U6539.BE2
HDMI_TXDP2: C96545.2 U6539.AY5
HOLD#: R68580.2 R68592.1 TP13316.1(TP) U6546.7 U6547.7 U6548.7
HP-L2: C589.2 R472.2 R474.1 R476.2 U20.32
HP-L3: C592.2 C96266.1 CN51.4 R472.1
HP-R2: C594.2 R473.2 R475.1 R477.2 U20.33
HP-R3: C593.2 C96267.1 CN51.3(R) R473.1
HP_JD#: CN51.6 D13095.1 R451.2
HWPG: D51.2 D60.2 D62.2 D64.2 D13106.1(CATHODE) Q6588.3 Q6651.6 R25312.1 R25524.2 R68490.1 R68492.1 U37.21
HWPG_1.5V: PR284.1 PR6416.2 R25524.1
HWPG_1.8VS5: D62.1(CATHODE) PR7080.1 PR9255.2 PR9256.1
HWPG_1.35VGFX: PR9088.2 PR9090.1 R69109.1 R69112.1
HWPG_2.5V: D64.1(CATHODE) PR5000.2 PR5021.2
HWPG_VDDR: D51.1(CATHODE) PR5001.2 PR5002.2
I2C0_SCL_TS: TP13371.1 U6539.DV18
I2C0_SDA_TS: TP13372.1 U6539.DW18
I2C1_CLK_TP: R558.2 R68738.1 U6539.DJ23
I2C1_DATA_TP: R560.2 R68739.1 U6539.DT18
I2C2_SCL_SEN_HUB: Q6632.3 R25632.1 R68742.1 U6539.DJ29
I2C2_SDA_SEN_HUB: Q6633.3 R25630.1 R68743.1 U6539.DJ31
I2C3_SCL_NFC: Q6556.3 R67570.1 R68740.1 U6539.DF29
I2C3_SDA_NFC: Q6559.3 R67564.1 R68741.1 U6539.DG29
I2C_INT#_TS: R68420.1 TP13369.1 U6539.DT31
I2C_RST#_TS: TP13370.1 U6539.DR32
I2C_SEL_PIN: R68203.2 U6537.31
I2CA_SCL: R326.1 U8.B7
I2CA_SDA: R25492.1 U8.A7
I2CINT13: R68989.1 U6516.B5
I219_PCH_SMCLK: Q6554.3 Q6616.3 R67525.1 R68348.1 R68893.2 U6539.DK19
I219_PCH_SMDATA: Q6554.6 Q6616.6 R67526.1 R68349.1 R68894.2 U6539.DM17
I219_SMCLK: Q6554.4 R4023.1 R67525.2 U6521.28
I219_SMDATA: Q6554.1(S) R4024.1 R67526.2 TP13162.1 U6521.31
ICCINSERTN: CN53.2 U6509.19
ICMNT: C6564.2 PC37.2 PR32.2 U37.67
IDCHG_R: C96796.2 PC73.2 PR26.2 U37.70
IDEA_G_3VLDO: PQ8014.2 PQ8016.3 PR8044.1
IDEA_G_5VS5_PD_C1: PQ8017.2 PQ8018.3 PR8059.1
ILIM_HI: R414.2 U14.16
ILIM_LO: R415.2 U14.15
IMONCPU_1: PR7059.2 PR7060.2
IMVP_PWRGD: PR7040.2 PR7041.1 Q85.2 R68466.2
INPUT3VSEL: R68410.2 R68413.1 U6539.DT49
INT1_GSENSOR_MB: Q6637.1(S) R25641.1 R68998.2 U6515.5
INT2_GSENSOR1: TP1310.1 U6515.6
INT_AMIC-VREFO: C564.1 R447.2 U20.27
INT_BT_OFF#_L: R68692.2 U6539.DH49
INT_BTN_L: CN52.10 R67861.1
INT_EDP_AUXN: C556.2 U6539.AJ1
INT_EDP_AUXN_C: C556.1 CN29.22 R25271.1
INT_EDP_AUXP: C557.2 U6539.AJ2
INT_EDP_AUXP_C: C557.1 CN29.23 R25270.1
INT_EDP_TXN0: C553.2 U6539.AG1
INT_EDP_TXN0_C: C553.1 CN29.19
INT_EDP_TXN1: C555.2 U6539.AF2
INT_EDP_TXN1_C: C555.1 CN29.16
INT_EDP_TXP0: C552.2 U6539.AG2
INT_EDP_TXP0_C: C552.1 CN29.20
INT_EDP_TXP1: C554.2 U6539.AF1
INT_EDP_TXP1_C: C554.1 CN29.17
INT_HUB_TO_CPU: Q6540.1(S) R25634.2 R25639.2 U6516.A4
INT_RF_OFF#_L: R68693.2 U6539.DC52
INTRUDER#: C96716.1 R68401.2 R68406.1 U6539.DM37
IR_WP#_EC: CN50.4 U37.2
IRQ_R: Q6555.3 R67555.1 R67557.2 U6539.DM25
ISEN1N: PC7034.1 PC7035.1 PR7012.2 PR7038.2 PR7039.1
ISEN1P: PR7011.2 PR7037.2
ISEN1P_1: PR7036.2 PR7037.1
ISEN2N: PC7036.1 PC7037.1 PR7031.2 PR7047.2 PR7048.1
ISEN2P: PR7030.2 PR7045.2
ISEN2P_1: PR7044.2 PR7045.1
ISH_I2C1_SCL: Q6567.6 R67875.1 R68744.1 U6539.CY39
ISH_I2C1_SDA: Q6567.3 R67873.1 R68745.1 U6539.DB47
ISOLATEB: R509.2 R510.2 R9340.1 U6521.1
IST_TP_0: TP13266.1 U6539.A4
IST_TP_1: TP13265.1 U6539.A6
JTAG_TCK: TP70.1 U8.AE5
JTAG_TDI: TP72.1 U8.AE6
JTAG_TDO: TP73.1 U8.AF6
JTAG_TMS: TP71.1 U8.AD6
JTAG_TRST#: R396.1 U8.AG4
KB_BL_LED: Q31.2 U37.113
KL_NO_EC: PR9269.1 PR9271.1 R68769.2
L_SPK+: R67370.1 R69067.1 U20.42
L_SPK+_1: C602.1 CN63.4 R67370.2
L_SPK+_1_VIKI: C96927.1 CN64.4 R69067.2
L_SPK-: R67369.1 R69066.1 U20.43
L_SPK-_1: C601.1 CN63.3 R67369.2
L_SPK-_1_VIKI: C96926.1 CN64.3 R69066.2
LAN_DIS#: Q6619.3 R67504.2 R68927.1 U6539.DT41
LAN_JTAG_TCK: R67512.2 TP13161.1 U6521.35
LAN_JTAG_TDI: R67509.2 TP13158.1 U6521.32
LAN_JTAG_TDO: R67510.2 TP13159.1 U6521.34
LAN_JTAG_TMS: R67511.2 TP13160.1 U6521.33
LAN_WAKE#: R36.1 R67505.2 U6539.DM41
LAN_XTAL1: C638.2 R511.2 Y4.1
LANPWR#: R67508.1 U37.16
LANWAKEB: Q6618.1(S) R68924.1 R68925.2 U6521.2
LED0: TP13153.1 U6521.26
LED1/EESK: TP13154.1 U6521.27
LED2/EEDO: TP13152.1 U6521.25
LID#: C841.1 CN4.6 D3.1(CATHODE) D13091.2 HE1.1 R25315.2 R25370.2 R67864.1
LID#_C: C6572.1 D65.1 R25315.1 U37.118
LID_OPEN_GMR: R67864.2 U6525.4
LINE1-L: C589.1 U20.22
LINE1-R: C594.1 U20.21
LINE1-VREFO-L: R476.1 U20.31
LINE1-VREFO-R: R477.1 U20.30
LTE_BODY_SAR_ODL: CN49.14 R67886.2
LTE_OFF_ODL: CN49.10 U37.31
M.2_BT_PCMCLK: R69030.2 U6539.DL53
M.2_BT_PCMIN: R69031.2 U6539.DG50
M.2_UART_BT_WAKE: R69032.2 R69033.1
M_A_A0: JDIM1.144 U6539.BV41
M_A_A1: JDIM1.133 U6539.CE52
M_A_A2: JDIM1.132 U6539.BV47
M_A_A3: JDIM1.131 U6539.CD53
M_A_A4: JDIM1.128 U6539.CD51
M_A_A5: JDIM1.126 U6539.BY50
M_A_A6: JDIM1.127 U6539.BY52
M_A_A7: JDIM1.122 U6539.CA50
M_A_A8: JDIM1.125 U6539.BY53
M_A_A9: JDIM1.121 U6539.BU50
M_A_A10: JDIM1.146 U6539.BV42
M_A_A11: JDIM1.120 U6539.BT51
M_A_A12: JDIM1.119 U6539.BU53
M_A_A13: JDIM1.158 U6539.CF41
M_A_ACT#: JDIM1.114 U6539.BT53
M_A_ALERT#: JDIM1.116 U6539.AU50
M_A_BG#0: JDIM1.115 U6539.BL52
M_A_BG#1: JDIM1.113 U6539.BN50
M_A_BS#0: JDIM1.150 U6539.BV44
M_A_BS#1: JDIM1.145 U6539.CB42
M_A_CAS#: JDIM1.156 U6539.CB44
M_A_CB0: JDIM1.92 R233.2
M_A_CB1: JDIM1.91 R234.2
M_A_CB2: JDIM1.101 R235.2
M_A_CB3: JDIM1.105 R236.2
M_A_CB4: JDIM1.88 R237.2
M_A_CB5: JDIM1.87 R238.2
M_A_CB6: JDIM1.100 R239.2
M_A_CB7: JDIM1.104 R240.2
M_A_CKE0: JDIM1.109 U6539.BL50
M_A_CKE1: JDIM1.110 U6539.BU52
M_A_CLKN0: JDIM1.139 U6539.CC53
M_A_CLKN1: JDIM1.140 U6539.BT41
M_A_CLKP0: JDIM1.137 U6539.CC52
M_A_CLKP1: JDIM1.138 U6539.BT42
M_A_CS#0: JDIM1.149 U6539.CF47
M_A_CS#1: JDIM1.157 U6539.CF42
M_A_DIM0_ODT0: JDIM1.155 U6539.CF45
M_A_DIM0_ODT1: JDIM1.161 U6539.CF44
M_A_DQ0: JDIM1.203 U6539.CU49
M_A_DQ1: JDIM1.204 U6539.CU50
M_A_DQ2: JDIM1.207 U6539.CU52
M_A_DQ3: JDIM1.208 U6539.CU53
M_A_DQ4: JDIM1.190 U6539.CP49
M_A_DQ5: JDIM1.194 U6539.CP50
M_A_DQ6: JDIM1.195 U6539.CP52
M_A_DQ7: JDIM1.191 U6539.CP53
M_A_DQ8: JDIM1.187 U6539.CL49
M_A_DQ9: JDIM1.170 U6539.CL50
M_A_DQ10: JDIM1.173 U6539.CL52
